  43995,  -20.1499825,   60.5122337,   2.72727275
  43996,  -20.4765663,   59.8609924,   2.72727275
  43997,  -20.7821064,   59.1996231,   2.72727275
  43998,  -21.0662899,   58.5287971,   2.72727275
  43999,   -21.328825,    57.849205,   2.72727275
  44000,  -21.5694485,   57.1615486,   2.72727275
  44001,  -21.7879066,   56.4665375,   2.72727275
  44002,  -21.9839745,   55.7648773,   2.72727275
  44003,  -22.1574516,   55.0572929,   2.72727275
  44004,  -22.3081627,   54.3445129,   2.72727275
  44005,  -22.4359493,   53.6272697,   2.72727275
  44006,  -22.5406818,   52.9062996,   2.72727275
  44007,  -22.6222553,   52.1823425,   2.72727275
  44008,  -22.6805763,   51.4561424,   2.72727275
  44009,  -22.7155952,   50.7284431,   2.72727275
  44010,   22.7155952,   50.7284431,   3.63636374
  44011,   22.6805763,   51.4561424,   3.63636374
  44012,   22.6222553,   52.1823425,   3.63636374
  44013,   22.5406818,   52.9062996,   3.63636374
  44014,   22.4359493,   53.6272697,   3.63636374
  44015,   22.3081627,   54.3445129,   3.63636374
  44016,   22.1574516,   55.0572929,   3.63636374
  44017,   21.9839745,   55.7648773,   3.63636374
  44018,   21.7879066,   56.4665375,   3.63636374
  44019,   21.5694485,   57.1615486,   3.63636374
  44020,    21.328825,    57.849205,   3.63636374
  44021,   21.0662899,   58.5287971,   3.63636374
  44022,   20.7821064,   59.1996231,   3.63636374
  44023,   20.4765663,   59.8609924,   3.63636374
  44024,   20.1499825,   60.5122337,   3.63636374
  44025,   19.8026981,   61.1526718,   3.63636374
  44026,   19.4350624,   61.7816505,   3.63636374
  44027,   19.0474567,   62.3985214,   3.63636374
  44028,   18.6402779,   63.0026512,   3.63636374
  44029,   18.2139454,   63.5934219,   3.63636374
  44030,    17.768898,   64.1702194,   3.63636374
  44031,   17.3055897,     64.73246,   3.63636374
  44032,   16.8244991,   65.2795639,   3.63636374
  44033,   16.3261223,   65.8109665,   3.63636374
  44034,   15.8109665,   66.3261185,   3.63636374
  44035,   15.2795658,    66.824501,   3.63636374
  44036,   14.7324638,   67.3055878,   3.63636374
  44037,   14.1702242,    67.768898,   3.63636374
  44038,     13.59342,   68.2139435,   3.63636374
  44039,   13.0026512,   68.6402817,   3.63636374
  44040,   12.3985195,   69.0474548,   3.63636374
  44041,   11.7816515,   69.4350662,   3.63636374
  44042,   11.1526709,   69.8026962,   3.63636374
  44043,   10.5122337,   70.1499863,   3.63636374
  44044,   9.86099339,   70.4765625,   3.63636374
  44045,   9.19962025,   70.7821045,   3.63636374
  44046,   8.52879429,   71.0662918,   3.63636374
  44047,   7.84920549,   71.3288269,   3.63636374
  44048,   7.16155005,   71.5694504,   3.63636374
  44049,   6.46653652,   71.7879028,   3.63636374
  44050,    5.7648778,   71.9839706,   3.63636374
  44051,   5.05729342,   72.1574554,   3.63636374
  44052,   4.34451485,   72.3081589,   3.63636374
  44053,   3.62727022,   72.4359512,   3.63636374
  44054,   2.90629911,   72.5406799,   3.63636374
  44055,   2.18234134,   72.6222534,   3.63636374
  44056,   1.45614135,   72.6805801,   3.63636374
  44057,  0.728444934,   72.7155991,   3.63636374
  44058,           0.,    72.727272,   3.63636374
  44059, -0.728444934,   72.7155991,   3.63636374
  44060,  -1.45614135,   72.6805801,   3.63636374
  44061,  -2.18234134,   72.6222534,   3.63636374
  44062,  -2.90629911,   72.5406799,   3.63636374
  44063,  -3.62727022,   72.4359512,   3.63636374
  44064,  -4.34451485,   72.3081589,   3.63636374
  44065,  -5.05729342,   72.1574554,   3.63636374
  44066,   -5.7648778,   71.9839706,   3.63636374
  44067,  -6.46653652,   71.7879028,   3.63636374
  44068,  -7.16155005,   71.5694504,   3.63636374
  44069,  -7.84920549,   71.3288269,   3.63636374
  44070,  -8.52879429,   71.0662918,   3.63636374
  44071,  -9.19962025,   70.7821045,   3.63636374
  44072,  -9.86099339,   70.4765625,   3.63636374
  44073,  -10.5122337,   70.1499863,   3.63636374
  44074,  -11.1526709,   69.8026962,   3.63636374
  44075,  -11.7816515,   69.4350662,   3.63636374
  44076,  -12.3985195,   69.0474548,   3.63636374
  44077,  -13.0026512,   68.6402817,   3.63636374
  44078,    -13.59342,   68.2139435,   3.63636374
  44079,  -14.1702242,    67.768898,   3.63636374
  44080,  -14.7324638,   67.3055878,   3.63636374
  44081,  -15.2795658,    66.824501,   3.63636374
  44082,  -15.8109665,   66.3261185,   3.63636374
  44083,  -16.3261223,   65.8109665,   3.63636374
  44084,  -16.8244991,   65.2795639,   3.63636374
  44085,  -17.3055897,     64.73246,   3.63636374
  44086,   -17.768898,   64.1702194,   3.63636374
  44087,  -18.2139454,   63.5934219,   3.63636374
  44088,  -18.6402779,   63.0026512,   3.63636374
  44089,  -19.0474567,   62.3985214,   3.63636374
  44090,  -19.4350624,   61.7816505,   3.63636374
  44091,  -19.8026981,   61.1526718,   3.63636374
  44092,  -20.1499825,   60.5122337,   3.63636374
  44093,  -20.4765663,   59.8609924,   3.63636374
  44094,  -20.7821064,   59.1996231,   3.63636374
  44095,  -21.0662899,   58.5287971,   3.63636374
  44096,   -21.328825,    57.849205,   3.63636374
  44097,  -21.5694485,   57.1615486,   3.63636374
  44098,  -21.7879066,   56.4665375,   3.63636374
  44099,  -21.9839745,   55.7648773,   3.63636374
  44100,  -22.1574516,   55.0572929,   3.63636374
  44101,  -22.3081627,   54.3445129,   3.63636374
  44102,  -22.4359493,   53.6272697,   3.63636374
  44103,  -22.5406818,   52.9062996,   3.63636374
  44104,  -22.6222553,   52.1823425,   3.63636374
  44105,  -22.6805763,   51.4561424,   3.63636374
  44106,  -22.7155952,   50.7284431,   3.63636374
  44107,   22.7155952,   50.7284431,    4.5454545
  44108,   22.6805763,   51.4561424,    4.5454545
  44109,   22.6222553,   52.1823425,    4.5454545
  44110,   22.5406818,   52.9062996,    4.5454545
  44111,   22.4359493,   53.6272697,    4.5454545
  44112,   22.3081627,   54.3445129,    4.5454545
  44113,   22.1574516,   55.0572929,    4.5454545
  44114,   21.9839745,   55.7648773,    4.5454545
  44115,   21.7879066,   56.4665375,    4.5454545
  44116,   21.5694485,   57.1615486,    4.5454545
  44117,    21.328825,    57.849205,    4.5454545
  44118,   21.0662899,   58.5287971,    4.5454545
  44119,   20.7821064,   59.1996231,    4.5454545
  44120,   20.4765663,   59.8609924,    4.5454545
  44121,   20.1499825,   60.5122337,    4.5454545
  44122,   19.8026981,   61.1526718,    4.5454545
  44123,   19.4350624,   61.7816505,    4.5454545
  44124,   19.0474567,   62.3985214,    4.5454545
  44125,   18.6402779,   63.0026512,    4.5454545
  44126,   18.2139454,   63.5934219,    4.5454545
  44127,    17.768898,   64.1702194,    4.5454545
  44128,   17.3055897,     64.73246,    4.5454545
  44129,   16.8244991,   65.2795639,    4.5454545
  44130,   16.3261223,   65.8109665,    4.5454545
  44131,   15.8109665,   66.3261185,    4.5454545
  44132,   15.2795658,    66.824501,    4.5454545
  44133,   14.7324638,   67.3055878,    4.5454545
  44134,   14.1702242,    67.768898,    4.5454545
  44135,     13.59342,   68.2139435,    4.5454545
  44136,   13.0026512,   68.6402817,    4.5454545
  44137,   12.3985195,   69.0474548,    4.5454545
  44138,   11.7816515,   69.4350662,    4.5454545
  44139,   11.1526709,   69.8026962,    4.5454545
  44140,   10.5122337,   70.1499863,    4.5454545
  44141,   9.86099339,   70.4765625,    4.5454545
  44142,   9.19962025,   70.7821045,    4.5454545
  44143,   8.52879429,   71.0662918,    4.5454545
  44144,   7.84920549,   71.3288269,    4.5454545
  44145,   7.16155005,   71.5694504,    4.5454545
  44146,   6.46653652,   71.7879028,    4.5454545
  44147,    5.7648778,   71.9839706,    4.5454545
  44148,   5.05729342,   72.1574554,    4.5454545
  44149,   4.34451485,   72.3081589,    4.5454545
  44150,   3.62727022,   72.4359512,    4.5454545
  44151,   2.90629911,   72.5406799,    4.5454545
  44152,   2.18234134,   72.6222534,    4.5454545
  44153,   1.45614135,   72.6805801,    4.5454545
  44154,  0.728444934,   72.7155991,    4.5454545
  44155,           0.,    72.727272,    4.5454545
  44156, -0.728444934,   72.7155991,    4.5454545
  44157,  -1.45614135,   72.6805801,    4.5454545
  44158,  -2.18234134,   72.6222534,    4.5454545
  44159,  -2.90629911,   72.5406799,    4.5454545
  44160,  -3.62727022,   72.4359512,    4.5454545
  44161,  -4.34451485,   72.3081589,    4.5454545
  44162,  -5.05729342,   72.1574554,    4.5454545
  44163,   -5.7648778,   71.9839706,    4.5454545
  44164,  -6.46653652,   71.7879028,    4.5454545
  44165,  -7.16155005,   71.5694504,    4.5454545
  44166,  -7.84920549,   71.3288269,    4.5454545
  44167,  -8.52879429,   71.0662918,    4.5454545
  44168,  -9.19962025,   70.7821045,    4.5454545
  44169,  -9.86099339,   70.4765625,    4.5454545
  44170,  -10.5122337,   70.1499863,    4.5454545
  44171,  -11.1526709,   69.8026962,    4.5454545
  44172,  -11.7816515,   69.4350662,    4.5454545
  44173,  -12.3985195,   69.0474548,    4.5454545
  44174,  -13.0026512,   68.6402817,    4.5454545
  44175,    -13.59342,   68.2139435,    4.5454545
  44176,  -14.1702242,    67.768898,    4.5454545
  44177,  -14.7324638,   67.3055878,    4.5454545
  44178,  -15.2795658,    66.824501,    4.5454545
  44179,  -15.8109665,   66.3261185,    4.5454545
  44180,  -16.3261223,   65.8109665,    4.5454545
  44181,  -16.8244991,   65.2795639,    4.5454545
  44182,  -17.3055897,     64.73246,    4.5454545
  44183,   -17.768898,   64.1702194,    4.5454545
  44184,  -18.2139454,   63.5934219,    4.5454545
  44185,  -18.6402779,   63.0026512,    4.5454545
  44186,  -19.0474567,   62.3985214,    4.5454545
  44187,  -19.4350624,   61.7816505,    4.5454545
  44188,  -19.8026981,   61.1526718,    4.5454545
  44189,  -20.1499825,   60.5122337,    4.5454545
  44190,  -20.4765663,   59.8609924,    4.5454545
  44191,  -20.7821064,   59.1996231,    4.5454545
  44192,  -21.0662899,   58.5287971,    4.5454545
  44193,   -21.328825,    57.849205,    4.5454545
  44194,  -21.5694485,   57.1615486,    4.5454545
  44195,  -21.7879066,   56.4665375,    4.5454545
  44196,  -21.9839745,   55.7648773,    4.5454545
  44197,  -22.1574516,   55.0572929,    4.5454545
  44198,  -22.3081627,   54.3445129,    4.5454545
  44199,  -22.4359493,   53.6272697,    4.5454545
  44200,  -22.5406818,   52.9062996,    4.5454545
  44201,  -22.6222553,   52.1823425,    4.5454545
  44202,  -22.6805763,   51.4561424,    4.5454545
  44203,  -22.7155952,   50.7284431,    4.5454545
  44204,   22.7155952,   50.7284431,    5.4545455
  44205,   22.6805763,   51.4561424,    5.4545455
  44206,   22.6222553,   52.1823425,    5.4545455
  44207,   22.5406818,   52.9062996,    5.4545455
  44208,   22.4359493,   53.6272697,    5.4545455
  44209,   22.3081627,   54.3445129,    5.4545455
  44210,   22.1574516,   55.0572929,    5.4545455
  44211,   21.9839745,   55.7648773,    5.4545455
  44212,   21.7879066,   56.4665375,    5.4545455
  44213,   21.5694485,   57.1615486,    5.4545455
  44214,    21.328825,    57.849205,    5.4545455
  44215,   21.0662899,   58.5287971,    5.4545455
  44216,   20.7821064,   59.1996231,    5.4545455
  44217,   20.4765663,   59.8609924,    5.4545455
  44218,   20.1499825,   60.5122337,    5.4545455
  44219,   19.8026981,   61.1526718,    5.4545455
  44220,   19.4350624,   61.7816505,    5.4545455
  44221,   19.0474567,   62.3985214,    5.4545455
  44222,   18.6402779,   63.0026512,    5.4545455
  44223,   18.2139454,   63.5934219,    5.4545455
  44224,    17.768898,   64.1702194,    5.4545455
  44225,   17.3055897,     64.73246,    5.4545455
  44226,   16.8244991,   65.2795639,    5.4545455
  44227,   16.3261223,   65.8109665,    5.4545455
  44228,   15.8109665,   66.3261185,    5.4545455
  44229,   15.2795658,    66.824501,    5.4545455
  44230,   14.7324638,   67.3055878,    5.4545455
  44231,   14.1702242,    67.768898,    5.4545455
  44232,     13.59342,   68.2139435,    5.4545455
  44233,   13.0026512,   68.6402817,    5.4545455
  44234,   12.3985195,   69.0474548,    5.4545455
  44235,   11.7816515,   69.4350662,    5.4545455
  44236,   11.1526709,   69.8026962,    5.4545455
  44237,   10.5122337,   70.1499863,    5.4545455
  44238,   9.86099339,   70.4765625,    5.4545455
  44239,   9.19962025,   70.7821045,    5.4545455
  44240,   8.52879429,   71.0662918,    5.4545455
  44241,   7.84920549,   71.3288269,    5.4545455
  44242,   7.16155005,   71.5694504,    5.4545455
  44243,   6.46653652,   71.7879028,    5.4545455
  44244,    5.7648778,   71.9839706,    5.4545455
  44245,   5.05729342,   72.1574554,    5.4545455
  44246,   4.34451485,   72.3081589,    5.4545455
  44247,   3.62727022,   72.4359512,    5.4545455
  44248,   2.90629911,   72.5406799,    5.4545455
  44249,   2.18234134,   72.6222534,    5.4545455
  44250,   1.45614135,   72.6805801,    5.4545455
  44251,  0.728444934,   72.7155991,    5.4545455
  44252,           0.,    72.727272,    5.4545455
  44253, -0.728444934,   72.7155991,    5.4545455
  44254,  -1.45614135,   72.6805801,    5.4545455
  44255,  -2.18234134,   72.6222534,    5.4545455
  44256,  -2.90629911,   72.5406799,    5.4545455
  44257,  -3.62727022,   72.4359512,    5.4545455
  44258,  -4.34451485,   72.3081589,    5.4545455
  44259,  -5.05729342,   72.1574554,    5.4545455
  44260,   -5.7648778,   71.9839706,    5.4545455
  44261,  -6.46653652,   71.7879028,    5.4545455
  44262,  -7.16155005,   71.5694504,    5.4545455
  44263,  -7.84920549,   71.3288269,    5.4545455
  44264,  -8.52879429,   71.0662918,    5.4545455
  44265,  -9.19962025,   70.7821045,    5.4545455
  44266,  -9.86099339,   70.4765625,    5.4545455
  44267,  -10.5122337,   70.1499863,    5.4545455
  44268,  -11.1526709,   69.8026962,    5.4545455
  44269,  -11.7816515,   69.4350662,    5.4545455
  44270,  -12.3985195,   69.0474548,    5.4545455
  44271,  -13.0026512,   68.6402817,    5.4545455
  44272,    -13.59342,   68.2139435,    5.4545455
  44273,  -14.1702242,    67.768898,    5.4545455
  44274,  -14.7324638,   67.3055878,    5.4545455
  44275,  -15.2795658,    66.824501,    5.4545455
  44276,  -15.8109665,   66.3261185,    5.4545455
  44277,  -16.3261223,   65.8109665,    5.4545455
  44278,  -16.8244991,   65.2795639,    5.4545455
  44279,  -17.3055897,     64.73246,    5.4545455
  44280,   -17.768898,   64.1702194,    5.4545455
  44281,  -18.2139454,   63.5934219,    5.4545455
  44282,  -18.6402779,   63.0026512,    5.4545455
  44283,  -19.0474567,   62.3985214,    5.4545455
  44284,  -19.4350624,   61.7816505,    5.4545455
  44285,  -19.8026981,   61.1526718,    5.4545455
  44286,  -20.1499825,   60.5122337,    5.4545455
  44287,  -20.4765663,   59.8609924,    5.4545455
  44288,  -20.7821064,   59.1996231,    5.4545455
  44289,  -21.0662899,   58.5287971,    5.4545455
  44290,   -21.328825,    57.849205,    5.4545455
  44291,  -21.5694485,   57.1615486,    5.4545455
  44292,  -21.7879066,   56.4665375,    5.4545455
  44293,  -21.9839745,   55.7648773,    5.4545455
  44294,  -22.1574516,   55.0572929,    5.4545455
  44295,  -22.3081627,   54.3445129,    5.4545455
  44296,  -22.4359493,   53.6272697,    5.4545455
  44297,  -22.5406818,   52.9062996,    5.4545455
  44298,  -22.6222553,   52.1823425,    5.4545455
  44299,  -22.6805763,   51.4561424,    5.4545455
  44300,  -22.7155952,   50.7284431,    5.4545455
  44301,   22.7155952,   50.7284431,   6.36363649
  44302,   22.6805763,   51.4561424,   6.36363649
  44303,   22.6222553,   52.1823425,   6.36363649
  44304,   22.5406818,   52.9062996,   6.36363649
  44305,   22.4359493,   53.6272697,   6.36363649
  44306,   22.3081627,   54.3445129,   6.36363649
  44307,   22.1574516,   55.0572929,   6.36363649
  44308,   21.9839745,   55.7648773,   6.36363649
  44309,   21.7879066,   56.4665375,   6.36363649
  44310,   21.5694485,   57.1615486,   6.36363649
  44311,    21.328825,    57.849205,   6.36363649
  44312,   21.0662899,   58.5287971,   6.36363649
  44313,   20.7821064,   59.1996231,   6.36363649
  44314,   20.4765663,   59.8609924,   6.36363649
  44315,   20.1499825,   60.5122337,   6.36363649
  44316,   19.8026981,   61.1526718,   6.36363649
  44317,   19.4350624,   61.7816505,   6.36363649
  44318,   19.0474567,   62.3985214,   6.36363649
  44319,   18.6402779,   63.0026512,   6.36363649
  44320,   18.2139454,   63.5934219,   6.36363649
  44321,    17.768898,   64.1702194,   6.36363649
  44322,   17.3055897,     64.73246,   6.36363649
  44323,   16.8244991,   65.2795639,   6.36363649
  44324,   16.3261223,   65.8109665,   6.36363649
  44325,   15.8109665,   66.3261185,   6.36363649
  44326,   15.2795658,    66.824501,   6.36363649
  44327,   14.7324638,   67.3055878,   6.36363649
  44328,   14.1702242,    67.768898,   6.36363649
  44329,     13.59342,   68.2139435,   6.36363649
  44330,   13.0026512,   68.6402817,   6.36363649
  44331,   12.3985195,   69.0474548,   6.36363649
  44332,   11.7816515,   69.4350662,   6.36363649
  44333,   11.1526709,   69.8026962,   6.36363649
  44334,   10.5122337,   70.1499863,   6.36363649
  44335,   9.86099339,   70.4765625,   6.36363649
  44336,   9.19962025,   70.7821045,   6.36363649
  44337,   8.52879429,   71.0662918,   6.36363649
  44338,   7.84920549,   71.3288269,   6.36363649
  44339,   7.16155005,   71.5694504,   6.36363649
  44340,   6.46653652,   71.7879028,   6.36363649
  44341,    5.7648778,   71.9839706,   6.36363649
  44342,   5.05729342,   72.1574554,   6.36363649
  44343,   4.34451485,   72.3081589,   6.36363649
  44344,   3.62727022,   72.4359512,   6.36363649
  44345,   2.90629911,   72.5406799,   6.36363649
  44346,   2.18234134,   72.6222534,   6.36363649
  44347,   1.45614135,   72.6805801,   6.36363649
  44348,  0.728444934,   72.7155991,   6.36363649
  44349,           0.,    72.727272,   6.36363649
  44350, -0.728444934,   72.7155991,   6.36363649
  44351,  -1.45614135,   72.6805801,   6.36363649
  44352,  -2.18234134,   72.6222534,   6.36363649
  44353,  -2.90629911,   72.5406799,   6.36363649
  44354,  -3.62727022,   72.4359512,   6.36363649
  44355,  -4.34451485,   72.3081589,   6.36363649
  44356,  -5.05729342,   72.1574554,   6.36363649
  44357,   -5.7648778,   71.9839706,   6.36363649
  44358,  -6.46653652,   71.7879028,   6.36363649
  44359,  -7.16155005,   71.5694504,   6.36363649
  44360,  -7.84920549,   71.3288269,   6.36363649
  44361,  -8.52879429,   71.0662918,   6.36363649
  44362,  -9.19962025,   70.7821045,   6.36363649
  44363,  -9.86099339,   70.4765625,   6.36363649
  44364,  -10.5122337,   70.1499863,   6.36363649
  44365,  -11.1526709,   69.8026962,   6.36363649
  44366,  -11.7816515,   69.4350662,   6.36363649
  44367,  -12.3985195,   69.0474548,   6.36363649
  44368,  -13.0026512,   68.6402817,   6.36363649
  44369,    -13.59342,   68.2139435,   6.36363649
  44370,  -14.1702242,    67.768898,   6.36363649
  44371,  -14.7324638,   67.3055878,   6.36363649
  44372,  -15.2795658,    66.824501,   6.36363649
  44373,  -15.8109665,   66.3261185,   6.36363649
  44374,  -16.3261223,   65.8109665,   6.36363649
  44375,  -16.8244991,   65.2795639,   6.36363649
  44376,  -17.3055897,     64.73246,   6.36363649
  44377,   -17.768898,   64.1702194,   6.36363649
  44378,  -18.2139454,   63.5934219,   6.36363649
  44379,  -18.6402779,   63.0026512,   6.36363649
  44380,  -19.0474567,   62.3985214,   6.36363649
  44381,  -19.4350624,   61.7816505,   6.36363649
  44382,  -19.8026981,   61.1526718,   6.36363649
  44383,  -20.1499825,   60.5122337,   6.36363649
  44384,  -20.4765663,   59.8609924,   6.36363649
  44385,  -20.7821064,   59.1996231,   6.36363649
  44386,  -21.0662899,   58.5287971,   6.36363649
  44387,   -21.328825,    57.849205,   6.36363649
  44388,  -21.5694485,   57.1615486,   6.36363649
  44389,  -21.7879066,   56.4665375,   6.36363649
  44390,  -21.9839745,   55.7648773,   6.36363649
  44391,  -22.1574516,   55.0572929,   6.36363649
  44392,  -22.3081627,   54.3445129,   6.36363649
  44393,  -22.4359493,   53.6272697,   6.36363649
  44394,  -22.5406818,   52.9062996,   6.36363649
  44395,  -22.6222553,   52.1823425,   6.36363649
  44396,  -22.6805763,   51.4561424,   6.36363649
  44397,  -22.7155952,   50.7284431,   6.36363649
  44398,   22.7155952,   50.7284431,   7.27272749
  44399,   22.6805763,   51.4561424,   7.27272749
  44400,   22.6222553,   52.1823425,   7.27272749
  44401,   22.5406818,   52.9062996,   7.27272749
  44402,   22.4359493,   53.6272697,   7.27272749
  44403,   22.3081627,   54.3445129,   7.27272749
  44404,   22.1574516,   55.0572929,   7.27272749
  44405,   21.9839745,   55.7648773,   7.27272749
  44406,   21.7879066,   56.4665375,   7.27272749
  44407,   21.5694485,   57.1615486,   7.27272749
  44408,    21.328825,    57.849205,   7.27272749
  44409,   21.0662899,   58.5287971,   7.27272749
  44410,   20.7821064,   59.1996231,   7.27272749
  44411,   20.4765663,   59.8609924,   7.27272749
  44412,   20.1499825,   60.5122337,   7.27272749
  44413,   19.8026981,   61.1526718,   7.27272749
  44414,   19.4350624,   61.7816505,   7.27272749
  44415,   19.0474567,   62.3985214,   7.27272749
  44416,   18.6402779,   63.0026512,   7.27272749
  44417,   18.2139454,   63.5934219,   7.27272749
  44418,    17.768898,   64.1702194,   7.27272749
  44419,   17.3055897,     64.73246,   7.27272749
  44420,   16.8244991,   65.2795639,   7.27272749
  44421,   16.3261223,   65.8109665,   7.27272749
  44422,   15.8109665,   66.3261185,   7.27272749
  44423,   15.2795658,    66.824501,   7.27272749
  44424,   14.7324638,   67.3055878,   7.27272749
  44425,   14.1702242,    67.768898,   7.27272749
  44426,     13.59342,   68.2139435,   7.27272749
  44427,   13.0026512,   68.6402817,   7.27272749
  44428,   12.3985195,   69.0474548,   7.27272749
  44429,   11.7816515,   69.4350662,   7.27272749
  44430,   11.1526709,   69.8026962,   7.27272749
  44431,   10.5122337,   70.1499863,   7.27272749
  44432,   9.86099339,   70.4765625,   7.27272749
  44433,   9.19962025,   70.7821045,   7.27272749
  44434,   8.52879429,   71.0662918,   7.27272749
  44435,   7.84920549,   71.3288269,   7.27272749
  44436,   7.16155005,   71.5694504,   7.27272749
  44437,   6.46653652,   71.7879028,   7.27272749
  44438,    5.7648778,   71.9839706,   7.27272749
  44439,   5.05729342,   72.1574554,   7.27272749
  44440,   4.34451485,   72.3081589,   7.27272749
  44441,   3.62727022,   72.4359512,   7.27272749
  44442,   2.90629911,   72.5406799,   7.27272749
  44443,   2.18234134,   72.6222534,   7.27272749
  44444,   1.45614135,   72.6805801,   7.27272749
  44445,  0.728444934,   72.7155991,   7.27272749
  44446,           0.,    72.727272,   7.27272749
  44447, -0.728444934,   72.7155991,   7.27272749
  44448,  -1.45614135,   72.6805801,   7.27272749
  44449,  -2.18234134,   72.6222534,   7.27272749
  44450,  -2.90629911,   72.5406799,   7.27272749
  44451,  -3.62727022,   72.4359512,   7.27272749
  44452,  -4.34451485,   72.3081589,   7.27272749
  44453,  -5.05729342,   72.1574554,   7.27272749
  44454,   -5.7648778,   71.9839706,   7.27272749
  44455,  -6.46653652,   71.7879028,   7.27272749
  44456,  -7.16155005,   71.5694504,   7.27272749
  44457,  -7.84920549,   71.3288269,   7.27272749
  44458,  -8.52879429,   71.0662918,   7.27272749
  44459,  -9.19962025,   70.7821045,   7.27272749
  44460,  -9.86099339,   70.4765625,   7.27272749
  44461,  -10.5122337,   70.1499863,   7.27272749
  44462,  -11.1526709,   69.8026962,   7.27272749
  44463,  -11.7816515,   69.4350662,   7.27272749
  44464,  -12.3985195,   69.0474548,   7.27272749
  44465,  -13.0026512,   68.6402817,   7.27272749
  44466,    -13.59342,   68.2139435,   7.27272749
  44467,  -14.1702242,    67.768898,   7.27272749
  44468,  -14.7324638,   67.3055878,   7.27272749
  44469,  -15.2795658,    66.824501,   7.27272749
  44470,  -15.8109665,   66.3261185,   7.27272749
  44471,  -16.3261223,   65.8109665,   7.27272749
  44472,  -16.8244991,   65.2795639,   7.27272749
  44473,  -17.3055897,     64.73246,   7.27272749
  44474,   -17.768898,   64.1702194,   7.27272749
  44475,  -18.2139454,   63.5934219,   7.27272749
  44476,  -18.6402779,   63.0026512,   7.27272749
  44477,  -19.0474567,   62.3985214,   7.27272749
  44478,  -19.4350624,   61.7816505,   7.27272749
  44479,  -19.8026981,   61.1526718,   7.27272749
  44480,  -20.1499825,   60.5122337,   7.27272749
  44481,  -20.4765663,   59.8609924,   7.27272749
  44482,  -20.7821064,   59.1996231,   7.27272749
  44483,  -21.0662899,   58.5287971,   7.27272749
  44484,   -21.328825,    57.849205,   7.27272749
  44485,  -21.5694485,   57.1615486,   7.27272749
  44486,  -21.7879066,   56.4665375,   7.27272749
  44487,  -21.9839745,   55.7648773,   7.27272749
  44488,  -22.1574516,   55.0572929,   7.27272749
  44489,  -22.3081627,   54.3445129,   7.27272749
  44490,  -22.4359493,   53.6272697,   7.27272749
  44491,  -22.5406818,   52.9062996,   7.27272749
  44492,  -22.6222553,   52.1823425,   7.27272749
  44493,  -22.6805763,   51.4561424,   7.27272749
  44494,  -22.7155952,   50.7284431,   7.27272749
  44495,   22.7155952,   50.7284431,   8.18181801
  44496,   22.6805763,   51.4561424,   8.18181801
  44497,   22.6222553,   52.1823425,   8.18181801
  44498,   22.5406818,   52.9062996,   8.18181801
  44499,   22.4359493,   53.6272697,   8.18181801
  44500,   22.3081627,   54.3445129,   8.18181801
  44501,   22.1574516,   55.0572929,   8.18181801
  44502,   21.9839745,   55.7648773,   8.18181801
  44503,   21.7879066,   56.4665375,   8.18181801
  44504,   21.5694485,   57.1615486,   8.18181801
  44505,    21.328825,    57.849205,   8.18181801
  44506,   21.0662899,   58.5287971,   8.18181801
  44507,   20.7821064,   59.1996231,   8.18181801
  44508,   20.4765663,   59.8609924,   8.18181801
  44509,   20.1499825,   60.5122337,   8.18181801
  44510,   19.8026981,   61.1526718,   8.18181801
  44511,   19.4350624,   61.7816505,   8.18181801
  44512,   19.0474567,   62.3985214,   8.18181801
  44513,   18.6402779,   63.0026512,   8.18181801
  44514,   18.2139454,   63.5934219,   8.18181801
  44515,    17.768898,   64.1702194,   8.18181801
  44516,   17.3055897,     64.73246,   8.18181801
  44517,   16.8244991,   65.2795639,   8.18181801
  44518,   16.3261223,   65.8109665,   8.18181801
  44519,   15.8109665,   66.3261185,   8.18181801
  44520,   15.2795658,    66.824501,   8.18181801
  44521,   14.7324638,   67.3055878,   8.18181801
  44522,   14.1702242,    67.768898,   8.18181801
  44523,     13.59342,   68.2139435,   8.18181801
  44524,   13.0026512,   68.6402817,   8.18181801
  44525,   12.3985195,   69.0474548,   8.18181801
  44526,   11.7816515,   69.4350662,   8.18181801
  44527,   11.1526709,   69.8026962,   8.18181801
  44528,   10.5122337,   70.1499863,   8.18181801
  44529,   9.86099339,   70.4765625,   8.18181801
  44530,   9.19962025,   70.7821045,   8.18181801
  44531,   8.52879429,   71.0662918,   8.18181801
  44532,   7.84920549,   71.3288269,   8.18181801
  44533,   7.16155005,   71.5694504,   8.18181801
  44534,   6.46653652,   71.7879028,   8.18181801
  44535,    5.7648778,   71.9839706,   8.18181801
  44536,   5.05729342,   72.1574554,   8.18181801
  44537,   4.34451485,   72.3081589,   8.18181801
  44538,   3.62727022,   72.4359512,   8.18181801
  44539,   2.90629911,   72.5406799,   8.18181801
  44540,   2.18234134,   72.6222534,   8.18181801
  44541,   1.45614135,   72.6805801,   8.18181801
  44542,  0.728444934,   72.7155991,   8.18181801
  44543,           0.,    72.727272,   8.18181801
  44544, -0.728444934,   72.7155991,   8.18181801
  44545,  -1.45614135,   72.6805801,   8.18181801
  44546,  -2.18234134,   72.6222534,   8.18181801
  44547,  -2.90629911,   72.5406799,   8.18181801
  44548,  -3.62727022,   72.4359512,   8.18181801
  44549,  -4.34451485,   72.3081589,   8.18181801
  44550,  -5.05729342,   72.1574554,   8.18181801
  44551,   -5.7648778,   71.9839706,   8.18181801
  44552,  -6.46653652,   71.7879028,   8.18181801
  44553,  -7.16155005,   71.5694504,   8.18181801
  44554,  -7.84920549,   71.3288269,   8.18181801
  44555,  -8.52879429,   71.0662918,   8.18181801
  44556,  -9.19962025,   70.7821045,   8.18181801
  44557,  -9.86099339,   70.4765625,   8.18181801
  44558,  -10.5122337,   70.1499863,   8.18181801
  44559,  -11.1526709,   69.8026962,   8.18181801
  44560,  -11.7816515,   69.4350662,   8.18181801
  44561,  -12.3985195,   69.0474548,   8.18181801
  44562,  -13.0026512,   68.6402817,   8.18181801
  44563,    -13.59342,   68.2139435,   8.18181801
  44564,  -14.1702242,    67.768898,   8.18181801
  44565,  -14.7324638,   67.3055878,   8.18181801
  44566,  -15.2795658,    66.824501,   8.18181801
  44567,  -15.8109665,   66.3261185,   8.18181801
  44568,  -16.3261223,   65.8109665,   8.18181801
  44569,  -16.8244991,   65.2795639,   8.18181801
  44570,  -17.3055897,     64.73246,   8.18181801
  44571,   -17.768898,   64.1702194,   8.18181801
  44572,  -18.2139454,   63.5934219,   8.18181801
  44573,  -18.6402779,   63.0026512,   8.18181801
  44574,  -19.0474567,   62.3985214,   8.18181801
  44575,  -19.4350624,   61.7816505,   8.18181801
  44576,  -19.8026981,   61.1526718,   8.18181801
  44577,  -20.1499825,   60.5122337,   8.18181801
  44578,  -20.4765663,   59.8609924,   8.18181801
  44579,  -20.7821064,   59.1996231,   8.18181801
  44580,  -21.0662899,   58.5287971,   8.18181801
  44581,   -21.328825,    57.849205,   8.18181801
  44582,  -21.5694485,   57.1615486,   8.18181801
  44583,  -21.7879066,   56.4665375,   8.18181801
  44584,  -21.9839745,   55.7648773,   8.18181801
  44585,  -22.1574516,   55.0572929,   8.18181801
  44586,  -22.3081627,   54.3445129,   8.18181801
  44587,  -22.4359493,   53.6272697,   8.18181801
  44588,  -22.5406818,   52.9062996,   8.18181801
  44589,  -22.6222553,   52.1823425,   8.18181801
  44590,  -22.6805763,   51.4561424,   8.18181801
  44591,  -22.7155952,   50.7284431,   8.18181801
  44592,   22.7155952,   50.7284431,     9.090909
  44593,   22.6805763,   51.4561424,     9.090909
  44594,   22.6222553,   52.1823425,     9.090909
  44595,   22.5406818,   52.9062996,     9.090909
  44596,   22.4359493,   53.6272697,     9.090909
  44597,   22.3081627,   54.3445129,     9.090909
  44598,   22.1574516,   55.0572929,     9.090909
  44599,   21.9839745,   55.7648773,     9.090909
  44600,   21.7879066,   56.4665375,     9.090909
  44601,   21.5694485,   57.1615486,     9.090909
  44602,    21.328825,    57.849205,     9.090909
  44603,   21.0662899,   58.5287971,     9.090909
  44604,   20.7821064,   59.1996231,     9.090909
  44605,   20.4765663,   59.8609924,     9.090909
  44606,   20.1499825,   60.5122337,     9.090909
  44607,   19.8026981,   61.1526718,     9.090909
  44608,   19.4350624,   61.7816505,     9.090909
  44609,   19.0474567,   62.3985214,     9.090909
  44610,   18.6402779,   63.0026512,     9.090909
  44611,   18.2139454,   63.5934219,     9.090909
  44612,    17.768898,   64.1702194,     9.090909
  44613,   17.3055897,     64.73246,     9.090909
  44614,   16.8244991,   65.2795639,     9.090909
  44615,   16.3261223,   65.8109665,     9.090909
  44616,   15.8109665,   66.3261185,     9.090909
  44617,   15.2795658,    66.824501,     9.090909
  44618,   14.7324638,   67.3055878,     9.090909
  44619,   14.1702242,    67.768898,     9.090909
  44620,     13.59342,   68.2139435,     9.090909
  44621,   13.0026512,   68.6402817,     9.090909
  44622,   12.3985195,   69.0474548,     9.090909
  44623,   11.7816515,   69.4350662,     9.090909
  44624,   11.1526709,   69.8026962,     9.090909
  44625,   10.5122337,   70.1499863,     9.090909
  44626,   9.86099339,   70.4765625,     9.090909
  44627,   9.19962025,   70.7821045,     9.090909
  44628,   8.52879429,   71.0662918,     9.090909
  44629,   7.84920549,   71.3288269,     9.090909
  44630,   7.16155005,   71.5694504,     9.090909
  44631,   6.46653652,   71.7879028,     9.090909
  44632,    5.7648778,   71.9839706,     9.090909
  44633,   5.05729342,   72.1574554,     9.090909
  44634,   4.34451485,   72.3081589,     9.090909
  44635,   3.62727022,   72.4359512,     9.090909
  44636,   2.90629911,   72.5406799,     9.090909
  44637,   2.18234134,   72.6222534,     9.090909
  44638,   1.45614135,   72.6805801,     9.090909
  44639,  0.728444934,   72.7155991,     9.090909
  44640,           0.,    72.727272,     9.090909
  44641, -0.728444934,   72.7155991,     9.090909
  44642,  -1.45614135,   72.6805801,     9.090909
  44643,  -2.18234134,   72.6222534,     9.090909
  44644,  -2.90629911,   72.5406799,     9.090909
  44645,  -3.62727022,   72.4359512,     9.090909
  44646,  -4.34451485,   72.3081589,     9.090909
  44647,  -5.05729342,   72.1574554,     9.090909
  44648,   -5.7648778,   71.9839706,     9.090909
  44649,  -6.46653652,   71.7879028,     9.090909
  44650,  -7.16155005,   71.5694504,     9.090909
  44651,  -7.84920549,   71.3288269,     9.090909
  44652,  -8.52879429,   71.0662918,     9.090909
  44653,  -9.19962025,   70.7821045,     9.090909
  44654,  -9.86099339,   70.4765625,     9.090909
  44655,  -10.5122337,   70.1499863,     9.090909
  44656,  -11.1526709,   69.8026962,     9.090909
  44657,  -11.7816515,   69.4350662,     9.090909
  44658,  -12.3985195,   69.0474548,     9.090909
  44659,  -13.0026512,   68.6402817,     9.090909
  44660,    -13.59342,   68.2139435,     9.090909
  44661,  -14.1702242,    67.768898,     9.090909
  44662,  -14.7324638,   67.3055878,     9.090909
  44663,  -15.2795658,    66.824501,     9.090909
  44664,  -15.8109665,   66.3261185,     9.090909
  44665,  -16.3261223,   65.8109665,     9.090909
  44666,  -16.8244991,   65.2795639,     9.090909
  44667,  -17.3055897,     64.73246,     9.090909
  44668,   -17.768898,   64.1702194,     9.090909
  44669,  -18.2139454,   63.5934219,     9.090909
  44670,  -18.6402779,   63.0026512,     9.090909
  44671,  -19.0474567,   62.3985214,     9.090909
  44672,  -19.4350624,   61.7816505,     9.090909
  44673,  -19.8026981,   61.1526718,     9.090909
  44674,  -20.1499825,   60.5122337,     9.090909
  44675,  -20.4765663,   59.8609924,     9.090909
  44676,  -20.7821064,   59.1996231,     9.090909
  44677,  -21.0662899,   58.5287971,     9.090909
  44678,   -21.328825,    57.849205,     9.090909
  44679,  -21.5694485,   57.1615486,     9.090909
  44680,  -21.7879066,   56.4665375,     9.090909
  44681,  -21.9839745,   55.7648773,     9.090909
  44682,  -22.1574516,   55.0572929,     9.090909
  44683,  -22.3081627,   54.3445129,     9.090909
  44684,  -22.4359493,   53.6272697,     9.090909
  44685,  -22.5406818,   52.9062996,     9.090909
  44686,  -22.6222553,   52.1823425,     9.090909
  44687,  -22.6805763,   51.4561424,     9.090909
  44688,  -22.7155952,   50.7284431,     9.090909
  44689,   21.8069725,   50.6993065,  0.909090936
  44690,   21.7733536,   51.3978958,  0.909090936
  44691,   21.7173653,    52.095047,  0.909090936
  44692,   21.6390553,   52.7900467,  0.909090936
  44693,   21.5385113,   53.4821777,  0.909090936
  44694,   21.4158363,   54.1707344,  0.909090936
  44695,   21.2711544,   54.8550034,  0.909090936
  44696,   21.1046143,   55.5342827,  0.909090936
  44697,   20.9163895,   56.2078743,  0.909090936
  44698,   20.7066708,   56.8750877,  0.909090936
  44699,   20.4756737,   57.5352364,  0.909090936
  44700,   20.2236385,    58.187645,  0.909090936
  44701,   19.9508228,   58.8316383,  0.909090936
  44702,    19.657505,   59.4665527,  0.909090936
  44703,   19.3439827,   60.0917435,  0.909090936
  44704,   19.0105896,   60.7065659,  0.909090936
  44705,   18.6576595,   61.3103828,  0.909090936
  44706,   18.2855587,   61.9025803,  0.909090936
  44707,   17.8946667,   62.4825439,  0.909090936
  44708,   17.4853878,   63.0496826,  0.909090936
  44709,   17.0581417,   63.6034126,  0.909090936
  44710,   16.6133671,   64.1431656,  0.909090936
  44711,   16.1515198,   64.6683807,  0.909090936
  44712,   15.6730766,   65.1785278,  0.909090936
  44713,   15.1785278,   65.6730804,  0.909090936
  44714,   14.6683826,   66.1515198,  0.909090936
  44715,   14.1431646,   66.6133652,  0.909090936
  44716,   13.6034145,   67.0581436,  0.909090936
  44717,   13.0496836,   67.4853897,  0.909090936
  44718,   12.4825449,   67.8946686,  0.909090936
  44719,   11.9025784,   68.2855606,  0.909090936
  44720,   11.3103848,   68.6576614,  0.909090936
  44721,   10.7065639,   69.0105896,  0.909090936
  44722,   10.0917444,   69.3439865,  0.909090936
  44723,   9.46655369,   69.6575012,  0.909090936
  44724,   8.83163548,   69.9508209,  0.909090936
  44725,   8.18764305,   70.2236404,  0.909090936
  44726,   7.53523684,   70.4756775,  0.909090936
  44727,   6.87508774,   70.7066727,  0.909090936
  44728,   6.20787525,   70.9163895,  0.909090936
  44729,   5.53428268,   71.1046143,  0.909090936
  44730,    4.8550024,   71.2711563,  0.909090936
  44731,   4.17073441,   71.4158325,  0.909090936
  44732,    3.4821794,   71.5385132,  0.909090936
  44733,   2.79004717,   71.6390533,  0.909090936
  44734,   2.09504771,   71.7173615,  0.909090936
  44735,   1.39789569,   71.7733536,  0.909090936
  44736,  0.699307203,   71.8069687,  0.909090936
  44737,           0.,   71.8181839,  0.909090936
  44738, -0.699307203,   71.8069687,  0.909090936
  44739,  -1.39789569,   71.7733536,  0.909090936
  44740,  -2.09504771,   71.7173615,  0.909090936
  44741,  -2.79004717,   71.6390533,  0.909090936
  44742,   -3.4821794,   71.5385132,  0.909090936
  44743,  -4.17073441,   71.4158325,  0.909090936
  44744,   -4.8550024,   71.2711563,  0.909090936
  44745,  -5.53428268,   71.1046143,  0.909090936
  44746,  -6.20787525,   70.9163895,  0.909090936
  44747,  -6.87508774,   70.7066727,  0.909090936
  44748,  -7.53523684,   70.4756775,  0.909090936
  44749,  -8.18764305,   70.2236404,  0.909090936
  44750,  -8.83163548,   69.9508209,  0.909090936
  44751,  -9.46655369,   69.6575012,  0.909090936
  44752,  -10.0917444,   69.3439865,  0.909090936
  44753,  -10.7065639,   69.0105896,  0.909090936
  44754,  -11.3103848,   68.6576614,  0.909090936
  44755,  -11.9025784,   68.2855606,  0.909090936
  44756,  -12.4825449,   67.8946686,  0.909090936
  44757,  -13.0496836,   67.4853897,  0.909090936
  44758,  -13.6034145,   67.0581436,  0.909090936
  44759,  -14.1431646,   66.6133652,  0.909090936
  44760,  -14.6683826,   66.1515198,  0.909090936
  44761,  -15.1785278,   65.6730804,  0.909090936
  44762,  -15.6730766,   65.1785278,  0.909090936
  44763,  -16.1515198,   64.6683807,  0.909090936
  44764,  -16.6133671,   64.1431656,  0.909090936
  44765,  -17.0581417,   63.6034126,  0.909090936
  44766,  -17.4853878,   63.0496826,  0.909090936
  44767,  -17.8946667,   62.4825439,  0.909090936
  44768,  -18.2855587,   61.9025803,  0.909090936
  44769,  -18.6576595,   61.3103828,  0.909090936
  44770,  -19.0105896,   60.7065659,  0.909090936
  44771,  -19.3439827,   60.0917435,  0.909090936
  44772,   -19.657505,   59.4665527,  0.909090936
  44773,  -19.9508228,   58.8316383,  0.909090936
  44774,  -20.2236385,    58.187645,  0.909090936
  44775,  -20.4756737,   57.5352364,  0.909090936
  44776,  -20.7066708,   56.8750877,  0.909090936
  44777,  -20.9163895,   56.2078743,  0.909090936
  44778,  -21.1046143,   55.5342827,  0.909090936
  44779,  -21.2711544,   54.8550034,  0.909090936
  44780,  -21.4158363,   54.1707344,  0.909090936
  44781,  -21.5385113,   53.4821777,  0.909090936
  44782,  -21.6390553,   52.7900467,  0.909090936
  44783,  -21.7173653,    52.095047,  0.909090936
  44784,  -21.7733536,   51.3978958,  0.909090936
  44785,  -21.8069725,   50.6993065,  0.909090936
  44786,   21.8069725,   50.6993065,   1.81818187
  44787,   21.7733536,   51.3978958,   1.81818187
  44788,   21.7173653,    52.095047,   1.81818187
  44789,   21.6390553,   52.7900467,   1.81818187
  44790,   21.5385113,   53.4821777,   1.81818187
  44791,   21.4158363,   54.1707344,   1.81818187
  44792,   21.2711544,   54.8550034,   1.81818187
  44793,   21.1046143,   55.5342827,   1.81818187
  44794,   20.9163895,   56.2078743,   1.81818187
  44795,   20.7066708,   56.8750877,   1.81818187
  44796,   20.4756737,   57.5352364,   1.81818187
  44797,   20.2236385,    58.187645,   1.81818187
  44798,   19.9508228,   58.8316383,   1.81818187
  44799,    19.657505,   59.4665527,   1.81818187
  44800,   19.3439827,   60.0917435,   1.81818187
  44801,   19.0105896,   60.7065659,   1.81818187
  44802,   18.6576595,   61.3103828,   1.81818187
  44803,   18.2855587,   61.9025803,   1.81818187
  44804,   17.8946667,   62.4825439,   1.81818187
  44805,   17.4853878,   63.0496826,   1.81818187
  44806,   17.0581417,   63.6034126,   1.81818187
  44807,   16.6133671,   64.1431656,   1.81818187
  44808,   16.1515198,   64.6683807,   1.81818187
  44809,   15.6730766,   65.1785278,   1.81818187
  44810,   15.1785278,   65.6730804,   1.81818187
  44811,   14.6683826,   66.1515198,   1.81818187
  44812,   14.1431646,   66.6133652,   1.81818187
  44813,   13.6034145,   67.0581436,   1.81818187
  44814,   13.0496836,   67.4853897,   1.81818187
  44815,   12.4825449,   67.8946686,   1.81818187
  44816,   11.9025784,   68.2855606,   1.81818187
  44817,   11.3103848,   68.6576614,   1.81818187
  44818,   10.7065639,   69.0105896,   1.81818187
  44819,   10.0917444,   69.3439865,   1.81818187
  44820,   9.46655369,   69.6575012,   1.81818187
  44821,   8.83163548,   69.9508209,   1.81818187
  44822,   8.18764305,   70.2236404,   1.81818187
  44823,   7.53523684,   70.4756775,   1.81818187
  44824,   6.87508774,   70.7066727,   1.81818187
  44825,   6.20787525,   70.9163895,   1.81818187
  44826,   5.53428268,   71.1046143,   1.81818187
  44827,    4.8550024,   71.2711563,   1.81818187
  44828,   4.17073441,   71.4158325,   1.81818187
  44829,    3.4821794,   71.5385132,   1.81818187
  44830,   2.79004717,   71.6390533,   1.81818187
  44831,   2.09504771,   71.7173615,   1.81818187
  44832,   1.39789569,   71.7733536,   1.81818187
  44833,  0.699307203,   71.8069687,   1.81818187
  44834,           0.,   71.8181839,   1.81818187
  44835, -0.699307203,   71.8069687,   1.81818187
  44836,  -1.39789569,   71.7733536,   1.81818187
  44837,  -2.09504771,   71.7173615,   1.81818187
  44838,  -2.79004717,   71.6390533,   1.81818187
  44839,   -3.4821794,   71.5385132,   1.81818187
  44840,  -4.17073441,   71.4158325,   1.81818187
  44841,   -4.8550024,   71.2711563,   1.81818187
  44842,  -5.53428268,   71.1046143,   1.81818187
  44843,  -6.20787525,   70.9163895,   1.81818187
  44844,  -6.87508774,   70.7066727,   1.81818187
  44845,  -7.53523684,   70.4756775,   1.81818187
  44846,  -8.18764305,   70.2236404,   1.81818187
  44847,  -8.83163548,   69.9508209,   1.81818187
  44848,  -9.46655369,   69.6575012,   1.81818187
  44849,  -10.0917444,   69.3439865,   1.81818187
  44850,  -10.7065639,   69.0105896,   1.81818187
  44851,  -11.3103848,   68.6576614,   1.81818187
  44852,  -11.9025784,   68.2855606,   1.81818187
  44853,  -12.4825449,   67.8946686,   1.81818187
  44854,  -13.0496836,   67.4853897,   1.81818187
  44855,  -13.6034145,   67.0581436,   1.81818187
  44856,  -14.1431646,   66.6133652,   1.81818187
  44857,  -14.6683826,   66.1515198,   1.81818187
  44858,  -15.1785278,   65.6730804,   1.81818187
  44859,  -15.6730766,   65.1785278,   1.81818187
  44860,  -16.1515198,   64.6683807,   1.81818187
  44861,  -16.6133671,   64.1431656,   1.81818187
  44862,  -17.0581417,   63.6034126,   1.81818187
  44863,  -17.4853878,   63.0496826,   1.81818187
  44864,  -17.8946667,   62.4825439,   1.81818187
  44865,  -18.2855587,   61.9025803,   1.81818187
  44866,  -18.6576595,   61.3103828,   1.81818187
  44867,  -19.0105896,   60.7065659,   1.81818187
  44868,  -19.3439827,   60.0917435,   1.81818187
  44869,   -19.657505,   59.4665527,   1.81818187
  44870,  -19.9508228,   58.8316383,   1.81818187
  44871,  -20.2236385,    58.187645,   1.81818187
  44872,  -20.4756737,   57.5352364,   1.81818187
  44873,  -20.7066708,   56.8750877,   1.81818187
  44874,  -20.9163895,   56.2078743,   1.81818187
  44875,  -21.1046143,   55.5342827,   1.81818187
  44876,  -21.2711544,   54.8550034,   1.81818187
  44877,  -21.4158363,   54.1707344,   1.81818187
  44878,  -21.5385113,   53.4821777,   1.81818187
  44879,  -21.6390553,   52.7900467,   1.81818187
  44880,  -21.7173653,    52.095047,   1.81818187
  44881,  -21.7733536,   51.3978958,   1.81818187
  44882,  -21.8069725,   50.6993065,   1.81818187
  44883,   21.8069725,   50.6993065,   2.72727275
  44884,   21.7733536,   51.3978958,   2.72727275
  44885,   21.7173653,    52.095047,   2.72727275
  44886,   21.6390553,   52.7900467,   2.72727275
  44887,   21.5385113,   53.4821777,   2.72727275
  44888,   21.4158363,   54.1707344,   2.72727275
  44889,   21.2711544,   54.8550034,   2.72727275
  44890,   21.1046143,   55.5342827,   2.72727275
  44891,   20.9163895,   56.2078743,   2.72727275
  44892,   20.7066708,   56.8750877,   2.72727275
  44893,   20.4756737,   57.5352364,   2.72727275
  44894,   20.2236385,    58.187645,   2.72727275
  44895,   19.9508228,   58.8316383,   2.72727275
  44896,    19.657505,   59.4665527,   2.72727275
  44897,   19.3439827,   60.0917435,   2.72727275
  44898,   19.0105896,   60.7065659,   2.72727275
  44899,   18.6576595,   61.3103828,   2.72727275
  44900,   18.2855587,   61.9025803,   2.72727275
  44901,   17.8946667,   62.4825439,   2.72727275
  44902,   17.4853878,   63.0496826,   2.72727275
  44903,   17.0581417,   63.6034126,   2.72727275
  44904,   16.6133671,   64.1431656,   2.72727275
  44905,   16.1515198,   64.6683807,   2.72727275
  44906,   15.6730766,   65.1785278,   2.72727275
  44907,   15.1785278,   65.6730804,   2.72727275
  44908,   14.6683826,   66.1515198,   2.72727275
  44909,   14.1431646,   66.6133652,   2.72727275
  44910,   13.6034145,   67.0581436,   2.72727275
  44911,   13.0496836,   67.4853897,   2.72727275
  44912,   12.4825449,   67.8946686,   2.72727275
  44913,   11.9025784,   68.2855606,   2.72727275
  44914,   11.3103848,   68.6576614,   2.72727275
  44915,   10.7065639,   69.0105896,   2.72727275
  44916,   10.0917444,   69.3439865,   2.72727275
  44917,   9.46655369,   69.6575012,   2.72727275
  44918,   8.83163548,   69.9508209,   2.72727275
  44919,   8.18764305,   70.2236404,   2.72727275
  44920,   7.53523684,   70.4756775,   2.72727275
  44921,   6.87508774,   70.7066727,   2.72727275
  44922,   6.20787525,   70.9163895,   2.72727275
  44923,   5.53428268,   71.1046143,   2.72727275
  44924,    4.8550024,   71.2711563,   2.72727275
  44925,   4.17073441,   71.4158325,   2.72727275
  44926,    3.4821794,   71.5385132,   2.72727275
  44927,   2.79004717,   71.6390533,   2.72727275
  44928,   2.09504771,   71.7173615,   2.72727275
  44929,   1.39789569,   71.7733536,   2.72727275
  44930,  0.699307203,   71.8069687,   2.72727275
  44931,           0.,   71.8181839,   2.72727275
  44932, -0.699307203,   71.8069687,   2.72727275
  44933,  -1.39789569,   71.7733536,   2.72727275
  44934,  -2.09504771,   71.7173615,   2.72727275
  44935,  -2.79004717,   71.6390533,   2.72727275
  44936,   -3.4821794,   71.5385132,   2.72727275
  44937,  -4.17073441,   71.4158325,   2.72727275
  44938,   -4.8550024,   71.2711563,   2.72727275
  44939,  -5.53428268,   71.1046143,   2.72727275
  44940,  -6.20787525,   70.9163895,   2.72727275
  44941,  -6.87508774,   70.7066727,   2.72727275
  44942,  -7.53523684,   70.4756775,   2.72727275
  44943,  -8.18764305,   70.2236404,   2.72727275
  44944,  -8.83163548,   69.9508209,   2.72727275
  44945,  -9.46655369,   69.6575012,   2.72727275
  44946,  -10.0917444,   69.3439865,   2.72727275
  44947,  -10.7065639,   69.0105896,   2.72727275
  44948,  -11.3103848,   68.6576614,   2.72727275
  44949,  -11.9025784,   68.2855606,   2.72727275
  44950,  -12.4825449,   67.8946686,   2.72727275
  44951,  -13.0496836,   67.4853897,   2.72727275
  44952,  -13.6034145,   67.0581436,   2.72727275
  44953,  -14.1431646,   66.6133652,   2.72727275
  44954,  -14.6683826,   66.1515198,   2.72727275
  44955,  -15.1785278,   65.6730804,   2.72727275
  44956,  -15.6730766,   65.1785278,   2.72727275
  44957,  -16.1515198,   64.6683807,   2.72727275
  44958,  -16.6133671,   64.1431656,   2.72727275
  44959,  -17.0581417,   63.6034126,   2.72727275
  44960,  -17.4853878,   63.0496826,   2.72727275
  44961,  -17.8946667,   62.4825439,   2.72727275
  44962,  -18.2855587,   61.9025803,   2.72727275
  44963,  -18.6576595,   61.3103828,   2.72727275
  44964,  -19.0105896,   60.7065659,   2.72727275
  44965,  -19.3439827,   60.0917435,   2.72727275
  44966,   -19.657505,   59.4665527,   2.72727275
  44967,  -19.9508228,   58.8316383,   2.72727275
  44968,  -20.2236385,    58.187645,   2.72727275
  44969,  -20.4756737,   57.5352364,   2.72727275
  44970,  -20.7066708,   56.8750877,   2.72727275
  44971,  -20.9163895,   56.2078743,   2.72727275
  44972,  -21.1046143,   55.5342827,   2.72727275
  44973,  -21.2711544,   54.8550034,   2.72727275
  44974,  -21.4158363,   54.1707344,   2.72727275
  44975,  -21.5385113,   53.4821777,   2.72727275
  44976,  -21.6390553,   52.7900467,   2.72727275
  44977,  -21.7173653,    52.095047,   2.72727275
  44978,  -21.7733536,   51.3978958,   2.72727275
  44979,  -21.8069725,   50.6993065,   2.72727275
  44980,   21.8069725,   50.6993065,   3.63636374
  44981,   21.7733536,   51.3978958,   3.63636374
  44982,   21.7173653,    52.095047,   3.63636374
  44983,   21.6390553,   52.7900467,   3.63636374
  44984,   21.5385113,   53.4821777,   3.63636374
  44985,   21.4158363,   54.1707344,   3.63636374
  44986,   21.2711544,   54.8550034,   3.63636374
  44987,   21.1046143,   55.5342827,   3.63636374
  44988,   20.9163895,   56.2078743,   3.63636374
  44989,   20.7066708,   56.8750877,   3.63636374
  44990,   20.4756737,   57.5352364,   3.63636374
  44991,   20.2236385,    58.187645,   3.63636374
  44992,   19.9508228,   58.8316383,   3.63636374
  44993,    19.657505,   59.4665527,   3.63636374
  44994,   19.3439827,   60.0917435,   3.63636374
  44995,   19.0105896,   60.7065659,   3.63636374
  44996,   18.6576595,   61.3103828,   3.63636374
  44997,   18.2855587,   61.9025803,   3.63636374
  44998,   17.8946667,   62.4825439,   3.63636374
  44999,   17.4853878,   63.0496826,   3.63636374
  45000,   17.0581417,   63.6034126,   3.63636374
  45001,   16.6133671,   64.1431656,   3.63636374
  45002,   16.1515198,   64.6683807,   3.63636374
  45003,   15.6730766,   65.1785278,   3.63636374
  45004,   15.1785278,   65.6730804,   3.63636374
  45005,   14.6683826,   66.1515198,   3.63636374
  45006,   14.1431646,   66.6133652,   3.63636374
  45007,   13.6034145,   67.0581436,   3.63636374
  45008,   13.0496836,   67.4853897,   3.63636374
  45009,   12.4825449,   67.8946686,   3.63636374
  45010,   11.9025784,   68.2855606,   3.63636374
  45011,   11.3103848,   68.6576614,   3.63636374
  45012,   10.7065639,   69.0105896,   3.63636374
  45013,   10.0917444,   69.3439865,   3.63636374
  45014,   9.46655369,   69.6575012,   3.63636374
  45015,   8.83163548,   69.9508209,   3.63636374
  45016,   8.18764305,   70.2236404,   3.63636374
  45017,   7.53523684,   70.4756775,   3.63636374
  45018,   6.87508774,   70.7066727,   3.63636374
  45019,   6.20787525,   70.9163895,   3.63636374
  45020,   5.53428268,   71.1046143,   3.63636374
  45021,    4.8550024,   71.2711563,   3.63636374
  45022,   4.17073441,   71.4158325,   3.63636374
  45023,    3.4821794,   71.5385132,   3.63636374
  45024,   2.79004717,   71.6390533,   3.63636374
  45025,   2.09504771,   71.7173615,   3.63636374
  45026,   1.39789569,   71.7733536,   3.63636374
  45027,  0.699307203,   71.8069687,   3.63636374
  45028,           0.,   71.8181839,   3.63636374
  45029, -0.699307203,   71.8069687,   3.63636374
  45030,  -1.39789569,   71.7733536,   3.63636374
  45031,  -2.09504771,   71.7173615,   3.63636374
  45032,  -2.79004717,   71.6390533,   3.63636374
  45033,   -3.4821794,   71.5385132,   3.63636374
  45034,  -4.17073441,   71.4158325,   3.63636374
  45035,   -4.8550024,   71.2711563,   3.63636374
  45036,  -5.53428268,   71.1046143,   3.63636374
  45037,  -6.20787525,   70.9163895,   3.63636374
  45038,  -6.87508774,   70.7066727,   3.63636374
  45039,  -7.53523684,   70.4756775,   3.63636374
  45040,  -8.18764305,   70.2236404,   3.63636374
  45041,  -8.83163548,   69.9508209,   3.63636374
  45042,  -9.46655369,   69.6575012,   3.63636374
  45043,  -10.0917444,   69.3439865,   3.63636374
  45044,  -10.7065639,   69.0105896,   3.63636374
  45045,  -11.3103848,   68.6576614,   3.63636374
  45046,  -11.9025784,   68.2855606,   3.63636374
  45047,  -12.4825449,   67.8946686,   3.63636374
  45048,  -13.0496836,   67.4853897,   3.63636374
  45049,  -13.6034145,   67.0581436,   3.63636374
  45050,  -14.1431646,   66.6133652,   3.63636374
  45051,  -14.6683826,   66.1515198,   3.63636374
  45052,  -15.1785278,   65.6730804,   3.63636374
  45053,  -15.6730766,   65.1785278,   3.63636374
  45054,  -16.1515198,   64.6683807,   3.63636374
  45055,  -16.6133671,   64.1431656,   3.63636374
  45056,  -17.0581417,   63.6034126,   3.63636374
  45057,  -17.4853878,   63.0496826,   3.63636374
  45058,  -17.8946667,   62.4825439,   3.63636374
  45059,  -18.2855587,   61.9025803,   3.63636374
  45060,  -18.6576595,   61.3103828,   3.63636374
  45061,  -19.0105896,   60.7065659,   3.63636374
  45062,  -19.3439827,   60.0917435,   3.63636374
  45063,   -19.657505,   59.4665527,   3.63636374
  45064,  -19.9508228,   58.8316383,   3.63636374
  45065,  -20.2236385,    58.187645,   3.63636374
  45066,  -20.4756737,   57.5352364,   3.63636374
  45067,  -20.7066708,   56.8750877,   3.63636374
  45068,  -20.9163895,   56.2078743,   3.63636374
  45069,  -21.1046143,   55.5342827,   3.63636374
  45070,  -21.2711544,   54.8550034,   3.63636374
  45071,  -21.4158363,   54.1707344,   3.63636374
  45072,  -21.5385113,   53.4821777,   3.63636374
  45073,  -21.6390553,   52.7900467,   3.63636374
  45074,  -21.7173653,    52.095047,   3.63636374
  45075,  -21.7733536,   51.3978958,   3.63636374
  45076,  -21.8069725,   50.6993065,   3.63636374
  45077,   21.8069725,   50.6993065,    4.5454545
  45078,   21.7733536,   51.3978958,    4.5454545
  45079,   21.7173653,    52.095047,    4.5454545
  45080,   21.6390553,   52.7900467,    4.5454545
  45081,   21.5385113,   53.4821777,    4.5454545
  45082,   21.4158363,   54.1707344,    4.5454545
  45083,   21.2711544,   54.8550034,    4.5454545
  45084,   21.1046143,   55.5342827,    4.5454545
  45085,   20.9163895,   56.2078743,    4.5454545
  45086,   20.7066708,   56.8750877,    4.5454545
  45087,   20.4756737,   57.5352364,    4.5454545
  45088,   20.2236385,    58.187645,    4.5454545
  45089,   19.9508228,   58.8316383,    4.5454545
  45090,    19.657505,   59.4665527,    4.5454545
  45091,   19.3439827,   60.0917435,    4.5454545
  45092,   19.0105896,   60.7065659,    4.5454545
  45093,   18.6576595,   61.3103828,    4.5454545
  45094,   18.2855587,   61.9025803,    4.5454545
  45095,   17.8946667,   62.4825439,    4.5454545
  45096,   17.4853878,   63.0496826,    4.5454545
  45097,   17.0581417,   63.6034126,    4.5454545
  45098,   16.6133671,   64.1431656,    4.5454545
  45099,   16.1515198,   64.6683807,    4.5454545
  45100,   15.6730766,   65.1785278,    4.5454545
  45101,   15.1785278,   65.6730804,    4.5454545
  45102,   14.6683826,   66.1515198,    4.5454545
  45103,   14.1431646,   66.6133652,    4.5454545
  45104,   13.6034145,   67.0581436,    4.5454545
  45105,   13.0496836,   67.4853897,    4.5454545
  45106,   12.4825449,   67.8946686,    4.5454545
  45107,   11.9025784,   68.2855606,    4.5454545
  45108,   11.3103848,   68.6576614,    4.5454545
  45109,   10.7065639,   69.0105896,    4.5454545
  45110,   10.0917444,   69.3439865,    4.5454545
  45111,   9.46655369,   69.6575012,    4.5454545
  45112,   8.83163548,   69.9508209,    4.5454545
  45113,   8.18764305,   70.2236404,    4.5454545
  45114,   7.53523684,   70.4756775,    4.5454545
  45115,   6.87508774,   70.7066727,    4.5454545
  45116,   6.20787525,   70.9163895,    4.5454545
  45117,   5.53428268,   71.1046143,    4.5454545
  45118,    4.8550024,   71.2711563,    4.5454545
  45119,   4.17073441,   71.4158325,    4.5454545
  45120,    3.4821794,   71.5385132,    4.5454545
  45121,   2.79004717,   71.6390533,    4.5454545
  45122,   2.09504771,   71.7173615,    4.5454545
  45123,   1.39789569,   71.7733536,    4.5454545
  45124,  0.699307203,   71.8069687,    4.5454545
  45125,           0.,   71.8181839,    4.5454545
  45126, -0.699307203,   71.8069687,    4.5454545
  45127,  -1.39789569,   71.7733536,    4.5454545
  45128,  -2.09504771,   71.7173615,    4.5454545
  45129,  -2.79004717,   71.6390533,    4.5454545
  45130,   -3.4821794,   71.5385132,    4.5454545
  45131,  -4.17073441,   71.4158325,    4.5454545
  45132,   -4.8550024,   71.2711563,    4.5454545
  45133,  -5.53428268,   71.1046143,    4.5454545
  45134,  -6.20787525,   70.9163895,    4.5454545
  45135,  -6.87508774,   70.7066727,    4.5454545
  45136,  -7.53523684,   70.4756775,    4.5454545
  45137,  -8.18764305,   70.2236404,    4.5454545
  45138,  -8.83163548,   69.9508209,    4.5454545
  45139,  -9.46655369,   69.6575012,    4.5454545
  45140,  -10.0917444,   69.3439865,    4.5454545
  45141,  -10.7065639,   69.0105896,    4.5454545
  45142,  -11.3103848,   68.6576614,    4.5454545
  45143,  -11.9025784,   68.2855606,    4.5454545
  45144,  -12.4825449,   67.8946686,    4.5454545
  45145,  -13.0496836,   67.4853897,    4.5454545
  45146,  -13.6034145,   67.0581436,    4.5454545
  45147,  -14.1431646,   66.6133652,    4.5454545
  45148,  -14.6683826,   66.1515198,    4.5454545
  45149,  -15.1785278,   65.6730804,    4.5454545
  45150,  -15.6730766,   65.1785278,    4.5454545
  45151,  -16.1515198,   64.6683807,    4.5454545
  45152,  -16.6133671,   64.1431656,    4.5454545
  45153,  -17.0581417,   63.6034126,    4.5454545
  45154,  -17.4853878,   63.0496826,    4.5454545
  45155,  -17.8946667,   62.4825439,    4.5454545
  45156,  -18.2855587,   61.9025803,    4.5454545
  45157,  -18.6576595,   61.3103828,    4.5454545
  45158,  -19.0105896,   60.7065659,    4.5454545
  45159,  -19.3439827,   60.0917435,    4.5454545
  45160,   -19.657505,   59.4665527,    4.5454545
  45161,  -19.9508228,   58.8316383,    4.5454545
  45162,  -20.2236385,    58.187645,    4.5454545
  45163,  -20.4756737,   57.5352364,    4.5454545
  45164,  -20.7066708,   56.8750877,    4.5454545
  45165,  -20.9163895,   56.2078743,    4.5454545
  45166,  -21.1046143,   55.5342827,    4.5454545
  45167,  -21.2711544,   54.8550034,    4.5454545
  45168,  -21.4158363,   54.1707344,    4.5454545
  45169,  -21.5385113,   53.4821777,    4.5454545
  45170,  -21.6390553,   52.7900467,    4.5454545
  45171,  -21.7173653,    52.095047,    4.5454545
  45172,  -21.7733536,   51.3978958,    4.5454545
  45173,  -21.8069725,   50.6993065,    4.5454545
  45174,   21.8069725,   50.6993065,    5.4545455
  45175,   21.7733536,   51.3978958,    5.4545455
  45176,   21.7173653,    52.095047,    5.4545455
  45177,   21.6390553,   52.7900467,    5.4545455
  45178,   21.5385113,   53.4821777,    5.4545455
  45179,   21.4158363,   54.1707344,    5.4545455
  45180,   21.2711544,   54.8550034,    5.4545455
  45181,   21.1046143,   55.5342827,    5.4545455
  45182,   20.9163895,   56.2078743,    5.4545455
  45183,   20.7066708,   56.8750877,    5.4545455
  45184,   20.4756737,   57.5352364,    5.4545455
  45185,   20.2236385,    58.187645,    5.4545455
  45186,   19.9508228,   58.8316383,    5.4545455
  45187,    19.657505,   59.4665527,    5.4545455
  45188,   19.3439827,   60.0917435,    5.4545455
  45189,   19.0105896,   60.7065659,    5.4545455
  45190,   18.6576595,   61.3103828,    5.4545455
  45191,   18.2855587,   61.9025803,    5.4545455
  45192,   17.8946667,   62.4825439,    5.4545455
  45193,   17.4853878,   63.0496826,    5.4545455
  45194,   17.0581417,   63.6034126,    5.4545455
  45195,   16.6133671,   64.1431656,    5.4545455
  45196,   16.1515198,   64.6683807,    5.4545455
  45197,   15.6730766,   65.1785278,    5.4545455
  45198,   15.1785278,   65.6730804,    5.4545455
  45199,   14.6683826,   66.1515198,    5.4545455
  45200,   14.1431646,   66.6133652,    5.4545455
  45201,   13.6034145,   67.0581436,    5.4545455
  45202,   13.0496836,   67.4853897,    5.4545455
  45203,   12.4825449,   67.8946686,    5.4545455
  45204,   11.9025784,   68.2855606,    5.4545455
  45205,   11.3103848,   68.6576614,    5.4545455
  45206,   10.7065639,   69.0105896,    5.4545455
  45207,   10.0917444,   69.3439865,    5.4545455
  45208,   9.46655369,   69.6575012,    5.4545455
  45209,   8.83163548,   69.9508209,    5.4545455
  45210,   8.18764305,   70.2236404,    5.4545455
  45211,   7.53523684,   70.4756775,    5.4545455
  45212,   6.87508774,   70.7066727,    5.4545455
  45213,   6.20787525,   70.9163895,    5.4545455
  45214,   5.53428268,   71.1046143,    5.4545455
  45215,    4.8550024,   71.2711563,    5.4545455
  45216,   4.17073441,   71.4158325,    5.4545455
  45217,    3.4821794,   71.5385132,    5.4545455
  45218,   2.79004717,   71.6390533,    5.4545455
  45219,   2.09504771,   71.7173615,    5.4545455
  45220,   1.39789569,   71.7733536,    5.4545455
  45221,  0.699307203,   71.8069687,    5.4545455
  45222,           0.,   71.8181839,    5.4545455
  45223, -0.699307203,   71.8069687,    5.4545455
  45224,  -1.39789569,   71.7733536,    5.4545455
  45225,  -2.09504771,   71.7173615,    5.4545455
  45226,  -2.79004717,   71.6390533,    5.4545455
  45227,   -3.4821794,   71.5385132,    5.4545455
  45228,  -4.17073441,   71.4158325,    5.4545455
  45229,   -4.8550024,   71.2711563,    5.4545455
  45230,  -5.53428268,   71.1046143,    5.4545455
  45231,  -6.20787525,   70.9163895,    5.4545455
  45232,  -6.87508774,   70.7066727,    5.4545455
  45233,  -7.53523684,   70.4756775,    5.4545455
  45234,  -8.18764305,   70.2236404,    5.4545455
  45235,  -8.83163548,   69.9508209,    5.4545455
  45236,  -9.46655369,   69.6575012,    5.4545455
  45237,  -10.0917444,   69.3439865,    5.4545455
  45238,  -10.7065639,   69.0105896,    5.4545455
  45239,  -11.3103848,   68.6576614,    5.4545455
  45240,  -11.9025784,   68.2855606,    5.4545455
  45241,  -12.4825449,   67.8946686,    5.4545455
  45242,  -13.0496836,   67.4853897,    5.4545455
  45243,  -13.6034145,   67.0581436,    5.4545455
  45244,  -14.1431646,   66.6133652,    5.4545455
  45245,  -14.6683826,   66.1515198,    5.4545455
  45246,  -15.1785278,   65.6730804,    5.4545455
  45247,  -15.6730766,   65.1785278,    5.4545455
  45248,  -16.1515198,   64.6683807,    5.4545455
  45249,  -16.6133671,   64.1431656,    5.4545455
  45250,  -17.0581417,   63.6034126,    5.4545455
  45251,  -17.4853878,   63.0496826,    5.4545455
  45252,  -17.8946667,   62.4825439,    5.4545455
  45253,  -18.2855587,   61.9025803,    5.4545455
  45254,  -18.6576595,   61.3103828,    5.4545455
  45255,  -19.0105896,   60.7065659,    5.4545455
  45256,  -19.3439827,   60.0917435,    5.4545455
  45257,   -19.657505,   59.4665527,    5.4545455
  45258,  -19.9508228,   58.8316383,    5.4545455
  45259,  -20.2236385,    58.187645,    5.4545455
  45260,  -20.4756737,   57.5352364,    5.4545455
  45261,  -20.7066708,   56.8750877,    5.4545455
  45262,  -20.9163895,   56.2078743,    5.4545455
  45263,  -21.1046143,   55.5342827,    5.4545455
  45264,  -21.2711544,   54.8550034,    5.4545455
  45265,  -21.4158363,   54.1707344,    5.4545455
  45266,  -21.5385113,   53.4821777,    5.4545455
  45267,  -21.6390553,   52.7900467,    5.4545455
  45268,  -21.7173653,    52.095047,    5.4545455
  45269,  -21.7733536,   51.3978958,    5.4545455
  45270,  -21.8069725,   50.6993065,    5.4545455
  45271,   21.8069725,   50.6993065,   6.36363649
  45272,   21.7733536,   51.3978958,   6.36363649
  45273,   21.7173653,    52.095047,   6.36363649
  45274,   21.6390553,   52.7900467,   6.36363649
  45275,   21.5385113,   53.4821777,   6.36363649
  45276,   21.4158363,   54.1707344,   6.36363649
  45277,   21.2711544,   54.8550034,   6.36363649
  45278,   21.1046143,   55.5342827,   6.36363649
  45279,   20.9163895,   56.2078743,   6.36363649
  45280,   20.7066708,   56.8750877,   6.36363649
  45281,   20.4756737,   57.5352364,   6.36363649
  45282,   20.2236385,    58.187645,   6.36363649
  45283,   19.9508228,   58.8316383,   6.36363649
  45284,    19.657505,   59.4665527,   6.36363649
  45285,   19.3439827,   60.0917435,   6.36363649
  45286,   19.0105896,   60.7065659,   6.36363649
  45287,   18.6576595,   61.3103828,   6.36363649
  45288,   18.2855587,   61.9025803,   6.36363649
  45289,   17.8946667,   62.4825439,   6.36363649
  45290,   17.4853878,   63.0496826,   6.36363649
  45291,   17.0581417,   63.6034126,   6.36363649
  45292,   16.6133671,   64.1431656,   6.36363649
  45293,   16.1515198,   64.6683807,   6.36363649
  45294,   15.6730766,   65.1785278,   6.36363649
  45295,   15.1785278,   65.6730804,   6.36363649
  45296,   14.6683826,   66.1515198,   6.36363649
  45297,   14.1431646,   66.6133652,   6.36363649
  45298,   13.6034145,   67.0581436,   6.36363649
  45299,   13.0496836,   67.4853897,   6.36363649
  45300,   12.4825449,   67.8946686,   6.36363649
  45301,   11.9025784,   68.2855606,   6.36363649
  45302,   11.3103848,   68.6576614,   6.36363649
  45303,   10.7065639,   69.0105896,   6.36363649
  45304,   10.0917444,   69.3439865,   6.36363649
  45305,   9.46655369,   69.6575012,   6.36363649
  45306,   8.83163548,   69.9508209,   6.36363649
  45307,   8.18764305,   70.2236404,   6.36363649
  45308,   7.53523684,   70.4756775,   6.36363649
  45309,   6.87508774,   70.7066727,   6.36363649
  45310,   6.20787525,   70.9163895,   6.36363649
  45311,   5.53428268,   71.1046143,   6.36363649
  45312,    4.8550024,   71.2711563,   6.36363649
  45313,   4.17073441,   71.4158325,   6.36363649
  45314,    3.4821794,   71.5385132,   6.36363649
  45315,   2.79004717,   71.6390533,   6.36363649
  45316,   2.09504771,   71.7173615,   6.36363649
  45317,   1.39789569,   71.7733536,   6.36363649
  45318,  0.699307203,   71.8069687,   6.36363649
  45319,           0.,   71.8181839,   6.36363649
  45320, -0.699307203,   71.8069687,   6.36363649
  45321,  -1.39789569,   71.7733536,   6.36363649
  45322,  -2.09504771,   71.7173615,   6.36363649
  45323,  -2.79004717,   71.6390533,   6.36363649
  45324,   -3.4821794,   71.5385132,   6.36363649
  45325,  -4.17073441,   71.4158325,   6.36363649
  45326,   -4.8550024,   71.2711563,   6.36363649
  45327,  -5.53428268,   71.1046143,   6.36363649
  45328,  -6.20787525,   70.9163895,   6.36363649
  45329,  -6.87508774,   70.7066727,   6.36363649
  45330,  -7.53523684,   70.4756775,   6.36363649
  45331,  -8.18764305,   70.2236404,   6.36363649
  45332,  -8.83163548,   69.9508209,   6.36363649
  45333,  -9.46655369,   69.6575012,   6.36363649
  45334,  -10.0917444,   69.3439865,   6.36363649
  45335,  -10.7065639,   69.0105896,   6.36363649
  45336,  -11.3103848,   68.6576614,   6.36363649
  45337,  -11.9025784,   68.2855606,   6.36363649
  45338,  -12.4825449,   67.8946686,   6.36363649
  45339,  -13.0496836,   67.4853897,   6.36363649
  45340,  -13.6034145,   67.0581436,   6.36363649
  45341,  -14.1431646,   66.6133652,   6.36363649
  45342,  -14.6683826,   66.1515198,   6.36363649
  45343,  -15.1785278,   65.6730804,   6.36363649
  45344,  -15.6730766,   65.1785278,   6.36363649
  45345,  -16.1515198,   64.6683807,   6.36363649
  45346,  -16.6133671,   64.1431656,   6.36363649
  45347,  -17.0581417,   63.6034126,   6.36363649
  45348,  -17.4853878,   63.0496826,   6.36363649
  45349,  -17.8946667,   62.4825439,   6.36363649
  45350,  -18.2855587,   61.9025803,   6.36363649
  45351,  -18.6576595,   61.3103828,   6.36363649
  45352,  -19.0105896,   60.7065659,   6.36363649
  45353,  -19.3439827,   60.0917435,   6.36363649
  45354,   -19.657505,   59.4665527,   6.36363649
  45355,  -19.9508228,   58.8316383,   6.36363649
  45356,  -20.2236385,    58.187645,   6.36363649
  45357,  -20.4756737,   57.5352364,   6.36363649
  45358,  -20.7066708,   56.8750877,   6.36363649
  45359,  -20.9163895,   56.2078743,   6.36363649
  45360,  -21.1046143,   55.5342827,   6.36363649
  45361,  -21.2711544,   54.8550034,   6.36363649
  45362,  -21.4158363,   54.1707344,   6.36363649
  45363,  -21.5385113,   53.4821777,   6.36363649
  45364,  -21.6390553,   52.7900467,   6.36363649
  45365,  -21.7173653,    52.095047,   6.36363649
  45366,  -21.7733536,   51.3978958,   6.36363649
  45367,  -21.8069725,   50.6993065,   6.36363649
  45368,   21.8069725,   50.6993065,   7.27272749
  45369,   21.7733536,   51.3978958,   7.27272749
  45370,   21.7173653,    52.095047,   7.27272749
  45371,   21.6390553,   52.7900467,   7.27272749
  45372,   21.5385113,   53.4821777,   7.27272749
  45373,   21.4158363,   54.1707344,   7.27272749
  45374,   21.2711544,   54.8550034,   7.27272749
  45375,   21.1046143,   55.5342827,   7.27272749
  45376,   20.9163895,   56.2078743,   7.27272749
  45377,   20.7066708,   56.8750877,   7.27272749
  45378,   20.4756737,   57.5352364,   7.27272749
  45379,   20.2236385,    58.187645,   7.27272749
  45380,   19.9508228,   58.8316383,   7.27272749
  45381,    19.657505,   59.4665527,   7.27272749
  45382,   19.3439827,   60.0917435,   7.27272749
  45383,   19.0105896,   60.7065659,   7.27272749
  45384,   18.6576595,   61.3103828,   7.27272749
  45385,   18.2855587,   61.9025803,   7.27272749
  45386,   17.8946667,   62.4825439,   7.27272749
  45387,   17.4853878,   63.0496826,   7.27272749
  45388,   17.0581417,   63.6034126,   7.27272749
  45389,   16.6133671,   64.1431656,   7.27272749
  45390,   16.1515198,   64.6683807,   7.27272749
  45391,   15.6730766,   65.1785278,   7.27272749
  45392,   15.1785278,   65.6730804,   7.27272749
  45393,   14.6683826,   66.1515198,   7.27272749
  45394,   14.1431646,   66.6133652,   7.27272749
  45395,   13.6034145,   67.0581436,   7.27272749
  45396,   13.0496836,   67.4853897,   7.27272749
  45397,   12.4825449,   67.8946686,   7.27272749
  45398,   11.9025784,   68.2855606,   7.27272749
  45399,   11.3103848,   68.6576614,   7.27272749
  45400,   10.7065639,   69.0105896,   7.27272749
  45401,   10.0917444,   69.3439865,   7.27272749
  45402,   9.46655369,   69.6575012,   7.27272749
  45403,   8.83163548,   69.9508209,   7.27272749
  45404,   8.18764305,   70.2236404,   7.27272749
  45405,   7.53523684,   70.4756775,   7.27272749
  45406,   6.87508774,   70.7066727,   7.27272749
  45407,   6.20787525,   70.9163895,   7.27272749
  45408,   5.53428268,   71.1046143,   7.27272749
  45409,    4.8550024,   71.2711563,   7.27272749
  45410,   4.17073441,   71.4158325,   7.27272749
  45411,    3.4821794,   71.5385132,   7.27272749
  45412,   2.79004717,   71.6390533,   7.27272749
  45413,   2.09504771,   71.7173615,   7.27272749
  45414,   1.39789569,   71.7733536,   7.27272749
  45415,  0.699307203,   71.8069687,   7.27272749
  45416,           0.,   71.8181839,   7.27272749
  45417, -0.699307203,   71.8069687,   7.27272749
  45418,  -1.39789569,   71.7733536,   7.27272749
  45419,  -2.09504771,   71.7173615,   7.27272749
  45420,  -2.79004717,   71.6390533,   7.27272749
  45421,   -3.4821794,   71.5385132,   7.27272749
  45422,  -4.17073441,   71.4158325,   7.27272749
  45423,   -4.8550024,   71.2711563,   7.27272749
  45424,  -5.53428268,   71.1046143,   7.27272749
  45425,  -6.20787525,   70.9163895,   7.27272749
  45426,  -6.87508774,   70.7066727,   7.27272749
  45427,  -7.53523684,   70.4756775,   7.27272749
  45428,  -8.18764305,   70.2236404,   7.27272749
  45429,  -8.83163548,   69.9508209,   7.27272749
  45430,  -9.46655369,   69.6575012,   7.27272749
  45431,  -10.0917444,   69.3439865,   7.27272749
  45432,  -10.7065639,   69.0105896,   7.27272749
  45433,  -11.3103848,   68.6576614,   7.27272749
  45434,  -11.9025784,   68.2855606,   7.27272749
  45435,  -12.4825449,   67.8946686,   7.27272749
  45436,  -13.0496836,   67.4853897,   7.27272749
  45437,  -13.6034145,   67.0581436,   7.27272749
  45438,  -14.1431646,   66.6133652,   7.27272749
  45439,  -14.6683826,   66.1515198,   7.27272749
  45440,  -15.1785278,   65.6730804,   7.27272749
  45441,  -15.6730766,   65.1785278,   7.27272749
  45442,  -16.1515198,   64.6683807,   7.27272749
  45443,  -16.6133671,   64.1431656,   7.27272749
  45444,  -17.0581417,   63.6034126,   7.27272749
  45445,  -17.4853878,   63.0496826,   7.27272749
  45446,  -17.8946667,   62.4825439,   7.27272749
  45447,  -18.2855587,   61.9025803,   7.27272749
  45448,  -18.6576595,   61.3103828,   7.27272749
  45449,  -19.0105896,   60.7065659,   7.27272749
  45450,  -19.3439827,   60.0917435,   7.27272749
  45451,   -19.657505,   59.4665527,   7.27272749
  45452,  -19.9508228,   58.8316383,   7.27272749
  45453,  -20.2236385,    58.187645,   7.27272749
  45454,  -20.4756737,   57.5352364,   7.27272749
  45455,  -20.7066708,   56.8750877,   7.27272749
  45456,  -20.9163895,   56.2078743,   7.27272749
  45457,  -21.1046143,   55.5342827,   7.27272749
  45458,  -21.2711544,   54.8550034,   7.27272749
  45459,  -21.4158363,   54.1707344,   7.27272749
  45460,  -21.5385113,   53.4821777,   7.27272749
  45461,  -21.6390553,   52.7900467,   7.27272749
  45462,  -21.7173653,    52.095047,   7.27272749
  45463,  -21.7733536,   51.3978958,   7.27272749
  45464,  -21.8069725,   50.6993065,   7.27272749
  45465,   21.8069725,   50.6993065,   8.18181801
  45466,   21.7733536,   51.3978958,   8.18181801
  45467,   21.7173653,    52.095047,   8.18181801
  45468,   21.6390553,   52.7900467,   8.18181801
  45469,   21.5385113,   53.4821777,   8.18181801
  45470,   21.4158363,   54.1707344,   8.18181801
  45471,   21.2711544,   54.8550034,   8.18181801
  45472,   21.1046143,   55.5342827,   8.18181801
  45473,   20.9163895,   56.2078743,   8.18181801
  45474,   20.7066708,   56.8750877,   8.18181801
  45475,   20.4756737,   57.5352364,   8.18181801
  45476,   20.2236385,    58.187645,   8.18181801
  45477,   19.9508228,   58.8316383,   8.18181801
  45478,    19.657505,   59.4665527,   8.18181801
  45479,   19.3439827,   60.0917435,   8.18181801
  45480,   19.0105896,   60.7065659,   8.18181801
  45481,   18.6576595,   61.3103828,   8.18181801
  45482,   18.2855587,   61.9025803,   8.18181801
  45483,   17.8946667,   62.4825439,   8.18181801
  45484,   17.4853878,   63.0496826,   8.18181801
  45485,   17.0581417,   63.6034126,   8.18181801
  45486,   16.6133671,   64.1431656,   8.18181801
  45487,   16.1515198,   64.6683807,   8.18181801
  45488,   15.6730766,   65.1785278,   8.18181801
  45489,   15.1785278,   65.6730804,   8.18181801
  45490,   14.6683826,   66.1515198,   8.18181801
  45491,   14.1431646,   66.6133652,   8.18181801
  45492,   13.6034145,   67.0581436,   8.18181801
  45493,   13.0496836,   67.4853897,   8.18181801
  45494,   12.4825449,   67.8946686,   8.18181801
  45495,   11.9025784,   68.2855606,   8.18181801
  45496,   11.3103848,   68.6576614,   8.18181801
  45497,   10.7065639,   69.0105896,   8.18181801
  45498,   10.0917444,   69.3439865,   8.18181801
  45499,   9.46655369,   69.6575012,   8.18181801
  45500,   8.83163548,   69.9508209,   8.18181801
  45501,   8.18764305,   70.2236404,   8.18181801
  45502,   7.53523684,   70.4756775,   8.18181801
  45503,   6.87508774,   70.7066727,   8.18181801
  45504,   6.20787525,   70.9163895,   8.18181801
  45505,   5.53428268,   71.1046143,   8.18181801
  45506,    4.8550024,   71.2711563,   8.18181801
  45507,   4.17073441,   71.4158325,   8.18181801
  45508,    3.4821794,   71.5385132,   8.18181801
  45509,   2.79004717,   71.6390533,   8.18181801
  45510,   2.09504771,   71.7173615,   8.18181801
  45511,   1.39789569,   71.7733536,   8.18181801
  45512,  0.699307203,   71.8069687,   8.18181801
  45513,           0.,   71.8181839,   8.18181801
  45514, -0.699307203,   71.8069687,   8.18181801
  45515,  -1.39789569,   71.7733536,   8.18181801
  45516,  -2.09504771,   71.7173615,   8.18181801
  45517,  -2.79004717,   71.6390533,   8.18181801
  45518,   -3.4821794,   71.5385132,   8.18181801
  45519,  -4.17073441,   71.4158325,   8.18181801
  45520,   -4.8550024,   71.2711563,   8.18181801
  45521,  -5.53428268,   71.1046143,   8.18181801
  45522,  -6.20787525,   70.9163895,   8.18181801
  45523,  -6.87508774,   70.7066727,   8.18181801
  45524,  -7.53523684,   70.4756775,   8.18181801
  45525,  -8.18764305,   70.2236404,   8.18181801
  45526,  -8.83163548,   69.9508209,   8.18181801
  45527,  -9.46655369,   69.6575012,   8.18181801
  45528,  -10.0917444,   69.3439865,   8.18181801
  45529,  -10.7065639,   69.0105896,   8.18181801
  45530,  -11.3103848,   68.6576614,   8.18181801
  45531,  -11.9025784,   68.2855606,   8.18181801
  45532,  -12.4825449,   67.8946686,   8.18181801
  45533,  -13.0496836,   67.4853897,   8.18181801
  45534,  -13.6034145,   67.0581436,   8.18181801
  45535,  -14.1431646,   66.6133652,   8.18181801
  45536,  -14.6683826,   66.1515198,   8.18181801
  45537,  -15.1785278,   65.6730804,   8.18181801
  45538,  -15.6730766,   65.1785278,   8.18181801
  45539,  -16.1515198,   64.6683807,   8.18181801
  45540,  -16.6133671,   64.1431656,   8.18181801
  45541,  -17.0581417,   63.6034126,   8.18181801
  45542,  -17.4853878,   63.0496826,   8.18181801
  45543,  -17.8946667,   62.4825439,   8.18181801
  45544,  -18.2855587,   61.9025803,   8.18181801
  45545,  -18.6576595,   61.3103828,   8.18181801
  45546,  -19.0105896,   60.7065659,   8.18181801
  45547,  -19.3439827,   60.0917435,   8.18181801
  45548,   -19.657505,   59.4665527,   8.18181801
  45549,  -19.9508228,   58.8316383,   8.18181801
  45550,  -20.2236385,    58.187645,   8.18181801
  45551,  -20.4756737,   57.5352364,   8.18181801
  45552,  -20.7066708,   56.8750877,   8.18181801
  45553,  -20.9163895,   56.2078743,   8.18181801
  45554,  -21.1046143,   55.5342827,   8.18181801
  45555,  -21.2711544,   54.8550034,   8.18181801
  45556,  -21.4158363,   54.1707344,   8.18181801
  45557,  -21.5385113,   53.4821777,   8.18181801
  45558,  -21.6390553,   52.7900467,   8.18181801
  45559,  -21.7173653,    52.095047,   8.18181801
  45560,  -21.7733536,   51.3978958,   8.18181801
  45561,  -21.8069725,   50.6993065,   8.18181801
  45562,   21.8069725,   50.6993065,     9.090909
  45563,   21.7733536,   51.3978958,     9.090909
  45564,   21.7173653,    52.095047,     9.090909
  45565,   21.6390553,   52.7900467,     9.090909
  45566,   21.5385113,   53.4821777,     9.090909
  45567,   21.4158363,   54.1707344,     9.090909
  45568,   21.2711544,   54.8550034,     9.090909
  45569,   21.1046143,   55.5342827,     9.090909
  45570,   20.9163895,   56.2078743,     9.090909
  45571,   20.7066708,   56.8750877,     9.090909
  45572,   20.4756737,   57.5352364,     9.090909
  45573,   20.2236385,    58.187645,     9.090909
  45574,   19.9508228,   58.8316383,     9.090909
  45575,    19.657505,   59.4665527,     9.090909
  45576,   19.3439827,   60.0917435,     9.090909
  45577,   19.0105896,   60.7065659,     9.090909
  45578,   18.6576595,   61.3103828,     9.090909
  45579,   18.2855587,   61.9025803,     9.090909
  45580,   17.8946667,   62.4825439,     9.090909
  45581,   17.4853878,   63.0496826,     9.090909
  45582,   17.0581417,   63.6034126,     9.090909
  45583,   16.6133671,   64.1431656,     9.090909
  45584,   16.1515198,   64.6683807,     9.090909
  45585,   15.6730766,   65.1785278,     9.090909
  45586,   15.1785278,   65.6730804,     9.090909
  45587,   14.6683826,   66.1515198,     9.090909
  45588,   14.1431646,   66.6133652,     9.090909
  45589,   13.6034145,   67.0581436,     9.090909
  45590,   13.0496836,   67.4853897,     9.090909
  45591,   12.4825449,   67.8946686,     9.090909
  45592,   11.9025784,   68.2855606,     9.090909
  45593,   11.3103848,   68.6576614,     9.090909
  45594,   10.7065639,   69.0105896,     9.090909
  45595,   10.0917444,   69.3439865,     9.090909
  45596,   9.46655369,   69.6575012,     9.090909
  45597,   8.83163548,   69.9508209,     9.090909
  45598,   8.18764305,   70.2236404,     9.090909
  45599,   7.53523684,   70.4756775,     9.090909
  45600,   6.87508774,   70.7066727,     9.090909
  45601,   6.20787525,   70.9163895,     9.090909
  45602,   5.53428268,   71.1046143,     9.090909
  45603,    4.8550024,   71.2711563,     9.090909
  45604,   4.17073441,   71.4158325,     9.090909
  45605,    3.4821794,   71.5385132,     9.090909
  45606,   2.79004717,   71.6390533,     9.090909
  45607,   2.09504771,   71.7173615,     9.090909
  45608,   1.39789569,   71.7733536,     9.090909
  45609,  0.699307203,   71.8069687,     9.090909
  45610,           0.,   71.8181839,     9.090909
  45611, -0.699307203,   71.8069687,     9.090909
  45612,  -1.39789569,   71.7733536,     9.090909
  45613,  -2.09504771,   71.7173615,     9.090909
  45614,  -2.79004717,   71.6390533,     9.090909
  45615,   -3.4821794,   71.5385132,     9.090909
  45616,  -4.17073441,   71.4158325,     9.090909
  45617,   -4.8550024,   71.2711563,     9.090909
  45618,  -5.53428268,   71.1046143,     9.090909
  45619,  -6.20787525,   70.9163895,     9.090909
  45620,  -6.87508774,   70.7066727,     9.090909
  45621,  -7.53523684,   70.4756775,     9.090909
  45622,  -8.18764305,   70.2236404,     9.090909
  45623,  -8.83163548,   69.9508209,     9.090909
  45624,  -9.46655369,   69.6575012,     9.090909
  45625,  -10.0917444,   69.3439865,     9.090909
  45626,  -10.7065639,   69.0105896,     9.090909
  45627,  -11.3103848,   68.6576614,     9.090909
  45628,  -11.9025784,   68.2855606,     9.090909
  45629,  -12.4825449,   67.8946686,     9.090909
  45630,  -13.0496836,   67.4853897,     9.090909
  45631,  -13.6034145,   67.0581436,     9.090909
  45632,  -14.1431646,   66.6133652,     9.090909
  45633,  -14.6683826,   66.1515198,     9.090909
  45634,  -15.1785278,   65.6730804,     9.090909
  45635,  -15.6730766,   65.1785278,     9.090909
  45636,  -16.1515198,   64.6683807,     9.090909
  45637,  -16.6133671,   64.1431656,     9.090909
  45638,  -17.0581417,   63.6034126,     9.090909
  45639,  -17.4853878,   63.0496826,     9.090909
  45640,  -17.8946667,   62.4825439,     9.090909
  45641,  -18.2855587,   61.9025803,     9.090909
  45642,  -18.6576595,   61.3103828,     9.090909
  45643,  -19.0105896,   60.7065659,     9.090909
  45644,  -19.3439827,   60.0917435,     9.090909
  45645,   -19.657505,   59.4665527,     9.090909
  45646,  -19.9508228,   58.8316383,     9.090909
  45647,  -20.2236385,    58.187645,     9.090909
  45648,  -20.4756737,   57.5352364,     9.090909
  45649,  -20.7066708,   56.8750877,     9.090909
  45650,  -20.9163895,   56.2078743,     9.090909
  45651,  -21.1046143,   55.5342827,     9.090909
  45652,  -21.2711544,   54.8550034,     9.090909
  45653,  -21.4158363,   54.1707344,     9.090909
  45654,  -21.5385113,   53.4821777,     9.090909
  45655,  -21.6390553,   52.7900467,     9.090909
  45656,  -21.7173653,    52.095047,     9.090909
  45657,  -21.7733536,   51.3978958,     9.090909
  45658,  -21.8069725,   50.6993065,     9.090909
  45659,   20.8983479,   50.6701698,  0.909090936
  45660,   20.8661308,   51.3396492,  0.909090936
  45661,   20.8124752,   52.0077553,  0.909090936
  45662,   20.7374268,   52.6737938,  0.909090936
  45663,   20.6410732,   53.3370895,  0.909090936
  45664,     20.52351,   53.9969521,  0.909090936
  45665,   20.3848572,     54.65271,  0.909090936
  45666,    20.225256,    55.303688,  0.909090936
  45667,   20.0448742,   55.9492149,  0.909090936
  45668,   19.8438931,   56.5886269,  0.909090936
  45669,   19.6225204,   57.2212677,  0.909090936
  45670,   19.3809872,   57.8464928,  0.909090936
  45671,   19.1195393,   58.4636536,  0.909090936
  45672,   18.8384418,    59.072113,  0.909090936
  45673,   18.5379829,    59.671257,  0.909090936
  45674,   18.2184811,   60.2604561,  0.909090936
  45675,   17.8802586,    60.839119,  0.909090936
  45676,   17.5236607,   61.4066391,  0.909090936
  45677,   17.1490555,   61.9624405,  0.909090936
  45678,   16.7568302,   62.5059471,  0.909090936
  45679,   16.3473854,   63.0366058,  0.909090936
  45680,   15.9211416,   63.5538673,  0.909090936
  45681,   15.4785395,   64.0571976,  0.909090936
  45682,   15.0200319,   64.5460892,  0.909090936
  45683,   14.5460892,   65.0200348,  0.909090936
  45684,   14.0572014,   65.4785385,  0.909090936
  45685,   13.5538654,   65.9211426,  0.909090936
  45686,   13.0366058,   66.3473892,  0.909090936
  45687,   12.5059462,   66.7568283,  0.909090936
  45688,   11.9624405,   67.1490555,  0.909090936
  45689,   11.4066381,   67.5236588,  0.909090936
  45690,    10.839119,   67.8802567,  0.909090936
  45691,    10.260457,    68.218483,  0.909090936
  45692,   9.67125511,   68.5379868,  0.909090936
  45693,   9.07211399,   68.8384399,  0.909090936
  45694,    8.4636507,   69.1195374,  0.909090936
  45695,   7.84649086,   69.3809891,  0.909090936
  45696,   7.22126818,   69.6225204,  0.909090936
  45697,   6.58862591,    69.843895,  0.909090936
  45698,    5.9492135,   70.0448761,  0.909090936
  45699,   5.30368757,   70.2252579,  0.909090936
  45700,   4.65271044,   70.3848572,  0.909090936
  45701,   3.99695396,   70.5235062,  0.909090936
  45702,   3.33708858,   70.6410751,  0.909090936
  45703,   2.67379522,   70.7374268,  0.909090936
  45704,   2.00775385,   70.8124695,  0.909090936
  45705,   1.33965003,   70.8661346,  0.909090936
  45706,  0.670169413,   70.8983459,  0.909090936
  45707,           0.,   70.9090881,  0.909090936
  45708, -0.670169413,   70.8983459,  0.909090936
  45709,  -1.33965003,   70.8661346,  0.909090936
  45710,  -2.00775385,   70.8124695,  0.909090936
  45711,  -2.67379522,   70.7374268,  0.909090936
  45712,  -3.33708858,   70.6410751,  0.909090936
  45713,  -3.99695396,   70.5235062,  0.909090936
  45714,  -4.65271044,   70.3848572,  0.909090936
  45715,  -5.30368757,   70.2252579,  0.909090936
  45716,   -5.9492135,   70.0448761,  0.909090936
  45717,  -6.58862591,    69.843895,  0.909090936
  45718,  -7.22126818,   69.6225204,  0.909090936
  45719,  -7.84649086,   69.3809891,  0.909090936
  45720,   -8.4636507,   69.1195374,  0.909090936
  45721,  -9.07211399,   68.8384399,  0.909090936
  45722,  -9.67125511,   68.5379868,  0.909090936
  45723,   -10.260457,    68.218483,  0.909090936
  45724,   -10.839119,   67.8802567,  0.909090936
  45725,  -11.4066381,   67.5236588,  0.909090936
  45726,  -11.9624405,   67.1490555,  0.909090936
  45727,  -12.5059462,   66.7568283,  0.909090936
  45728,  -13.0366058,   66.3473892,  0.909090936
  45729,  -13.5538654,   65.9211426,  0.909090936
  45730,  -14.0572014,   65.4785385,  0.909090936
  45731,  -14.5460892,   65.0200348,  0.909090936
  45732,  -15.0200319,   64.5460892,  0.909090936
  45733,  -15.4785395,   64.0571976,  0.909090936
  45734,  -15.9211416,   63.5538673,  0.909090936
  45735,  -16.3473854,   63.0366058,  0.909090936
  45736,  -16.7568302,   62.5059471,  0.909090936
  45737,  -17.1490555,   61.9624405,  0.909090936
  45738,  -17.5236607,   61.4066391,  0.909090936
  45739,  -17.8802586,    60.839119,  0.909090936
  45740,  -18.2184811,   60.2604561,  0.909090936
  45741,  -18.5379829,    59.671257,  0.909090936
  45742,  -18.8384418,    59.072113,  0.909090936
  45743,  -19.1195393,   58.4636536,  0.909090936
  45744,  -19.3809872,   57.8464928,  0.909090936
  45745,  -19.6225204,   57.2212677,  0.909090936
  45746,  -19.8438931,   56.5886269,  0.909090936
  45747,  -20.0448742,   55.9492149,  0.909090936
  45748,   -20.225256,    55.303688,  0.909090936
  45749,  -20.3848572,     54.65271,  0.909090936
  45750,    -20.52351,   53.9969521,  0.909090936
  45751,  -20.6410732,   53.3370895,  0.909090936
  45752,  -20.7374268,   52.6737938,  0.909090936
  45753,  -20.8124752,   52.0077553,  0.909090936
  45754,  -20.8661308,   51.3396492,  0.909090936
  45755,  -20.8983479,   50.6701698,  0.909090936
  45756,   20.8983479,   50.6701698,   1.81818187
  45757,   20.8661308,   51.3396492,   1.81818187
  45758,   20.8124752,   52.0077553,   1.81818187
  45759,   20.7374268,   52.6737938,   1.81818187
  45760,   20.6410732,   53.3370895,   1.81818187
  45761,     20.52351,   53.9969521,   1.81818187
  45762,   20.3848572,     54.65271,   1.81818187
  45763,    20.225256,    55.303688,   1.81818187
  45764,   20.0448742,   55.9492149,   1.81818187
  45765,   19.8438931,   56.5886269,   1.81818187
  45766,   19.6225204,   57.2212677,   1.81818187
  45767,   19.3809872,   57.8464928,   1.81818187
  45768,   19.1195393,   58.4636536,   1.81818187
  45769,   18.8384418,    59.072113,   1.81818187
  45770,   18.5379829,    59.671257,   1.81818187
  45771,   18.2184811,   60.2604561,   1.81818187
  45772,   17.8802586,    60.839119,   1.81818187
  45773,   17.5236607,   61.4066391,   1.81818187
  45774,   17.1490555,   61.9624405,   1.81818187
  45775,   16.7568302,   62.5059471,   1.81818187
  45776,   16.3473854,   63.0366058,   1.81818187
  45777,   15.9211416,   63.5538673,   1.81818187
  45778,   15.4785395,   64.0571976,   1.81818187
  45779,   15.0200319,   64.5460892,   1.81818187
  45780,   14.5460892,   65.0200348,   1.81818187
  45781,   14.0572014,   65.4785385,   1.81818187
  45782,   13.5538654,   65.9211426,   1.81818187
  45783,   13.0366058,   66.3473892,   1.81818187
  45784,   12.5059462,   66.7568283,   1.81818187
  45785,   11.9624405,   67.1490555,   1.81818187
  45786,   11.4066381,   67.5236588,   1.81818187
  45787,    10.839119,   67.8802567,   1.81818187
  45788,    10.260457,    68.218483,   1.81818187
  45789,   9.67125511,   68.5379868,   1.81818187
  45790,   9.07211399,   68.8384399,   1.81818187
  45791,    8.4636507,   69.1195374,   1.81818187
  45792,   7.84649086,   69.3809891,   1.81818187
  45793,   7.22126818,   69.6225204,   1.81818187
  45794,   6.58862591,    69.843895,   1.81818187
  45795,    5.9492135,   70.0448761,   1.81818187
  45796,   5.30368757,   70.2252579,   1.81818187
  45797,   4.65271044,   70.3848572,   1.81818187
  45798,   3.99695396,   70.5235062,   1.81818187
  45799,   3.33708858,   70.6410751,   1.81818187
  45800,   2.67379522,   70.7374268,   1.81818187
  45801,   2.00775385,   70.8124695,   1.81818187
  45802,   1.33965003,   70.8661346,   1.81818187
  45803,  0.670169413,   70.8983459,   1.81818187
  45804,           0.,   70.9090881,   1.81818187
  45805, -0.670169413,   70.8983459,   1.81818187
  45806,  -1.33965003,   70.8661346,   1.81818187
  45807,  -2.00775385,   70.8124695,   1.81818187
  45808,  -2.67379522,   70.7374268,   1.81818187
  45809,  -3.33708858,   70.6410751,   1.81818187
  45810,  -3.99695396,   70.5235062,   1.81818187
  45811,  -4.65271044,   70.3848572,   1.81818187
  45812,  -5.30368757,   70.2252579,   1.81818187
  45813,   -5.9492135,   70.0448761,   1.81818187
  45814,  -6.58862591,    69.843895,   1.81818187
  45815,  -7.22126818,   69.6225204,   1.81818187
  45816,  -7.84649086,   69.3809891,   1.81818187
  45817,   -8.4636507,   69.1195374,   1.81818187
  45818,  -9.07211399,   68.8384399,   1.81818187
  45819,  -9.67125511,   68.5379868,   1.81818187
  45820,   -10.260457,    68.218483,   1.81818187
  45821,   -10.839119,   67.8802567,   1.81818187
  45822,  -11.4066381,   67.5236588,   1.81818187
  45823,  -11.9624405,   67.1490555,   1.81818187
  45824,  -12.5059462,   66.7568283,   1.81818187
  45825,  -13.0366058,   66.3473892,   1.81818187
  45826,  -13.5538654,   65.9211426,   1.81818187
  45827,  -14.0572014,   65.4785385,   1.81818187
  45828,  -14.5460892,   65.0200348,   1.81818187
  45829,  -15.0200319,   64.5460892,   1.81818187
  45830,  -15.4785395,   64.0571976,   1.81818187
  45831,  -15.9211416,   63.5538673,   1.81818187
  45832,  -16.3473854,   63.0366058,   1.81818187
  45833,  -16.7568302,   62.5059471,   1.81818187
  45834,  -17.1490555,   61.9624405,   1.81818187
  45835,  -17.5236607,   61.4066391,   1.81818187
  45836,  -17.8802586,    60.839119,   1.81818187
  45837,  -18.2184811,   60.2604561,   1.81818187
  45838,  -18.5379829,    59.671257,   1.81818187
  45839,  -18.8384418,    59.072113,   1.81818187
  45840,  -19.1195393,   58.4636536,   1.81818187
  45841,  -19.3809872,   57.8464928,   1.81818187
  45842,  -19.6225204,   57.2212677,   1.81818187
  45843,  -19.8438931,   56.5886269,   1.81818187
  45844,  -20.0448742,   55.9492149,   1.81818187
  45845,   -20.225256,    55.303688,   1.81818187
  45846,  -20.3848572,     54.65271,   1.81818187
  45847,    -20.52351,   53.9969521,   1.81818187
  45848,  -20.6410732,   53.3370895,   1.81818187
  45849,  -20.7374268,   52.6737938,   1.81818187
  45850,  -20.8124752,   52.0077553,   1.81818187
  45851,  -20.8661308,   51.3396492,   1.81818187
  45852,  -20.8983479,   50.6701698,   1.81818187
  45853,   20.8983479,   50.6701698,   2.72727275
  45854,   20.8661308,   51.3396492,   2.72727275
  45855,   20.8124752,   52.0077553,   2.72727275
  45856,   20.7374268,   52.6737938,   2.72727275
  45857,   20.6410732,   53.3370895,   2.72727275
  45858,     20.52351,   53.9969521,   2.72727275
  45859,   20.3848572,     54.65271,   2.72727275
  45860,    20.225256,    55.303688,   2.72727275
  45861,   20.0448742,   55.9492149,   2.72727275
  45862,   19.8438931,   56.5886269,   2.72727275
  45863,   19.6225204,   57.2212677,   2.72727275
  45864,   19.3809872,   57.8464928,   2.72727275
  45865,   19.1195393,   58.4636536,   2.72727275
  45866,   18.8384418,    59.072113,   2.72727275
  45867,   18.5379829,    59.671257,   2.72727275
  45868,   18.2184811,   60.2604561,   2.72727275
  45869,   17.8802586,    60.839119,   2.72727275
  45870,   17.5236607,   61.4066391,   2.72727275
  45871,   17.1490555,   61.9624405,   2.72727275
  45872,   16.7568302,   62.5059471,   2.72727275
  45873,   16.3473854,   63.0366058,   2.72727275
  45874,   15.9211416,   63.5538673,   2.72727275
  45875,   15.4785395,   64.0571976,   2.72727275
  45876,   15.0200319,   64.5460892,   2.72727275
  45877,   14.5460892,   65.0200348,   2.72727275
  45878,   14.0572014,   65.4785385,   2.72727275
  45879,   13.5538654,   65.9211426,   2.72727275
  45880,   13.0366058,   66.3473892,   2.72727275
  45881,   12.5059462,   66.7568283,   2.72727275
  45882,   11.9624405,   67.1490555,   2.72727275
  45883,   11.4066381,   67.5236588,   2.72727275
  45884,    10.839119,   67.8802567,   2.72727275
  45885,    10.260457,    68.218483,   2.72727275
  45886,   9.67125511,   68.5379868,   2.72727275
  45887,   9.07211399,   68.8384399,   2.72727275
  45888,    8.4636507,   69.1195374,   2.72727275
  45889,   7.84649086,   69.3809891,   2.72727275
  45890,   7.22126818,   69.6225204,   2.72727275
  45891,   6.58862591,    69.843895,   2.72727275
  45892,    5.9492135,   70.0448761,   2.72727275
  45893,   5.30368757,   70.2252579,   2.72727275
  45894,   4.65271044,   70.3848572,   2.72727275
  45895,   3.99695396,   70.5235062,   2.72727275
  45896,   3.33708858,   70.6410751,   2.72727275
  45897,   2.67379522,   70.7374268,   2.72727275
  45898,   2.00775385,   70.8124695,   2.72727275
  45899,   1.33965003,   70.8661346,   2.72727275
  45900,  0.670169413,   70.8983459,   2.72727275
  45901,           0.,   70.9090881,   2.72727275
  45902, -0.670169413,   70.8983459,   2.72727275
  45903,  -1.33965003,   70.8661346,   2.72727275
  45904,  -2.00775385,   70.8124695,   2.72727275
  45905,  -2.67379522,   70.7374268,   2.72727275
  45906,  -3.33708858,   70.6410751,   2.72727275
  45907,  -3.99695396,   70.5235062,   2.72727275
  45908,  -4.65271044,   70.3848572,   2.72727275
  45909,  -5.30368757,   70.2252579,   2.72727275
  45910,   -5.9492135,   70.0448761,   2.72727275
  45911,  -6.58862591,    69.843895,   2.72727275
  45912,  -7.22126818,   69.6225204,   2.72727275
  45913,  -7.84649086,   69.3809891,   2.72727275
  45914,   -8.4636507,   69.1195374,   2.72727275
  45915,  -9.07211399,   68.8384399,   2.72727275
  45916,  -9.67125511,   68.5379868,   2.72727275
  45917,   -10.260457,    68.218483,   2.72727275
  45918,   -10.839119,   67.8802567,   2.72727275
  45919,  -11.4066381,   67.5236588,   2.72727275
  45920,  -11.9624405,   67.1490555,   2.72727275
  45921,  -12.5059462,   66.7568283,   2.72727275
  45922,  -13.0366058,   66.3473892,   2.72727275
  45923,  -13.5538654,   65.9211426,   2.72727275
  45924,  -14.0572014,   65.4785385,   2.72727275
  45925,  -14.5460892,   65.0200348,   2.72727275
  45926,  -15.0200319,   64.5460892,   2.72727275
  45927,  -15.4785395,   64.0571976,   2.72727275
  45928,  -15.9211416,   63.5538673,   2.72727275
  45929,  -16.3473854,   63.0366058,   2.72727275
  45930,  -16.7568302,   62.5059471,   2.72727275
  45931,  -17.1490555,   61.9624405,   2.72727275
  45932,  -17.5236607,   61.4066391,   2.72727275
  45933,  -17.8802586,    60.839119,   2.72727275
  45934,  -18.2184811,   60.2604561,   2.72727275
  45935,  -18.5379829,    59.671257,   2.72727275
  45936,  -18.8384418,    59.072113,   2.72727275
  45937,  -19.1195393,   58.4636536,   2.72727275
  45938,  -19.3809872,   57.8464928,   2.72727275
  45939,  -19.6225204,   57.2212677,   2.72727275
  45940,  -19.8438931,   56.5886269,   2.72727275
  45941,  -20.0448742,   55.9492149,   2.72727275
  45942,   -20.225256,    55.303688,   2.72727275
  45943,  -20.3848572,     54.65271,   2.72727275
  45944,    -20.52351,   53.9969521,   2.72727275
  45945,  -20.6410732,   53.3370895,   2.72727275
  45946,  -20.7374268,   52.6737938,   2.72727275
  45947,  -20.8124752,   52.0077553,   2.72727275
  45948,  -20.8661308,   51.3396492,   2.72727275
  45949,  -20.8983479,   50.6701698,   2.72727275
  45950,   20.8983479,   50.6701698,   3.63636374
  45951,   20.8661308,   51.3396492,   3.63636374
  45952,   20.8124752,   52.0077553,   3.63636374
  45953,   20.7374268,   52.6737938,   3.63636374
  45954,   20.6410732,   53.3370895,   3.63636374
  45955,     20.52351,   53.9969521,   3.63636374
  45956,   20.3848572,     54.65271,   3.63636374
  45957,    20.225256,    55.303688,   3.63636374
  45958,   20.0448742,   55.9492149,   3.63636374
  45959,   19.8438931,   56.5886269,   3.63636374
  45960,   19.6225204,   57.2212677,   3.63636374
  45961,   19.3809872,   57.8464928,   3.63636374
  45962,   19.1195393,   58.4636536,   3.63636374
  45963,   18.8384418,    59.072113,   3.63636374
  45964,   18.5379829,    59.671257,   3.63636374
  45965,   18.2184811,   60.2604561,   3.63636374
  45966,   17.8802586,    60.839119,   3.63636374
  45967,   17.5236607,   61.4066391,   3.63636374
  45968,   17.1490555,   61.9624405,   3.63636374
  45969,   16.7568302,   62.5059471,   3.63636374
  45970,   16.3473854,   63.0366058,   3.63636374
  45971,   15.9211416,   63.5538673,   3.63636374
  45972,   15.4785395,   64.0571976,   3.63636374
  45973,   15.0200319,   64.5460892,   3.63636374
  45974,   14.5460892,   65.0200348,   3.63636374
  45975,   14.0572014,   65.4785385,   3.63636374
  45976,   13.5538654,   65.9211426,   3.63636374
  45977,   13.0366058,   66.3473892,   3.63636374
  45978,   12.5059462,   66.7568283,   3.63636374
  45979,   11.9624405,   67.1490555,   3.63636374
  45980,   11.4066381,   67.5236588,   3.63636374
  45981,    10.839119,   67.8802567,   3.63636374
  45982,    10.260457,    68.218483,   3.63636374
  45983,   9.67125511,   68.5379868,   3.63636374
  45984,   9.07211399,   68.8384399,   3.63636374
  45985,    8.4636507,   69.1195374,   3.63636374
  45986,   7.84649086,   69.3809891,   3.63636374
  45987,   7.22126818,   69.6225204,   3.63636374
  45988,   6.58862591,    69.843895,   3.63636374
  45989,    5.9492135,   70.0448761,   3.63636374
  45990,   5.30368757,   70.2252579,   3.63636374
  45991,   4.65271044,   70.3848572,   3.63636374
  45992,   3.99695396,   70.5235062,   3.63636374
  45993,   3.33708858,   70.6410751,   3.63636374
  45994,   2.67379522,   70.7374268,   3.63636374
