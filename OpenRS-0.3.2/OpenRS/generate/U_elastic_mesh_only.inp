  53995,  -23.5985832,   28.5961723,   8.18181801
  53996,  -22.6989365,   28.5961723,   8.18181801
  53997,  -21.7992916,   28.5961723,   8.18181801
  53998,  -20.8996449,   28.5961723,   8.18181801
  53999,  -29.0743809,   29.3875599,   8.18181801
  54000,  -28.1487598,   29.3875599,   8.18181801
  54001,  -27.2231407,   29.3875599,   8.18181801
  54002,  -26.2975197,   29.3875599,   8.18181801
  54003,  -25.3978748,   29.3875599,   8.18181801
  54004,  -24.4982281,   29.3875599,   8.18181801
  54005,  -23.5985832,   29.3875599,   8.18181801
  54006,  -22.6989365,   29.3875599,   8.18181801
  54007,  -21.7992916,   29.3875599,   8.18181801
  54008,  -20.8996449,   29.3875599,   8.18181801
  54009,  -29.0743809,   30.1789474,   8.18181801
  54010,  -28.1487598,   30.1789474,   8.18181801
  54011,  -27.2231407,   30.1789474,   8.18181801
  54012,  -26.2975197,   30.1789474,   8.18181801
  54013,  -25.3978748,   30.1789474,   8.18181801
  54014,  -24.4982281,   30.1789474,   8.18181801
  54015,  -23.5985832,   30.1789474,   8.18181801
  54016,  -22.6989365,   30.1789474,   8.18181801
  54017,  -21.7992916,   30.1789474,   8.18181801
  54018,  -20.8996449,   30.1789474,   8.18181801
  54019,  -29.0743809,    30.970335,   8.18181801
  54020,  -28.1487598,    30.970335,   8.18181801
  54021,  -27.2231407,    30.970335,   8.18181801
  54022,  -26.2975197,    30.970335,   8.18181801
  54023,  -25.3978748,    30.970335,   8.18181801
  54024,  -24.4982281,    30.970335,   8.18181801
  54025,  -23.5985832,    30.970335,   8.18181801
  54026,  -22.6989365,    30.970335,   8.18181801
  54027,  -21.7992916,    30.970335,   8.18181801
  54028,  -20.8996449,    30.970335,   8.18181801
  54029,  -29.0743809,   31.7617226,   8.18181801
  54030,  -28.1487598,   31.7617226,   8.18181801
  54031,  -27.2231407,   31.7617226,   8.18181801
  54032,  -26.2975197,   31.7617226,   8.18181801
  54033,  -25.3978748,   31.7617226,   8.18181801
  54034,  -24.4982281,   31.7617226,   8.18181801
  54035,  -23.5985832,   31.7617226,   8.18181801
  54036,  -22.6989365,   31.7617226,   8.18181801
  54037,  -21.7992916,   31.7617226,   8.18181801
  54038,  -20.8996449,   31.7617226,   8.18181801
  54039,  -29.0743809,   32.5531082,   8.18181801
  54040,  -28.1487598,   32.5531082,   8.18181801
  54041,  -27.2231407,   32.5531082,   8.18181801
  54042,  -26.2975197,   32.5531082,   8.18181801
  54043,  -25.3978748,   32.5531082,   8.18181801
  54044,  -24.4982281,   32.5531082,   8.18181801
  54045,  -23.5985832,   32.5531082,   8.18181801
  54046,  -22.6989365,   32.5531082,   8.18181801
  54047,  -21.7992916,   32.5531082,   8.18181801
  54048,  -20.8996449,   32.5531082,   8.18181801
  54049,  -29.0743809,   33.3444977,   8.18181801
  54050,  -28.1487598,   33.3444977,   8.18181801
  54051,  -27.2231407,   33.3444977,   8.18181801
  54052,  -26.2975197,   33.3444977,   8.18181801
  54053,  -25.3978748,   33.3444977,   8.18181801
  54054,  -24.4982281,   33.3444977,   8.18181801
  54055,  -23.5985832,   33.3444977,   8.18181801
  54056,  -22.6989365,   33.3444977,   8.18181801
  54057,  -21.7992916,   33.3444977,   8.18181801
  54058,  -20.8996449,   33.3444977,   8.18181801
  54059,  -29.0743809,   34.1358833,   8.18181801
  54060,  -28.1487598,   34.1358833,   8.18181801
  54061,  -27.2231407,   34.1358833,   8.18181801
  54062,  -26.2975197,   34.1358833,   8.18181801
  54063,  -25.3978748,   34.1358833,   8.18181801
  54064,  -24.4982281,   34.1358833,   8.18181801
  54065,  -23.5985832,   34.1358833,   8.18181801
  54066,  -22.6989365,   34.1358833,   8.18181801
  54067,  -21.7992916,   34.1358833,   8.18181801
  54068,  -20.8996449,   34.1358833,   8.18181801
  54069,  -29.0743809,   34.9272728,   8.18181801
  54070,  -28.1487598,   34.9272728,   8.18181801
  54071,  -27.2231407,   34.9272728,   8.18181801
  54072,  -26.2975197,   34.9272728,   8.18181801
  54073,  -25.3978748,   34.9272728,   8.18181801
  54074,  -24.4982281,   34.9272728,   8.18181801
  54075,  -23.5985832,   34.9272728,   8.18181801
  54076,  -22.6989365,   34.9272728,   8.18181801
  54077,  -21.7992916,   34.9272728,   8.18181801
  54078,  -20.8996449,   34.9272728,   8.18181801
  54079,  -29.0743809,   35.7186584,   8.18181801
  54080,  -28.1487598,   35.7186584,   8.18181801
  54081,  -27.2231407,   35.7186584,   8.18181801
  54082,  -26.2975197,   35.7186584,   8.18181801
  54083,  -25.3978748,   35.7186584,   8.18181801
  54084,  -24.4982281,   35.7186584,   8.18181801
  54085,  -23.5985832,   35.7186584,   8.18181801
  54086,  -22.6989365,   35.7186584,   8.18181801
  54087,  -21.7992916,   35.7186584,   8.18181801
  54088,  -20.8996449,   35.7186584,   8.18181801
  54089,  -29.0743809,   36.5100479,   8.18181801
  54090,  -28.1487598,   36.5100479,   8.18181801
  54091,  -27.2231407,   36.5100479,   8.18181801
  54092,  -26.2975197,   36.5100479,   8.18181801
  54093,  -25.3978748,   36.5100479,   8.18181801
  54094,  -24.4982281,   36.5100479,   8.18181801
  54095,  -23.5985832,   36.5100479,   8.18181801
  54096,  -22.6989365,   36.5100479,   8.18181801
  54097,  -21.7992916,   36.5100479,   8.18181801
  54098,  -20.8996449,   36.5100479,   8.18181801
  54099,  -29.0743809,   37.3014336,   8.18181801
  54100,  -28.1487598,   37.3014336,   8.18181801
  54101,  -27.2231407,   37.3014336,   8.18181801
  54102,  -26.2975197,   37.3014336,   8.18181801
  54103,  -25.3978748,   37.3014336,   8.18181801
  54104,  -24.4982281,   37.3014336,   8.18181801
  54105,  -23.5985832,   37.3014336,   8.18181801
  54106,  -22.6989365,   37.3014336,   8.18181801
  54107,  -21.7992916,   37.3014336,   8.18181801
  54108,  -20.8996449,   37.3014336,   8.18181801
  54109,  -29.0743809,    38.092823,   8.18181801
  54110,  -28.1487598,    38.092823,   8.18181801
  54111,  -27.2231407,    38.092823,   8.18181801
  54112,  -26.2975197,    38.092823,   8.18181801
  54113,  -25.3978748,    38.092823,   8.18181801
  54114,  -24.4982281,    38.092823,   8.18181801
  54115,  -23.5985832,    38.092823,   8.18181801
  54116,  -22.6989365,    38.092823,   8.18181801
  54117,  -21.7992916,    38.092823,   8.18181801
  54118,  -20.8996449,    38.092823,   8.18181801
  54119,  -29.0743809,   38.8842087,   8.18181801
  54120,  -28.1487598,   38.8842087,   8.18181801
  54121,  -27.2231407,   38.8842087,   8.18181801
  54122,  -26.2975197,   38.8842087,   8.18181801
  54123,  -25.3978748,   38.8842087,   8.18181801
  54124,  -24.4982281,   38.8842087,   8.18181801
  54125,  -23.5985832,   38.8842087,   8.18181801
  54126,  -22.6989365,   38.8842087,   8.18181801
  54127,  -21.7992916,   38.8842087,   8.18181801
  54128,  -20.8996449,   38.8842087,   8.18181801
  54129,  -29.0743809,   39.6755981,   8.18181801
  54130,  -28.1487598,   39.6755981,   8.18181801
  54131,  -27.2231407,   39.6755981,   8.18181801
  54132,  -26.2975197,   39.6755981,   8.18181801
  54133,  -25.3978748,   39.6755981,   8.18181801
  54134,  -24.4982281,   39.6755981,   8.18181801
  54135,  -23.5985832,   39.6755981,   8.18181801
  54136,  -22.6989365,   39.6755981,   8.18181801
  54137,  -21.7992916,   39.6755981,   8.18181801
  54138,  -20.8996449,   39.6755981,   8.18181801
  54139,  -29.0743809,   40.4669838,   8.18181801
  54140,  -28.1487598,   40.4669838,   8.18181801
  54141,  -27.2231407,   40.4669838,   8.18181801
  54142,  -26.2975197,   40.4669838,   8.18181801
  54143,  -25.3978748,   40.4669838,   8.18181801
  54144,  -24.4982281,   40.4669838,   8.18181801
  54145,  -23.5985832,   40.4669838,   8.18181801
  54146,  -22.6989365,   40.4669838,   8.18181801
  54147,  -21.7992916,   40.4669838,   8.18181801
  54148,  -20.8996449,   40.4669838,   8.18181801
  54149,  -29.0743809,   41.2583733,   8.18181801
  54150,  -28.1487598,   41.2583733,   8.18181801
  54151,  -27.2231407,   41.2583733,   8.18181801
  54152,  -26.2975197,   41.2583733,   8.18181801
  54153,  -25.3978748,   41.2583733,   8.18181801
  54154,  -24.4982281,   41.2583733,   8.18181801
  54155,  -23.5985832,   41.2583733,   8.18181801
  54156,  -22.6989365,   41.2583733,   8.18181801
  54157,  -21.7992916,   41.2583733,   8.18181801
  54158,  -20.8996449,   41.2583733,   8.18181801
  54159,  -29.0743809,   42.0497589,   8.18181801
  54160,  -28.1487598,   42.0497589,   8.18181801
  54161,  -27.2231407,   42.0497589,   8.18181801
  54162,  -26.2975197,   42.0497589,   8.18181801
  54163,  -25.3978748,   42.0497589,   8.18181801
  54164,  -24.4982281,   42.0497589,   8.18181801
  54165,  -23.5985832,   42.0497589,   8.18181801
  54166,  -22.6989365,   42.0497589,   8.18181801
  54167,  -21.7992916,   42.0497589,   8.18181801
  54168,  -20.8996449,   42.0497589,   8.18181801
  54169,  -29.0743809,   42.8411484,   8.18181801
  54170,  -28.1487598,   42.8411484,   8.18181801
  54171,  -27.2231407,   42.8411484,   8.18181801
  54172,  -26.2975197,   42.8411484,   8.18181801
  54173,  -25.3978748,   42.8411484,   8.18181801
  54174,  -24.4982281,   42.8411484,   8.18181801
  54175,  -23.5985832,   42.8411484,   8.18181801
  54176,  -22.6989365,   42.8411484,   8.18181801
  54177,  -21.7992916,   42.8411484,   8.18181801
  54178,  -20.8996449,   42.8411484,   8.18181801
  54179,  -29.0743809,    43.632534,   8.18181801
  54180,  -28.1487598,    43.632534,   8.18181801
  54181,  -27.2231407,    43.632534,   8.18181801
  54182,  -26.2975197,    43.632534,   8.18181801
  54183,  -25.3978748,    43.632534,   8.18181801
  54184,  -24.4982281,    43.632534,   8.18181801
  54185,  -23.5985832,    43.632534,   8.18181801
  54186,  -22.6989365,    43.632534,   8.18181801
  54187,  -21.7992916,    43.632534,   8.18181801
  54188,  -20.8996449,    43.632534,   8.18181801
  54189,  -29.0743809,   44.4239235,   8.18181801
  54190,  -28.1487598,   44.4239235,   8.18181801
  54191,  -27.2231407,   44.4239235,   8.18181801
  54192,  -26.2975197,   44.4239235,   8.18181801
  54193,  -25.3978748,   44.4239235,   8.18181801
  54194,  -24.4982281,   44.4239235,   8.18181801
  54195,  -23.5985832,   44.4239235,   8.18181801
  54196,  -22.6989365,   44.4239235,   8.18181801
  54197,  -21.7992916,   44.4239235,   8.18181801
  54198,  -20.8996449,   44.4239235,   8.18181801
  54199,  -29.0743809,   45.2153091,   8.18181801
  54200,  -28.1487598,   45.2153091,   8.18181801
  54201,  -27.2231407,   45.2153091,   8.18181801
  54202,  -26.2975197,   45.2153091,   8.18181801
  54203,  -25.3978748,   45.2153091,   8.18181801
  54204,  -24.4982281,   45.2153091,   8.18181801
  54205,  -23.5985832,   45.2153091,   8.18181801
  54206,  -22.6989365,   45.2153091,   8.18181801
  54207,  -21.7992916,   45.2153091,   8.18181801
  54208,  -20.8996449,   45.2153091,   8.18181801
  54209,  -29.0771351,   46.0127602,   8.18181801
  54210,  -28.1542702,   46.0127602,   8.18181801
  54211,  -27.2314053,   46.0127602,   8.18181801
  54212,  -26.3085403,   46.0127602,   8.18181801
  54213,    -25.40732,   46.0127602,   8.18181801
  54214,  -24.5060997,   46.0127602,   8.18181801
  54215,  -23.6048794,   46.0127602,   8.18181801
  54216,  -22.7036591,   46.0127602,   8.18181801
  54217,  -21.8024406,   46.0127602,   8.18181801
  54218,  -20.9012184,   46.0127602,   8.18181801
  54219,  -29.0798912,   46.8102074,   8.18181801
  54220,  -28.1597786,   46.8102074,   8.18181801
  54221,  -27.2396698,   46.8102074,   8.18181801
  54222,  -26.3195591,   46.8102074,   8.18181801
  54223,  -25.4167652,   46.8102074,   8.18181801
  54224,  -24.5139694,   46.8102074,   8.18181801
  54225,  -23.6111774,   46.8102074,   8.18181801
  54226,  -22.7083817,   46.8102074,   8.18181801
  54227,  -21.8055878,   46.8102074,   8.18181801
  54228,  -20.9027939,   46.8102074,   8.18181801
  54229,  -29.0826454,   47.6076546,   8.18181801
  54230,  -28.1652889,   47.6076546,   8.18181801
  54231,  -27.2479343,   47.6076546,   8.18181801
  54232,  -26.3305779,   47.6076546,   8.18181801
  54233,  -25.4262104,   47.6076546,   8.18181801
  54234,   -24.521841,   47.6076546,   8.18181801
  54235,  -23.6174736,   47.6076546,   8.18181801
  54236,  -22.7131042,   47.6076546,   8.18181801
  54237,  -21.8087368,   47.6076546,   8.18181801
  54238,  -20.9043674,   47.6076546,   8.18181801
  54239,  -29.0853996,   48.4051018,   8.18181801
  54240,  -28.1707993,   48.4051018,   8.18181801
  54241,  -27.2561989,   48.4051018,   8.18181801
  54242,  -26.3415966,   48.4051018,   8.18181801
  54243,  -25.4356556,   48.4051018,   8.18181801
  54244,  -24.5297127,   48.4051018,   8.18181801
  54245,  -23.6237698,   48.4051018,   8.18181801
  54246,  -22.7178268,   48.4051018,   8.18181801
  54247,  -21.8118858,   48.4051018,   8.18181801
  54248,   -20.905941,   48.4051018,   8.18181801
  54249,  -29.0881557,   49.2025528,   8.18181801
  54250,  -28.1763077,   49.2025528,   8.18181801
  54251,  -27.2644634,   49.2025528,   8.18181801
  54252,  -26.3526173,   49.2025528,   8.18181801
  54253,  -25.4451008,   49.2025528,   8.18181801
  54254,  -24.5375824,   49.2025528,   8.18181801
  54255,  -23.6300678,   49.2025528,   8.18181801
  54256,  -22.7225494,   49.2025528,   8.18181801
  54257,   -21.815033,   49.2025528,   8.18181801
  54258,  -20.9075165,   49.2025528,   8.18181801
  54259,  -29.0897293,   20.7826385,     9.090909
  54260,  -28.1794567,   20.7826385,     9.090909
  54261,   -27.269186,   20.7826385,     9.090909
  54262,  -26.3589134,   20.7826385,     9.090909
  54263,  -25.4504986,   20.7826385,     9.090909
  54264,  -24.5420799,   20.7826385,     9.090909
  54265,  -23.6336651,   20.7826385,     9.090909
  54266,  -22.7252483,   20.7826385,     9.090909
  54267,  -21.8168335,   20.7826385,     9.090909
  54268,  -20.9084148,   20.7826385,     9.090909
  54269,  -29.0885487,   21.5652771,     9.090909
  54270,  -28.1770954,   21.5652771,     9.090909
  54271,  -27.2656441,   21.5652771,     9.090909
  54272,  -26.3541908,   21.5652771,     9.090909
  54273,  -25.4464493,   21.5652771,     9.090909
  54274,  -24.5387077,   21.5652771,     9.090909
  54275,  -23.6309662,   21.5652771,     9.090909
  54276,  -22.7232246,   21.5652771,     9.090909
  54277,  -21.8154831,   21.5652771,     9.090909
  54278,  -20.9077415,   21.5652771,     9.090909
  54279,   -29.087368,   22.3479156,     9.090909
  54280,  -28.1747341,   22.3479156,     9.090909
  54281,  -27.2621021,   22.3479156,     9.090909
  54282,  -26.3494682,   22.3479156,     9.090909
  54283,  -25.4424019,   22.3479156,     9.090909
  54284,  -24.5353336,   22.3479156,     9.090909
  54285,  -23.6282673,   22.3479156,     9.090909
  54286,  -22.7212009,   22.3479156,     9.090909
  54287,  -21.8141346,   22.3479156,     9.090909
  54288,  -20.9070663,   22.3479156,     9.090909
  54289,  -29.0861874,   23.1305542,     9.090909
  54290,  -28.1723728,   23.1305542,     9.090909
  54291,  -27.2585602,   23.1305542,     9.090909
  54292,  -26.3447456,   23.1305542,     9.090909
  54293,  -25.4383545,   23.1305542,     9.090909
  54294,  -24.5319614,   23.1305542,     9.090909
  54295,  -23.6255703,   23.1305542,     9.090909
  54296,  -22.7191772,   23.1305542,     9.090909
  54297,  -21.8127842,   23.1305542,     9.090909
  54298,  -20.9063911,   23.1305542,     9.090909
  54299,  -29.0850067,   23.9131927,     9.090909
  54300,  -28.1700115,   23.9131927,     9.090909
  54301,  -27.2550182,   23.9131927,     9.090909
  54302,   -26.340023,   23.9131927,     9.090909
  54303,  -25.4343071,   23.9131927,     9.090909
  54304,  -24.5285873,   23.9131927,     9.090909
  54305,  -23.6228714,   23.9131927,     9.090909
  54306,  -22.7171516,   23.9131927,     9.090909
  54307,  -21.8114357,   23.9131927,     9.090909
  54308,  -20.9057159,   23.9131927,     9.090909
  54309,  -29.0838261,   24.6958313,     9.090909
  54310,  -28.1676502,   24.6958313,     9.090909
  54311,  -27.2514763,   24.6958313,     9.090909
  54312,  -26.3353004,   24.6958313,     9.090909
  54313,  -25.4302578,   24.6958313,     9.090909
  54314,  -24.5252151,   24.6958313,     9.090909
  54315,  -23.6201725,   24.6958313,     9.090909
  54316,  -22.7151279,   24.6958313,     9.090909
  54317,  -21.8100853,   24.6958313,     9.090909
  54318,  -20.9050426,   24.6958313,     9.090909
  54319,  -29.0826454,   25.4784698,     9.090909
  54320,  -28.1652889,   25.4784698,     9.090909
  54321,  -27.2479343,   25.4784698,     9.090909
  54322,  -26.3305779,   25.4784698,     9.090909
  54323,  -25.4262104,   25.4784698,     9.090909
  54324,   -24.521841,   25.4784698,     9.090909
  54325,  -23.6174736,   25.4784698,     9.090909
  54326,  -22.7131042,   25.4784698,     9.090909
  54327,  -21.8087368,   25.4784698,     9.090909
  54328,  -20.9043674,   25.4784698,     9.090909
  54329,  -29.0826454,   26.2688999,     9.090909
  54330,  -28.1652889,   26.2688999,     9.090909
  54331,  -27.2479343,   26.2688999,     9.090909
  54332,  -26.3305779,   26.2688999,     9.090909
  54333,  -25.4262104,   26.2688999,     9.090909
  54334,   -24.521841,   26.2688999,     9.090909
  54335,  -23.6174736,   26.2688999,     9.090909
  54336,  -22.7131042,   26.2688999,     9.090909
  54337,  -21.8087368,   26.2688999,     9.090909
  54338,  -20.9043674,   26.2688999,     9.090909
  54339,  -29.0826454,     27.05933,     9.090909
  54340,  -28.1652889,     27.05933,     9.090909
  54341,  -27.2479343,     27.05933,     9.090909
  54342,  -26.3305779,     27.05933,     9.090909
  54343,  -25.4262104,     27.05933,     9.090909
  54344,   -24.521841,     27.05933,     9.090909
  54345,  -23.6174736,     27.05933,     9.090909
  54346,  -22.7131042,     27.05933,     9.090909
  54347,  -21.8087368,     27.05933,     9.090909
  54348,  -20.9043674,     27.05933,     9.090909
  54349,  -29.0826454,   27.8497601,     9.090909
  54350,  -28.1652889,   27.8497601,     9.090909
  54351,  -27.2479343,   27.8497601,     9.090909
  54352,  -26.3305779,   27.8497601,     9.090909
  54353,  -25.4262104,   27.8497601,     9.090909
  54354,   -24.521841,   27.8497601,     9.090909
  54355,  -23.6174736,   27.8497601,     9.090909
  54356,  -22.7131042,   27.8497601,     9.090909
  54357,  -21.8087368,   27.8497601,     9.090909
  54358,  -20.9043674,   27.8497601,     9.090909
  54359,  -29.0826454,    28.640192,     9.090909
  54360,  -28.1652889,    28.640192,     9.090909
  54361,  -27.2479343,    28.640192,     9.090909
  54362,  -26.3305779,    28.640192,     9.090909
  54363,  -25.4262104,    28.640192,     9.090909
  54364,   -24.521841,    28.640192,     9.090909
  54365,  -23.6174736,    28.640192,     9.090909
  54366,  -22.7131042,    28.640192,     9.090909
  54367,  -21.8087368,    28.640192,     9.090909
  54368,  -20.9043674,    28.640192,     9.090909
  54369,  -29.0826454,   29.4306221,     9.090909
  54370,  -28.1652889,   29.4306221,     9.090909
  54371,  -27.2479343,   29.4306221,     9.090909
  54372,  -26.3305779,   29.4306221,     9.090909
  54373,  -25.4262104,   29.4306221,     9.090909
  54374,   -24.521841,   29.4306221,     9.090909
  54375,  -23.6174736,   29.4306221,     9.090909
  54376,  -22.7131042,   29.4306221,     9.090909
  54377,  -21.8087368,   29.4306221,     9.090909
  54378,  -20.9043674,   29.4306221,     9.090909
  54379,  -29.0826454,   30.2210522,     9.090909
  54380,  -28.1652889,   30.2210522,     9.090909
  54381,  -27.2479343,   30.2210522,     9.090909
  54382,  -26.3305779,   30.2210522,     9.090909
  54383,  -25.4262104,   30.2210522,     9.090909
  54384,   -24.521841,   30.2210522,     9.090909
  54385,  -23.6174736,   30.2210522,     9.090909
  54386,  -22.7131042,   30.2210522,     9.090909
  54387,  -21.8087368,   30.2210522,     9.090909
  54388,  -20.9043674,   30.2210522,     9.090909
  54389,  -29.0826454,   31.0114841,     9.090909
  54390,  -28.1652889,   31.0114841,     9.090909
  54391,  -27.2479343,   31.0114841,     9.090909
  54392,  -26.3305779,   31.0114841,     9.090909
  54393,  -25.4262104,   31.0114841,     9.090909
  54394,   -24.521841,   31.0114841,     9.090909
  54395,  -23.6174736,   31.0114841,     9.090909
  54396,  -22.7131042,   31.0114841,     9.090909
  54397,  -21.8087368,   31.0114841,     9.090909
  54398,  -20.9043674,   31.0114841,     9.090909
  54399,  -29.0826454,   31.8019142,     9.090909
  54400,  -28.1652889,   31.8019142,     9.090909
  54401,  -27.2479343,   31.8019142,     9.090909
  54402,  -26.3305779,   31.8019142,     9.090909
  54403,  -25.4262104,   31.8019142,     9.090909
  54404,   -24.521841,   31.8019142,     9.090909
  54405,  -23.6174736,   31.8019142,     9.090909
  54406,  -22.7131042,   31.8019142,     9.090909
  54407,  -21.8087368,   31.8019142,     9.090909
  54408,  -20.9043674,   31.8019142,     9.090909
  54409,  -29.0826454,   32.5923462,     9.090909
  54410,  -28.1652889,   32.5923462,     9.090909
  54411,  -27.2479343,   32.5923462,     9.090909
  54412,  -26.3305779,   32.5923462,     9.090909
  54413,  -25.4262104,   32.5923462,     9.090909
  54414,   -24.521841,   32.5923462,     9.090909
  54415,  -23.6174736,   32.5923462,     9.090909
  54416,  -22.7131042,   32.5923462,     9.090909
  54417,  -21.8087368,   32.5923462,     9.090909
  54418,  -20.9043674,   32.5923462,     9.090909
  54419,  -29.0826454,   33.3827744,     9.090909
  54420,  -28.1652889,   33.3827744,     9.090909
  54421,  -27.2479343,   33.3827744,     9.090909
  54422,  -26.3305779,   33.3827744,     9.090909
  54423,  -25.4262104,   33.3827744,     9.090909
  54424,   -24.521841,   33.3827744,     9.090909
  54425,  -23.6174736,   33.3827744,     9.090909
  54426,  -22.7131042,   33.3827744,     9.090909
  54427,  -21.8087368,   33.3827744,     9.090909
  54428,  -20.9043674,   33.3827744,     9.090909
  54429,  -29.0826454,   34.1732063,     9.090909
  54430,  -28.1652889,   34.1732063,     9.090909
  54431,  -27.2479343,   34.1732063,     9.090909
  54432,  -26.3305779,   34.1732063,     9.090909
  54433,  -25.4262104,   34.1732063,     9.090909
  54434,   -24.521841,   34.1732063,     9.090909
  54435,  -23.6174736,   34.1732063,     9.090909
  54436,  -22.7131042,   34.1732063,     9.090909
  54437,  -21.8087368,   34.1732063,     9.090909
  54438,  -20.9043674,   34.1732063,     9.090909
  54439,  -29.0826454,   34.9636345,     9.090909
  54440,  -28.1652889,   34.9636345,     9.090909
  54441,  -27.2479343,   34.9636345,     9.090909
  54442,  -26.3305779,   34.9636345,     9.090909
  54443,  -25.4262104,   34.9636345,     9.090909
  54444,   -24.521841,   34.9636345,     9.090909
  54445,  -23.6174736,   34.9636345,     9.090909
  54446,  -22.7131042,   34.9636345,     9.090909
  54447,  -21.8087368,   34.9636345,     9.090909
  54448,  -20.9043674,   34.9636345,     9.090909
  54449,  -29.0826454,   35.7540665,     9.090909
  54450,  -28.1652889,   35.7540665,     9.090909
  54451,  -27.2479343,   35.7540665,     9.090909
  54452,  -26.3305779,   35.7540665,     9.090909
  54453,  -25.4262104,   35.7540665,     9.090909
  54454,   -24.521841,   35.7540665,     9.090909
  54455,  -23.6174736,   35.7540665,     9.090909
  54456,  -22.7131042,   35.7540665,     9.090909
  54457,  -21.8087368,   35.7540665,     9.090909
  54458,  -20.9043674,   35.7540665,     9.090909
  54459,  -29.0826454,   36.5444984,     9.090909
  54460,  -28.1652889,   36.5444984,     9.090909
  54461,  -27.2479343,   36.5444984,     9.090909
  54462,  -26.3305779,   36.5444984,     9.090909
  54463,  -25.4262104,   36.5444984,     9.090909
  54464,   -24.521841,   36.5444984,     9.090909
  54465,  -23.6174736,   36.5444984,     9.090909
  54466,  -22.7131042,   36.5444984,     9.090909
  54467,  -21.8087368,   36.5444984,     9.090909
  54468,  -20.9043674,   36.5444984,     9.090909
  54469,  -29.0826454,   37.3349266,     9.090909
  54470,  -28.1652889,   37.3349266,     9.090909
  54471,  -27.2479343,   37.3349266,     9.090909
  54472,  -26.3305779,   37.3349266,     9.090909
  54473,  -25.4262104,   37.3349266,     9.090909
  54474,   -24.521841,   37.3349266,     9.090909
  54475,  -23.6174736,   37.3349266,     9.090909
  54476,  -22.7131042,   37.3349266,     9.090909
  54477,  -21.8087368,   37.3349266,     9.090909
  54478,  -20.9043674,   37.3349266,     9.090909
  54479,  -29.0826454,   38.1253586,     9.090909
  54480,  -28.1652889,   38.1253586,     9.090909
  54481,  -27.2479343,   38.1253586,     9.090909
  54482,  -26.3305779,   38.1253586,     9.090909
  54483,  -25.4262104,   38.1253586,     9.090909
  54484,   -24.521841,   38.1253586,     9.090909
  54485,  -23.6174736,   38.1253586,     9.090909
  54486,  -22.7131042,   38.1253586,     9.090909
  54487,  -21.8087368,   38.1253586,     9.090909
  54488,  -20.9043674,   38.1253586,     9.090909
  54489,  -29.0826454,   38.9157906,     9.090909
  54490,  -28.1652889,   38.9157906,     9.090909
  54491,  -27.2479343,   38.9157906,     9.090909
  54492,  -26.3305779,   38.9157906,     9.090909
  54493,  -25.4262104,   38.9157906,     9.090909
  54494,   -24.521841,   38.9157906,     9.090909
  54495,  -23.6174736,   38.9157906,     9.090909
  54496,  -22.7131042,   38.9157906,     9.090909
  54497,  -21.8087368,   38.9157906,     9.090909
  54498,  -20.9043674,   38.9157906,     9.090909
  54499,  -29.0826454,   39.7062187,     9.090909
  54500,  -28.1652889,   39.7062187,     9.090909
  54501,  -27.2479343,   39.7062187,     9.090909
  54502,  -26.3305779,   39.7062187,     9.090909
  54503,  -25.4262104,   39.7062187,     9.090909
  54504,   -24.521841,   39.7062187,     9.090909
  54505,  -23.6174736,   39.7062187,     9.090909
  54506,  -22.7131042,   39.7062187,     9.090909
  54507,  -21.8087368,   39.7062187,     9.090909
  54508,  -20.9043674,   39.7062187,     9.090909
  54509,  -29.0826454,   40.4966507,     9.090909
  54510,  -28.1652889,   40.4966507,     9.090909
  54511,  -27.2479343,   40.4966507,     9.090909
  54512,  -26.3305779,   40.4966507,     9.090909
  54513,  -25.4262104,   40.4966507,     9.090909
  54514,   -24.521841,   40.4966507,     9.090909
  54515,  -23.6174736,   40.4966507,     9.090909
  54516,  -22.7131042,   40.4966507,     9.090909
  54517,  -21.8087368,   40.4966507,     9.090909
  54518,  -20.9043674,   40.4966507,     9.090909
  54519,  -29.0826454,   41.2870827,     9.090909
  54520,  -28.1652889,   41.2870827,     9.090909
  54521,  -27.2479343,   41.2870827,     9.090909
  54522,  -26.3305779,   41.2870827,     9.090909
  54523,  -25.4262104,   41.2870827,     9.090909
  54524,   -24.521841,   41.2870827,     9.090909
  54525,  -23.6174736,   41.2870827,     9.090909
  54526,  -22.7131042,   41.2870827,     9.090909
  54527,  -21.8087368,   41.2870827,     9.090909
  54528,  -20.9043674,   41.2870827,     9.090909
  54529,  -29.0826454,   42.0775108,     9.090909
  54530,  -28.1652889,   42.0775108,     9.090909
  54531,  -27.2479343,   42.0775108,     9.090909
  54532,  -26.3305779,   42.0775108,     9.090909
  54533,  -25.4262104,   42.0775108,     9.090909
  54534,   -24.521841,   42.0775108,     9.090909
  54535,  -23.6174736,   42.0775108,     9.090909
  54536,  -22.7131042,   42.0775108,     9.090909
  54537,  -21.8087368,   42.0775108,     9.090909
  54538,  -20.9043674,   42.0775108,     9.090909
  54539,  -29.0826454,   42.8679428,     9.090909
  54540,  -28.1652889,   42.8679428,     9.090909
  54541,  -27.2479343,   42.8679428,     9.090909
  54542,  -26.3305779,   42.8679428,     9.090909
  54543,  -25.4262104,   42.8679428,     9.090909
  54544,   -24.521841,   42.8679428,     9.090909
  54545,  -23.6174736,   42.8679428,     9.090909
  54546,  -22.7131042,   42.8679428,     9.090909
  54547,  -21.8087368,   42.8679428,     9.090909
  54548,  -20.9043674,   42.8679428,     9.090909
  54549,  -29.0826454,   43.6583748,     9.090909
  54550,  -28.1652889,   43.6583748,     9.090909
  54551,  -27.2479343,   43.6583748,     9.090909
  54552,  -26.3305779,   43.6583748,     9.090909
  54553,  -25.4262104,   43.6583748,     9.090909
  54554,   -24.521841,   43.6583748,     9.090909
  54555,  -23.6174736,   43.6583748,     9.090909
  54556,  -22.7131042,   43.6583748,     9.090909
  54557,  -21.8087368,   43.6583748,     9.090909
  54558,  -20.9043674,   43.6583748,     9.090909
  54559,  -29.0826454,   44.4488029,     9.090909
  54560,  -28.1652889,   44.4488029,     9.090909
  54561,  -27.2479343,   44.4488029,     9.090909
  54562,  -26.3305779,   44.4488029,     9.090909
  54563,  -25.4262104,   44.4488029,     9.090909
  54564,   -24.521841,   44.4488029,     9.090909
  54565,  -23.6174736,   44.4488029,     9.090909
  54566,  -22.7131042,   44.4488029,     9.090909
  54567,  -21.8087368,   44.4488029,     9.090909
  54568,  -20.9043674,   44.4488029,     9.090909
  54569,  -29.0826454,   45.2392349,     9.090909
  54570,  -28.1652889,   45.2392349,     9.090909
  54571,  -27.2479343,   45.2392349,     9.090909
  54572,  -26.3305779,   45.2392349,     9.090909
  54573,  -25.4262104,   45.2392349,     9.090909
  54574,   -24.521841,   45.2392349,     9.090909
  54575,  -23.6174736,   45.2392349,     9.090909
  54576,  -22.7131042,   45.2392349,     9.090909
  54577,  -21.8087368,   45.2392349,     9.090909
  54578,  -20.9043674,   45.2392349,     9.090909
  54579,  -29.0840225,   46.0326958,     9.090909
  54580,  -28.1680431,   46.0326958,     9.090909
  54581,  -27.2520676,   46.0326958,     9.090909
  54582,  -26.3360882,   46.0326958,     9.090909
  54583,   -25.430933,   46.0326958,     9.090909
  54584,  -24.5257759,   46.0326958,     9.090909
  54585,  -23.6206226,   46.0326958,     9.090909
  54586,  -22.7154655,   46.0326958,     9.090909
  54587,  -21.8103104,   46.0326958,     9.090909
  54588,  -20.9051552,   46.0326958,     9.090909
  54589,  -29.0853996,   46.8261566,     9.090909
  54590,  -28.1707993,   46.8261566,     9.090909
  54591,  -27.2561989,   46.8261566,     9.090909
  54592,  -26.3415966,   46.8261566,     9.090909
  54593,  -25.4356556,   46.8261566,     9.090909
  54594,  -24.5297127,   46.8261566,     9.090909
  54595,  -23.6237698,   46.8261566,     9.090909
  54596,  -22.7178268,   46.8261566,     9.090909
  54597,  -21.8118858,   46.8261566,     9.090909
  54598,   -20.905941,   46.8261566,     9.090909
  54599,  -29.0867767,   47.6196175,     9.090909
  54600,  -28.1735535,   47.6196175,     9.090909
  54601,  -27.2603321,   47.6196175,     9.090909
  54602,  -26.3471069,   47.6196175,     9.090909
  54603,  -25.4403782,   47.6196175,     9.090909
  54604,  -24.5336475,   47.6196175,     9.090909
  54605,  -23.6269188,   47.6196175,     9.090909
  54606,  -22.7201881,   47.6196175,     9.090909
  54607,  -21.8134594,   47.6196175,     9.090909
  54608,  -20.9067287,   47.6196175,     9.090909
  54609,  -29.0881557,   48.4130783,     9.090909
  54610,  -28.1763077,   48.4130783,     9.090909
  54611,  -27.2644634,   48.4130783,     9.090909
  54612,  -26.3526173,   48.4130783,     9.090909
  54613,  -25.4451008,   48.4130783,     9.090909
  54614,  -24.5375824,   48.4130783,     9.090909
  54615,  -23.6300678,   48.4130783,     9.090909
  54616,  -22.7225494,   48.4130783,     9.090909
  54617,   -21.815033,   48.4130783,     9.090909
  54618,  -20.9075165,   48.4130783,     9.090909
  54619,  -29.0895329,   49.2065392,     9.090909
  54620,  -28.1790638,   49.2065392,     9.090909
  54621,  -27.2685947,   49.2065392,     9.090909
  54622,  -26.3581257,   49.2065392,     9.090909
  54623,  -25.4498234,   49.2065392,     9.090909
  54624,  -24.5415192,   49.2065392,     9.090909
  54625,   -23.633215,   49.2065392,     9.090909
  54626,  -22.7249107,   49.2065392,     9.090909
  54627,  -21.8166084,   49.2065392,     9.090909
  54628,  -20.9083023,   49.2065392,     9.090909
  54629,  -22.2465725,   15.9132528,   5.37313366
  54630,  -22.8584461,   15.9132528,   5.37313366
  54631,  -23.4703178,   15.9132528,   5.37313366
  54632,  -24.0821915,   15.9132528,   5.37313366
  54633,  -24.6940651,   15.9132528,   5.37313318
  54634,  -25.3059368,   15.9132528,   5.37313318
  54635,  -25.9178085,   15.9132528,   5.37313318
  54636,  -26.5296822,   15.9132528,   5.37313318
  54637,  -27.1415558,   15.9132528,   5.37313318
  54638,  -27.7534294,   15.9132538,   5.37313318
  54639,  -22.2560062,    15.884428,    5.8358202
  54640,  -22.8657837,    15.884428,    5.8358202
  54641,  -23.4755592,    15.884428,    5.8358202
  54642,  -24.0853348,    15.884428,    5.8358202
  54643,  -24.6951122,    15.884428,    5.8358202
  54644,  -25.3048897,    15.884428,    5.8358202
  54645,  -25.9146652,    15.884428,    5.8358202
  54646,  -26.5244408,    15.884428,    5.8358202
  54647,  -27.1342182,    15.884428,    5.8358202
  54648,  -27.7439957,    15.884429,    5.8358202
  54649,    -22.26544,   15.8556023,   6.29850721
  54650,  -22.8731194,   15.8556023,   6.29850721
  54651,  -23.4807987,   15.8556023,   6.29850721
  54652,    -24.08848,   15.8556023,   6.29850721
  54653,  -24.6961613,   15.8556023,   6.29850674
  54654,  -25.3038406,   15.8556023,   6.29850674
  54655,    -25.91152,   15.8556023,   6.29850674
  54656,  -26.5192013,   15.8556023,   6.29850674
  54657,  -27.1268806,   15.8556023,   6.29850674
  54658,  -27.7345619,   15.8556032,   6.29850674
  54659,  -22.2748737,   15.8267775,   6.76119375
  54660,  -22.8804569,   15.8267765,   6.76119375
  54661,  -23.4860401,   15.8267765,   6.76119375
  54662,  -24.0916233,   15.8267765,   6.76119375
  54663,  -24.6972084,   15.8267775,   6.76119328
  54664,  -25.3027916,   15.8267775,   6.76119328
  54665,  -25.9083767,   15.8267775,   6.76119328
  54666,  -26.5139599,   15.8267775,   6.76119328
  54667,   -27.119545,   15.8267775,   6.76119328
  54668,  -27.7251282,   15.8267775,   6.76119328
  54669,  -22.2843094,   15.7979517,   7.22388029
  54670,  -22.8877964,   15.7979517,   7.22388029
  54671,  -23.4912834,   15.7979517,   7.22388029
  54672,  -24.0947704,   15.7979517,   7.22388029
  54673,  -24.6982574,   15.7979517,   7.22387981
  54674,  -25.3017445,   15.7979517,   7.22387981
  54675,  -25.9052315,   15.7979517,   7.22387981
  54676,  -26.5087185,   15.7979517,   7.22387981
  54677,  -27.1122074,   15.7979517,   7.22387981
  54678,  -27.7156944,   15.7979527,   7.22387981
  54679,  -22.2937412,   15.7691259,   7.68656683
  54680,  -22.8951321,   15.7691259,   7.68656683
  54681,  -23.4965229,   15.7691259,   7.68656683
  54682,  -24.0979137,   15.7691259,   7.68656683
  54683,  -24.6993065,   15.7691269,   7.68656683
  54684,  -25.3006973,   15.7691269,   7.68656683
  54685,  -25.9020882,   15.7691269,   7.68656683
  54686,   -26.503479,   15.7691269,   7.68656683
  54687,  -27.1048698,   15.7691269,   7.68656683
  54688,  -27.7062607,   15.7691269,   7.68656683
  54689,   -22.303175,   15.7403011,   8.14925385
  54690,  -22.9024696,   15.7403011,   8.14925385
  54691,  -23.5017643,   15.7403011,   8.14925385
  54692,   -24.101059,   15.7403011,   8.14925385
  54693,  -24.7003536,   15.7403021,   8.14925289
  54694,  -25.2996483,   15.7403021,   8.14925289
  54695,  -25.8989429,   15.7403021,   8.14925289
  54696,  -26.4982376,   15.7403021,   8.14925289
  54697,  -27.0975323,   15.7403021,   8.14925289
  54698,  -27.6968269,   15.7403021,   8.14925289
  54699,  -22.3126087,   15.7114754,   8.61194038
  54700,  -22.9098072,   15.7114754,   8.61194038
  54701,  -23.5070057,   15.7114754,   8.61194038
  54702,  -24.1042023,   15.7114754,   8.61194038
  54703,  -24.7014008,   15.7114763,   8.61194038
  54704,  -25.2985992,   15.7114763,   8.61194038
  54705,  -25.8957977,   15.7114763,   8.61194038
  54706,  -26.4929943,   15.7114763,   8.61194038
  54707,  -27.0901947,   15.7114763,   8.61194038
  54708,  -27.6873913,   15.7114763,   8.61194038
  54709,  -22.3220425,   15.6826506,   9.07462692
  54710,  -22.9171429,   15.6826506,   9.07462692
  54711,  -23.5122452,   15.6826506,   9.07462692
  54712,  -24.1073475,   15.6826506,   9.07462692
  54713,  -24.7024498,   15.6826506,   9.07462692
  54714,  -25.2975502,   15.6826506,   9.07462692
  54715,  -25.8926525,   15.6826506,   9.07462692
  54716,  -26.4877548,   15.6826506,   9.07462692
  54717,  -27.0828571,   15.6826506,   9.07462692
  54718,  -27.6779575,   15.6826506,   9.07462692
  54719,  -22.3314762,   15.6538248,   9.53731346
  54720,  -22.9244804,   15.6538248,   9.53731346
  54721,  -23.5174866,   15.6538248,   9.53731346
  54722,  -24.1104908,   15.6538248,   9.53731346
  54723,  -24.7034969,   15.6538258,   9.53731346
  54724,  -25.2965031,   15.6538258,   9.53731346
  54725,  -25.8895092,   15.6538258,   9.53731346
  54726,  -26.4825134,   15.6538258,   9.53731346
  54727,  -27.0755196,   15.6538258,   9.53731346
  54728,  -27.6685238,   15.6538258,   9.53731346
  54729,   -21.956461,   16.7997017,   5.13026857
  54730,   -22.632803,   16.7997017,   5.13026857
  54731,   -23.309145,   16.7997017,   5.13026857
  54732,   -23.985487,   16.7997017,   5.13026857
  54733,   -24.661829,   16.7997017,   5.13026857
  54734,   -25.338171,   16.7997017,   5.13026857
  54735,   -26.014513,   16.7996998,   5.13026905
  54736,   -26.690855,   16.7997017,    5.1302681
  54737,   -27.367197,   16.7997017,    5.1302681
  54738,   -28.043539,   16.7997017,    5.1302681
  54739,  -21.9744511,   16.7447319,   5.61724186
  54740,  -22.6467953,   16.7447319,   5.61724186
  54741,  -23.3191395,   16.7447319,   5.61724186
  54742,  -23.9914837,   16.7447319,   5.61724186
  54743,  -24.6638279,   16.7447319,   5.61724186
  54744,  -25.3361721,   16.7447319,   5.61724186
  54745,  -26.0085163,     16.74473,   5.61724186
  54746,  -26.6808605,   16.7447319,   5.61724138
  54747,  -27.3532047,   16.7447319,   5.61724138
  54748,  -28.0255489,   16.7447319,   5.61724138
  54749,  -21.9924431,   16.6897602,   6.10421515
  54750,  -22.6607895,   16.6897602,   6.10421515
  54751,  -23.3291359,   16.6897602,   6.10421515
  54752,  -23.9974823,   16.6897602,   6.10421515
  54753,  -24.6658287,   16.6897602,   6.10421515
  54754,  -25.3341732,   16.6897602,   6.10421515
  54755,  -26.0025196,   16.6897602,   6.10421515
  54756,   -26.670866,   16.6897621,   6.10421467
  54757,  -27.3392124,   16.6897621,   6.10421467
  54758,  -28.0075588,   16.6897621,   6.10421467
  54759,  -22.0104332,   16.6347904,   6.59118795
  54760,  -22.6747818,   16.6347904,   6.59118795
  54761,  -23.3391304,   16.6347904,   6.59118795
  54762,   -24.003479,   16.6347904,   6.59118795
  54763,  -24.6678276,   16.6347904,   6.59118843
  54764,  -25.3321743,   16.6347904,   6.59118843
  54765,  -25.9965229,   16.6347904,   6.59118843
  54766,  -26.6608715,   16.6347923,   6.59118795
  54767,  -27.3252201,   16.6347923,   6.59118795
  54768,  -27.9895687,   16.6347923,   6.59118795
  54769,  -22.0284233,   16.5798206,   7.07816124
  54770,  -22.6887741,   16.5798206,   7.07816124
  54771,   -23.349123,   16.5798206,   7.07816124
  54772,  -24.0094738,   16.5798206,   7.07816124
  54773,  -24.6698246,   16.5798206,   7.07816124
  54774,  -25.3301754,   16.5798206,   7.07816124
  54775,  -25.9905262,   16.5798206,   7.07816124
  54776,   -26.650877,   16.5798206,   7.07816076
  54777,  -27.3112259,   16.5798206,   7.07816076
  54778,  -27.9715767,   16.5798206,   7.07816076
  54779,  -22.0464134,   16.5248508,   7.56513453
  54780,  -22.7027664,   16.5248508,   7.56513453
  54781,  -23.3591175,   16.5248508,   7.56513453
  54782,  -24.0154705,   16.5248508,   7.56513453
  54783,  -24.6718235,   16.5248508,   7.56513453
  54784,  -25.3281765,   16.5248508,   7.56513453
  54785,  -25.9845295,   16.5248508,   7.56513453
  54786,  -26.6408825,   16.5248508,   7.56513405
  54787,  -27.2972336,   16.5248508,   7.56513405
  54788,  -27.9535866,   16.5248508,   7.56513405
  54789,  -22.0644035,   16.4698811,   8.05210781
  54790,  -22.7167587,   16.4698811,   8.05210781
  54791,   -23.369112,   16.4698811,   8.05210781
  54792,  -24.0214672,   16.4698811,   8.05210781
  54793,  -24.6738224,   16.4698811,   8.05210781
  54794,  -25.3261776,   16.4698811,   8.05210781
  54795,  -25.9785328,   16.4698811,   8.05210781
  54796,   -26.630888,   16.4698811,   8.05210686
  54797,  -27.2832413,   16.4698811,   8.05210686
  54798,  -27.9355965,   16.4698811,   8.05210686
  54799,  -22.0823936,   16.4149113,   8.53908062
  54800,   -22.730751,   16.4149113,   8.53908062
  54801,  -23.3791065,   16.4149113,   8.53908062
  54802,  -24.0274639,   16.4149113,   8.53908062
  54803,  -24.6758213,   16.4149113,   8.53908062
  54804,  -25.3241787,   16.4149113,   8.53908062
  54805,  -25.9725361,   16.4149113,   8.53908062
  54806,  -26.6208935,   16.4149113,   8.53908062
  54807,   -27.269249,   16.4149113,   8.53908062
  54808,  -27.9176064,   16.4149113,   8.53908062
  54809,  -22.1003838,   16.3599396,   9.02605343
  54810,  -22.7447433,   16.3599396,   9.02605343
  54811,   -23.389101,   16.3599396,   9.02605343
  54812,  -24.0334606,   16.3599396,   9.02605343
  54813,  -24.6778202,   16.3599396,   9.02605343
  54814,  -25.3221798,   16.3599396,   9.02605343
  54815,  -25.9665394,   16.3599396,   9.02605343
  54816,   -26.610899,   16.3599396,   9.02605343
  54817,  -27.2552567,   16.3599396,   9.02605343
  54818,  -27.8996162,   16.3599396,   9.02605343
  54819,  -22.1183739,   16.3049698,   9.51302719
  54820,  -22.7587357,   16.3049698,   9.51302719
  54821,  -23.3990955,   16.3049698,   9.51302719
  54822,  -24.0394573,   16.3049698,   9.51302719
  54823,  -24.6798191,   16.3049698,   9.51302719
  54824,  -25.3201809,   16.3049698,   9.51302719
  54825,  -25.9605427,   16.3049698,   9.51302719
  54826,  -26.6009045,   16.3049698,   9.51302719
  54827,  -27.2412643,   16.3049698,   9.51302719
  54828,  -27.8816261,   16.3049698,   9.51302719
  54829,  -21.6841125,   17.6318855,   4.73041439
  54830,  -22.4209766,   17.6318855,   4.73041439
  54831,  -23.1578407,   17.6318855,   4.73041439
  54832,  -23.8947048,   17.6318855,   4.73041439
  54833,  -24.6315689,   17.6318855,   4.73041439
  54834,   -25.368433,   17.6318855,   4.73041391
  54835,  -26.1052971,   17.6318855,   4.73041391
  54836,  -26.8421612,   17.6318855,   4.73041391
  54837,  -27.5790253,   17.6318855,   4.73041391
  54838,  -28.3158913,   17.6318855,   4.73041391
  54839,  -21.7088814,   17.5561981,   5.25737286
  54840,  -22.4402409,   17.5561981,   5.25737286
  54841,  -23.1716003,   17.5561981,   5.25737286
  54842,  -23.9029598,   17.5561981,   5.25737286
  54843,  -24.6343212,   17.5561981,   5.25737286
  54844,  -25.3656807,   17.5561981,   5.25737286
  54845,  -26.0970402,   17.5561962,   5.25737286
  54846,  -26.8283997,   17.5561962,   5.25737286
  54847,  -27.5597591,   17.5561962,   5.25737286
  54848,  -28.2911205,   17.5561962,   5.25737286
  54849,   -21.733654,   17.4805088,   5.78433132
  54850,   -22.459507,   17.4805088,   5.78433132
  54851,  -23.1853619,   17.4805088,   5.78433132
  54852,  -23.9112167,   17.4805088,   5.78433132
  54853,  -24.6370735,   17.4805088,   5.78433132
  54854,  -25.3629284,   17.4805088,   5.78433132
  54855,  -26.0887833,   17.4805088,   5.78433132
  54856,  -26.8146381,   17.4805069,   5.78433132
  54857,   -27.540493,   17.4805069,   5.78433132
  54858,  -28.2663479,   17.4805069,   5.78433132
  54859,  -21.7584248,   17.4048195,   6.31128979
  54860,   -22.478775,   17.4048195,   6.31128979
  54861,  -23.1991253,   17.4048195,   6.31128979
  54862,  -23.9194756,   17.4048195,   6.31128979
  54863,  -24.6398258,   17.4048195,   6.31128979
  54864,  -25.3601761,   17.4048195,   6.31128979
  54865,  -26.0805264,   17.4048195,   6.31128979
  54866,  -26.8008766,   17.4048195,   6.31128979
  54867,  -27.5212269,   17.4048195,   6.31128979
  54868,  -28.2415791,   17.4048195,   6.31128979
  54869,  -21.7831936,   17.3291321,   6.83824873
  54870,  -22.4980392,   17.3291321,   6.83824873
  54871,  -23.2128849,   17.3291321,   6.83824873
  54872,  -23.9277306,   17.3291321,   6.83824873
  54873,  -24.6425781,   17.3291321,   6.83824873
  54874,  -25.3574238,   17.3291321,   6.83824873
  54875,  -26.0722694,   17.3291321,   6.83824873
  54876,  -26.7871151,   17.3291321,   6.83824873
  54877,  -27.5019608,   17.3291321,   6.83824873
  54878,  -28.2168064,   17.3291321,   6.83824873
  54879,  -21.8079643,   17.2534428,    7.3652072
  54880,  -22.5173054,   17.2534428,    7.3652072
  54881,  -23.2266464,   17.2534428,    7.3652072
  54882,  -23.9359875,   17.2534428,    7.3652072
  54883,  -24.6453285,   17.2534428,    7.3652072
  54884,  -25.3546715,   17.2534428,    7.3652072
  54885,  -26.0640125,   17.2534428,    7.3652072
  54886,  -26.7733536,   17.2534428,    7.3652072
  54887,  -27.4826946,   17.2534428,    7.3652072
  54888,  -28.1920357,   17.2534428,    7.3652072
  54889,  -21.8327351,   17.1777554,   7.89216566
  54890,  -22.5365715,   17.1777554,   7.89216566
  54891,  -23.2404079,   17.1777554,   7.89216566
  54892,  -23.9442444,   17.1777554,   7.89216566
  54893,  -24.6480808,   17.1777554,   7.89216566
  54894,  -25.3519192,   17.1777554,   7.89216566
  54895,  -26.0557556,   17.1777554,   7.89216566
  54896,  -26.7595921,   17.1777554,   7.89216566
  54897,  -27.4634285,   17.1777554,   7.89216518
  54898,  -28.1672649,   17.1777554,   7.89216518
  54899,  -21.8575058,    17.102066,    8.4191246
  54900,  -22.5558376,    17.102066,    8.4191246
  54901,  -23.2541695,    17.102066,    8.4191246
  54902,  -23.9525013,    17.102066,    8.4191246
  54903,  -24.6508331,    17.102066,    8.4191246
  54904,  -25.3491669,    17.102066,    8.4191246
  54905,  -26.0474987,    17.102066,   8.41912365
  54906,  -26.7458305,    17.102066,   8.41912365
  54907,  -27.4441624,    17.102066,   8.41912365
  54908,  -28.1424942,    17.102066,   8.41912365
  54909,  -21.8822765,   17.0263767,   8.94608307
  54910,  -22.5751038,   17.0263767,   8.94608307
  54911,   -23.267931,   17.0263767,   8.94608307
  54912,  -23.9607582,   17.0263767,   8.94608307
  54913,  -24.6535854,   17.0263767,   8.94608307
  54914,  -25.3464146,   17.0263767,   8.94608307
  54915,  -26.0392418,   17.0263767,   8.94608307
  54916,   -26.732069,   17.0263767,   8.94608307
  54917,  -27.4248962,   17.0263767,   8.94608307
  54918,  -28.1177235,   17.0263767,   8.94608307
  54919,  -21.9070473,   16.9506893,   9.47304153
  54920,  -22.5943699,   16.9506893,   9.47304153
  54921,  -23.2816925,   16.9506893,   9.47304153
  54922,  -23.9690151,   16.9506893,   9.47304153
  54923,  -24.6563377,   16.9506893,   9.47304153
  54924,  -25.3436623,   16.9506893,   9.47304153
  54925,  -26.0309849,   16.9506893,   9.47304153
  54926,  -26.7183075,   16.9506893,   9.47304153
  54927,  -27.4056301,   16.9506893,   9.47304153
  54928,  -28.0929527,   16.9506893,   9.47304153
  54929,  -21.4388332,     18.38134,   4.18216562
  54930,  -22.2302055,   18.3813419,   4.18216515
  54931,   -23.021574,   18.3813419,   4.18216515
  54932,  -23.8129425,   18.3813419,   4.18216515
  54933,  -24.6043148,     18.38134,   4.18216515
  54934,  -25.3956833,     18.38134,   4.18216467
  54935,  -26.1870556,     18.38134,   4.18216467
  54936,  -26.9784241,     18.38134,   4.18216467
  54937,  -27.7697945,     18.38134,   4.18216467
  54938,  -28.5611649,     18.38134,   4.18216467
  54939,  -21.4676781,   18.2932053,   4.76394939
  54940,  -22.2526398,   18.2932072,   4.76394844
  54941,  -23.0375996,   18.2932072,   4.76394844
  54942,  -23.8225594,   18.2932072,   4.76394844
  54943,  -24.6075211,   18.2932072,   4.76394844
  54944,  -25.3924809,   18.2932072,   4.76394844
  54945,  -26.1774406,   18.2932072,   4.76394844
  54946,  -26.9624004,   18.2932072,   4.76394844
  54947,  -27.7473621,   18.2932072,   4.76394844
  54948,  -28.5323219,   18.2932072,   4.76394844
  54949,   -21.496521,   18.2050724,   5.34573269
  54950,   -22.275074,   18.2050743,   5.34573221
  54951,  -23.0536232,   18.2050743,   5.34573221
  54952,  -23.8321724,   18.2050724,   5.34573221
  54953,  -24.6107235,   18.2050724,   5.34573221
  54954,  -25.3892746,   18.2050724,   5.34573174
  54955,  -26.1678257,   18.2050724,   5.34573174
  54956,  -26.9463749,   18.2050724,   5.34573174
  54957,   -27.724926,   18.2050724,   5.34573174
  54958,  -28.5034771,   18.2050724,   5.34573174
  54959,  -21.5253658,   18.1169376,   5.92751598
  54960,  -22.2975082,   18.1169395,   5.92751551
  54961,  -23.0696468,   18.1169376,   5.92751551
  54962,  -23.8417873,   18.1169376,   5.92751551
  54963,  -24.6139297,   18.1169376,   5.92751551
  54964,  -25.3860703,   18.1169376,   5.92751551
  54965,  -26.1582108,   18.1169376,   5.92751551
  54966,  -26.9303513,   18.1169376,   5.92751551
  54967,  -27.7024918,   18.1169376,   5.92751551
  54968,  -28.4746342,   18.1169376,   5.92751551
  54969,  -21.5542088,   18.0288048,   6.50929928
  54970,  -22.3199406,   18.0288048,    6.5092988
  54971,  -23.0856724,   18.0288048,    6.5092988
  54972,  -23.8514023,   18.0288048,    6.5092988
  54973,  -24.6171341,   18.0288048,    6.5092988
  54974,   -25.382864,   18.0288048,    6.5092988
  54975,  -26.1485977,   18.0288048,    6.5092988
  54976,  -26.9143276,   18.0288048,    6.5092988
  54977,  -27.6800594,   18.0288048,    6.5092988
  54978,  -28.4457893,   18.0288048,    6.5092988
  54979,  -21.5830536,     17.94067,   7.09108305
  54980,  -22.3423748,     17.94067,   7.09108257
  54981,   -23.101696,     17.94067,   7.09108257
  54982,  -23.8610172,     17.94067,   7.09108257
  54983,  -24.6203384,     17.94067,   7.09108257
  54984,  -25.3796597,     17.94067,   7.09108257
  54985,  -26.1389828,     17.94067,   7.09108257
  54986,  -26.8983021,     17.94067,   7.09108257
  54987,  -27.6576252,     17.94067,   7.09108257
  54988,  -28.4169464,     17.94067,   7.09108257
  54989,  -21.6118965,   17.8525352,   7.67286634
  54990,   -22.364809,   17.8525352,   7.67286587
  54991,  -23.1177197,   17.8525372,   7.67286587
  54992,  -23.8706322,   17.8525372,   7.67286587
  54993,  -24.6235447,   17.8525372,   7.67286587
  54994,  -25.3764553,   17.8525372,   7.67286587
  54995,  -26.1293678,   17.8525372,   7.67286587
  54996,  -26.8822784,   17.8525372,   7.67286587
  54997,   -27.635191,   17.8525372,   7.67286587
  54998,  -28.3881016,   17.8525372,   7.67286587
  54999,  -21.6407413,   17.7644024,   8.25465012
  55000,  -22.3872433,   17.7644024,   8.25465012
  55001,  -23.1337452,   17.7644024,   8.25465012
  55002,  -23.8802452,   17.7644024,   8.25465012
  55003,   -24.626749,   17.7644024,   8.25464916
  55004,   -25.373251,   17.7644024,   8.25464916
  55005,  -26.1197529,   17.7644024,   8.25464916
  55006,  -26.8662548,   17.7644024,   8.25464916
  55007,  -27.6127567,   17.7644024,   8.25464916
  55008,  -28.3592587,   17.7644024,   8.25464916
  55009,  -21.6695843,   17.6762676,   8.83643341
  55010,  -22.4096775,   17.6762676,   8.83643341
  55011,  -23.1497688,   17.6762676,   8.83643341
  55012,  -23.8898602,   17.6762676,   8.83643341
  55013,  -24.6299534,   17.6762676,   8.83643341
  55014,  -25.3700447,   17.6762676,   8.83643341
  55015,  -26.1101398,   17.6762676,   8.83643341
  55016,  -26.8502312,   17.6762676,   8.83643341
  55017,  -27.5903225,   17.6762676,   8.83643341
  55018,  -28.3304157,   17.6762676,   8.83643341
  55019,  -21.6984291,   17.5881348,   9.41821671
  55020,  -22.4321117,   17.5881348,   9.41821671
  55021,  -23.1657944,   17.5881348,   9.41821671
  55022,  -23.8994751,   17.5881348,   9.41821671
  55023,  -24.6331596,   17.5881348,   9.41821671
  55024,  -25.3668404,   17.5881348,   9.41821671
  55025,  -26.1005249,   17.5881348,   9.41821671
  55026,  -26.8342056,   17.5881348,   9.41821671
  55027,  -27.5678883,   17.5881348,   9.41821671
  55028,  -28.3015709,   17.5881348,   9.41821671
  55029,  -21.2301636,   19.0189476,    3.4998455
  55030,  -22.0679054,   19.0189476,    3.4998455
  55031,  -22.9056473,   19.0189476,    3.4998455
  55032,  -23.7433872,   19.0189476,    3.4998455
  55033,  -24.5811291,   19.0189476,    3.4998455
  55034,  -25.4188709,   19.0189476,   3.49984527
  55035,  -26.2566128,   19.0189476,   3.49984527
  55036,  -27.0943527,   19.0189476,   3.49984527
  55037,  -27.9320946,   19.0189476,   3.49984527
  55038,  -28.7698364,   19.0189476,   3.49984527
  55039,  -21.2594204,   18.9295521,   4.14986086
  55040,  -22.0906582,   18.9295521,   4.14986086
  55041,  -22.9218998,   18.9295521,   4.14986086
  55042,  -23.7531395,   18.9295521,   4.14986086
  55043,  -24.5843811,   18.9295521,   4.14986086
  55044,  -25.4156189,   18.9295521,   4.14986086
  55045,  -26.2468605,   18.9295521,   4.14986086
  55046,  -27.0781002,   18.9295521,   4.14986086
  55047,  -27.9093418,   18.9295521,   4.14986086
  55048,  -28.7405796,   18.9295521,   4.14986038
  55049,  -21.2886772,   18.8401566,   4.79987621
  55050,  -22.1134148,   18.8401566,   4.79987621
  55051,  -22.9381542,   18.8401566,   4.79987621
  55052,  -23.7628937,   18.8401566,   4.79987621
  55053,  -24.5876312,   18.8401566,   4.79987621
  55054,  -25.4123707,   18.8401585,   4.79987621
  55055,  -26.2371082,   18.8401585,   4.79987621
  55056,  -27.0618477,   18.8401585,   4.79987621
  55057,  -27.8865871,   18.8401585,   4.79987621
  55058,  -28.7113247,   18.8401585,   4.79987621
  55059,  -21.3179321,   18.7507629,   5.44989204
  55060,  -22.1361694,   18.7507629,   5.44989204
  55061,  -22.9544067,   18.7507629,   5.44989204
  55062,   -23.772644,   18.7507629,   5.44989204
  55063,  -24.5908813,   18.7507629,   5.44989204
  55064,  -25.4091187,   18.7507629,   5.44989204
  55065,   -26.227356,   18.7507629,   5.44989204
  55066,  -27.0455933,   18.7507629,   5.44989204
  55067,  -27.8638306,   18.7507629,   5.44989157
  55068,  -28.6820679,   18.7507629,   5.44989157
  55069,  -21.3471909,   18.6613674,    6.0999074
  55070,  -22.1589241,   18.6613674,    6.0999074
  55071,  -22.9706612,   18.6613674,    6.0999074
  55072,  -23.7823963,   18.6613674,    6.0999074
  55073,  -24.5941315,   18.6613674,    6.0999074
  55074,  -25.4058685,   18.6613674,    6.0999074
  55075,  -26.2176037,   18.6613674,    6.0999074
  55076,  -27.0293388,   18.6613674,   6.09990692
  55077,  -27.8410759,   18.6613674,   6.09990692
  55078,  -28.6528091,   18.6613674,   6.09990692
  55079,  -21.3764458,   18.5719738,   6.74992275
  55080,  -22.1816788,   18.5719738,   6.74992275
  55081,  -22.9869137,   18.5719738,   6.74992275
  55082,  -23.7921486,   18.5719738,   6.74992275
  55083,  -24.5973835,   18.5719738,   6.74992275
  55084,  -25.4026165,   18.5719738,   6.74992275
  55085,  -26.2078514,   18.5719738,   6.74992275
  55086,  -27.0130863,   18.5719738,   6.74992275
  55087,  -27.8183212,   18.5719738,   6.74992275
  55088,  -28.6235542,   18.5719738,   6.74992275
  55089,  -21.4057026,   18.4825783,   7.39993811
  55090,  -22.2044334,   18.4825783,   7.39993811
  55091,  -23.0031681,   18.4825783,   7.39993811
  55092,  -23.8019009,   18.4825783,   7.39993811
  55093,  -24.6006336,   18.4825783,   7.39993811
  55094,  -25.3993664,   18.4825783,   7.39993811
  55095,  -26.1980991,   18.4825783,   7.39993811
  55096,  -26.9968319,   18.4825783,   7.39993811
  55097,  -27.7955666,   18.4825783,   7.39993811
  55098,  -28.5942974,   18.4825783,   7.39993811
  55099,  -21.4349594,   18.3931847,   8.04995346
  55100,    -22.22719,   18.3931847,   8.04995346
  55101,  -23.0194225,   18.3931847,   8.04995346
  55102,  -23.8116531,   18.3931847,   8.04995346
  55103,  -24.6038837,   18.3931847,   8.04995346
  55104,  -25.3961163,   18.3931847,   8.04995346
  55105,  -26.1883469,   18.3931847,   8.04995346
  55106,  -26.9805775,   18.3931847,   8.04995346
  55107,    -27.77281,   18.3931847,   8.04995346
  55108,  -28.5650406,   18.3931847,   8.04995346
  55109,  -21.4642143,   18.3037891,   8.69996929
  55110,  -22.2499447,   18.3037891,   8.69996929
  55111,   -23.035675,   18.3037891,   8.69996929
  55112,  -23.8214054,   18.3037891,   8.69996929
  55113,  -24.6071339,   18.3037891,   8.69996929
  55114,  -25.3928661,   18.3037891,   8.69996929
  55115,  -26.1785946,   18.3037891,   8.69996929
  55116,   -26.964325,   18.3037891,   8.69996929
  55117,  -27.7500553,   18.3037891,   8.69996929
  55118,  -28.5357857,   18.3037891,   8.69996929
  55119,  -21.4934711,   18.2143955,   9.34998417
  55120,  -22.2726974,   18.2143955,   9.34998417
  55121,  -23.0519276,   18.2143955,   9.34998417
  55122,  -23.8311577,   18.2143955,   9.34998417
  55123,  -24.6103859,   18.2143955,   9.34998417
  55124,  -25.3896141,   18.2143955,   9.34998417
  55125,  -26.1688423,   18.2143955,   9.34998417
  55126,  -26.9480724,   18.2143955,   9.34998417
  55127,  -27.7273026,   18.2143955,   9.34998417
  55128,  -28.5065289,   18.2143955,   9.34998417
  55129,  -21.0673542,   19.5164204,   2.70527005
  55130,  -21.9412746,   19.5164204,   2.70527005
  55131,   -22.815197,   19.5164204,   2.70527005
  55132,  -23.6891193,   19.5164204,   2.70527005
  55133,  -24.5630398,   19.5164204,   2.70526981
  55134,  -25.4369602,   19.5164204,   2.70526981
  55135,  -26.3108807,   19.5164204,   2.70526981
  55136,   -27.184803,   19.5164204,   2.70526981
  55137,  -28.0587254,   19.5164204,   2.70526981
  55138,  -28.9326458,   19.5164204,   2.70526981
  55139,  -21.0924358,   19.4397793,   3.43474317
  55140,  -21.9607849,   19.4397793,   3.43474317
  55141,  -22.8291321,   19.4397793,   3.43474317
  55142,  -23.6974792,   19.4397793,   3.43474317
  55143,  -24.5658264,   19.4397793,   3.43474293
  55144,  -25.4341736,   19.4397793,   3.43474293
  55145,  -26.3025208,   19.4397793,   3.43474317
  55146,  -27.1708679,   19.4397793,   3.43474317
  55147,  -28.0392151,   19.4397793,   3.43474293
  55148,  -28.9075642,   19.4397793,   3.43474293
  55149,  -21.1175194,   19.3631363,   4.16421604
  55150,  -21.9802933,   19.3631363,   4.16421604
  55151,  -22.8430672,   19.3631363,   4.16421604
  55152,  -23.7058411,   19.3631363,   4.16421604
  55153,   -24.568615,   19.3631363,   4.16421604
  55154,   -25.431385,   19.3631363,   4.16421604
  55155,  -26.2941589,   19.3631363,   4.16421604
  55156,  -27.1569328,   19.3631363,   4.16421604
  55157,  -28.0197067,   19.3631363,   4.16421604
  55158,  -28.8824806,   19.3631363,   4.16421604
  55159,  -21.1426029,   19.2864952,   4.89368916
  55160,  -21.9998016,   19.2864952,   4.89368916
  55161,  -22.8570023,   19.2864952,   4.89368916
  55162,   -23.714201,   19.2864952,   4.89368916
  55163,  -24.5714016,   19.2864952,   4.89368916
  55164,  -25.4285984,   19.2864952,   4.89368916
  55165,   -26.285799,   19.2864952,   4.89368916
  55166,  -27.1429977,   19.2864952,   4.89368916
  55167,  -28.0001984,   19.2864952,   4.89368916
  55168,  -28.8573971,   19.2864952,   4.89368916
  55169,  -21.1676846,   19.2098522,   5.62316227
  55170,    -22.01931,   19.2098522,   5.62316227
  55171,  -22.8709373,   19.2098522,   5.62316227
  55172,  -23.7225628,   19.2098522,   5.62316227
  55173,  -24.5741882,   19.2098522,   5.62316227
  55174,  -25.4258118,   19.2098522,   5.62316227
  55175,  -26.2774372,   19.2098522,   5.62316227
  55176,  -27.1290627,   19.2098522,   5.62316227
  55177,    -27.98069,   19.2098522,   5.62316227
  55178,  -28.8323154,   19.2098522,   5.62316227
  55179,  -21.1927681,   19.1332111,   6.35263538
  55180,  -22.0388203,   19.1332111,   6.35263538
  55181,  -22.8848705,   19.1332111,   6.35263491
  55182,  -23.7309227,   19.1332111,   6.35263491
  55183,  -24.5769749,   19.1332111,   6.35263491
  55184,  -25.4230251,   19.1332111,   6.35263491
  55185,  -26.2690773,   19.1332111,   6.35263491
  55186,  -27.1151295,   19.1332111,   6.35263491
  55187,  -27.9611797,   19.1332111,   6.35263491
  55188,  -28.8072319,   19.1332111,   6.35263491
  55189,  -21.2178497,   19.0565681,   7.08210802
  55190,  -22.0583286,   19.0565681,   7.08210802
  55191,  -22.8988056,   19.0565681,   7.08210802
  55192,  -23.7392845,   19.0565681,   7.08210802
  55193,  -24.5797615,   19.0565681,   7.08210802
  55194,  -25.4202385,   19.0565681,   7.08210802
  55195,  -26.2607155,   19.0565681,   7.08210802
  55196,  -27.1011944,   19.0565681,   7.08210802
  55197,  -27.9416714,   19.0565681,   7.08210802
  55198,  -28.7821503,   19.0565681,   7.08210802
  55199,  -21.2429333,   18.9799271,   7.81158113
  55200,   -22.077837,   18.9799271,   7.81158113
  55201,  -22.9127407,   18.9799271,   7.81158113
  55202,  -23.7476444,   18.9799271,   7.81158113
  55203,  -24.5825481,   18.9799271,   7.81158113
  55204,  -25.4174519,   18.9799271,   7.81158113
  55205,  -26.2523556,   18.9799271,   7.81158113
  55206,  -27.0872593,   18.9799271,   7.81158113
  55207,   -27.922163,   18.9799271,   7.81158113
  55208,  -28.7570667,   18.9799271,   7.81158113
  55209,  -21.2680168,   18.9032841,   8.54105377
  55210,  -22.0973454,   18.9032841,   8.54105377
  55211,  -22.9266758,   18.9032841,   8.54105377
  55212,  -23.7560062,   18.9032841,   8.54105377
  55213,  -24.5853367,   18.9032841,   8.54105377
  55214,  -25.4146633,   18.9032841,   8.54105377
  55215,  -26.2439938,   18.9032841,   8.54105377
  55216,  -27.0733242,   18.9032841,   8.54105377
  55217,  -27.9026546,   18.9032841,   8.54105377
  55218,  -28.7319832,   18.9032841,   8.54105377
  55219,  -21.2930984,    18.826643,   9.27052689
  55220,  -22.1168556,    18.826643,   9.27052689
  55221,  -22.9406109,    18.826643,   9.27052689
  55222,  -23.7643661,    18.826643,   9.27052689
  55223,  -24.5881233,    18.826643,   9.27052689
  55224,  -25.4118767,    18.826643,   9.27052689
  55225,  -26.2356339,    18.826643,   9.27052689
  55226,  -27.0593891,    18.826643,   9.27052689
  55227,  -27.8831444,    18.826643,   9.27052689
  55228,  -28.7069016,    18.826643,   9.27052689
  55229,  -20.9584599,   19.8491497,   1.82887173
  55230,  -21.8565807,   19.8491497,   1.82887173
  55231,  -22.7546997,   19.8491497,   1.82887173
  55232,  -23.6528206,   19.8491497,   1.82887173
  55233,  -24.5509396,   19.8491497,   1.82887173
  55234,  -25.4490604,   19.8491497,   1.82887173
  55235,  -26.3471794,   19.8491497,   1.82887173
  55236,  -27.2453003,   19.8491497,   1.82887173
  55237,  -28.1434193,   19.8491497,   1.82887173
  55238,  -29.0415401,   19.8491497,   1.82887173
  55239,  -20.9739761,   19.8017349,   2.64598465
  55240,  -21.8686485,   19.8017349,   2.64598465
  55241,  -22.7633209,   19.8017349,   2.64598465
  55242,  -23.6579933,   19.8017349,   2.64598465
  55243,  -24.5526638,   19.8017349,   2.64598465
  55244,  -25.4473362,   19.8017349,   2.64598465
  55245,  -26.3420067,   19.8017349,   2.64598465
  55246,  -27.2366791,   19.8017349,   2.64598465
  55247,  -28.1313515,   19.8017349,   2.64598465
  55248,  -29.0260239,   19.8017349,   2.64598465
  55249,  -20.9894943,   19.7543201,   3.46309733
  55250,  -21.8807182,   19.7543201,   3.46309733
  55251,  -22.7719421,   19.7543201,   3.46309733
  55252,   -23.663166,   19.7543201,   3.46309733
  55253,   -24.554388,   19.7543201,   3.46309733
  55254,   -25.445612,   19.7543201,   3.46309733
  55255,   -26.336834,   19.7543201,   3.46309733
  55256,  -27.2280579,   19.7543201,   3.46309733
  55257,  -28.1192818,   19.7543201,   3.46309733
  55258,  -29.0105057,   19.7543201,   3.46309733
  55259,  -21.0050106,   19.7069054,   4.28021002
  55260,  -21.8927879,   19.7069054,   4.28021002
  55261,  -22.7805614,   19.7069054,   4.28021002
  55262,  -23.6683369,   19.7069054,   4.28021002
  55263,  -24.5561123,   19.7069054,   4.28021002
  55264,  -25.4438877,   19.7069054,   4.28021002
  55265,  -26.3316631,   19.7069054,   4.28021002
  55266,  -27.2194386,   19.7069054,   4.28021002
  55267,  -28.1072121,   19.7069054,   4.28021002
  55268,  -28.9949894,   19.7069054,   4.28021002
  55269,  -21.0205288,   19.6594906,   5.09732294
  55270,  -21.9048576,   19.6594906,   5.09732294
  55271,  -22.7891827,   19.6594906,   5.09732294
  55272,  -23.6735096,   19.6594906,   5.09732294
  55273,  -24.5578365,   19.6594906,   5.09732294
  55274,  -25.4421635,   19.6594906,   5.09732294
  55275,  -26.3264904,   19.6594906,   5.09732294
  55276,  -27.2108173,   19.6594906,   5.09732294
  55277,  -28.0951424,   19.6594906,   5.09732294
  55278,  -28.9794712,   19.6594906,   5.09732294
  55279,  -21.0360489,   19.6120739,   5.91443586
  55280,  -21.9169254,   19.6120739,   5.91443586
  55281,  -22.7978058,   19.6120739,   5.91443586
  55282,  -23.6786842,   19.6120739,   5.91443586
  55283,  -24.5595608,   19.6120739,   5.91443586
  55284,  -25.4404392,   19.6120739,   5.91443586
  55285,  -26.3213158,   19.6120739,   5.91443586
  55286,  -27.2021942,   19.6120739,   5.91443586
  55287,  -28.0830746,   19.6120739,   5.91443586
  55288,  -28.9639511,   19.6120739,   5.91443586
  55289,  -21.0515671,   19.5646591,   6.73154879
  55290,  -21.9289951,   19.5646591,   6.73154879
  55291,   -22.806427,   19.5646591,   6.73154879
  55292,   -23.683857,   19.5646591,   6.73154879
  55293,   -24.561285,   19.5646591,   6.73154879
  55294,   -25.438715,   19.5646591,   6.73154879
  55295,   -26.316143,   19.5646591,   6.73154879
  55296,   -27.193573,   19.5646591,   6.73154879
  55297,  -28.0710049,   19.5646591,   6.73154879
  55298,  -28.9484329,   19.5646591,   6.73154879
  55299,  -21.0670834,   19.5172443,   7.54866171
  55300,  -21.9410648,   19.5172443,   7.54866171
  55301,  -22.8150463,   19.5172443,   7.54866171
  55302,  -23.6890278,   19.5172443,   7.54866171
  55303,  -24.5630093,   19.5172443,   7.54866171
  55304,  -25.4369907,   19.5172443,   7.54866171
  55305,  -26.3109722,   19.5172443,   7.54866171
  55306,  -27.1849537,   19.5172443,   7.54866171
  55307,  -28.0589352,   19.5172443,   7.54866171
  55308,  -28.9329166,   19.5172443,   7.54866171
  55309,  -21.0826015,   19.4698296,   8.36577415
  55310,  -21.9531345,   19.4698296,   8.36577415
  55311,  -22.8236675,   19.4698296,   8.36577415
  55312,  -23.6942005,   19.4698296,   8.36577415
  55313,  -24.5647335,   19.4698296,   8.36577415
  55314,  -25.4352665,   19.4698296,   8.36577415
  55315,  -26.3057995,   19.4698296,   8.36577415
  55316,  -27.1763325,   19.4698296,   8.36577415
  55317,  -28.0468655,   19.4698296,   8.36577415
  55318,  -28.9173985,   19.4698296,   8.36577415
  55319,  -21.0981178,   19.4224148,   9.18288708
  55320,  -21.9652023,   19.4224148,   9.18288708
  55321,  -22.8322887,   19.4224148,   9.18288708
  55322,  -23.6993732,   19.4224148,   9.18288708
  55323,  -24.5664577,   19.4224148,   9.18288708
  55324,  -25.4335423,   19.4224148,   9.18288708
  55325,  -26.3006268,   19.4224148,   9.18288708
  55326,  -27.1677113,   19.4224148,   9.18288708
  55327,  -28.0347977,   19.4224148,   9.18288708
  55328,  -28.9018822,   19.4224148,   9.18288708
  55329,   28.9018822,   19.4224148,  -9.18288708
  55330,   28.9173985,   19.4698296,  -8.36577415
  55331,   28.9329166,   19.5172443,  -7.54866171
  55332,   28.9484329,   19.5646591,  -6.73154879
  55333,   28.9639511,   19.6120739,  -5.91443586
  55334,   28.9794712,   19.6594906,  -5.09732294
  55335,   28.9949894,   19.7069054,  -4.28021002
  55336,   29.0105057,   19.7543201,  -3.46309733
  55337,   29.0260239,   19.8017349,  -2.64598465
  55338,   29.0415401,   19.8491497,  -1.82887173
  55339,   28.7069016,    18.826643,  -9.27052689
  55340,   28.7319832,   18.9032841,  -8.54105377
  55341,   28.7570667,   18.9799271,  -7.81158113
  55342,   28.7821503,   19.0565681,  -7.08210802
  55343,   28.8072319,   19.1332111,  -6.35263491
  55344,   28.8323154,   19.2098522,  -5.62316227
  55345,   28.8573971,   19.2864952,  -4.89368916
  55346,   28.8824806,   19.3631363,  -4.16421604
  55347,   28.9075642,   19.4397793,  -3.43474293
  55348,   28.9326458,   19.5164204,  -2.70526981
  55349,   28.5065289,   18.2143955,  -9.34998417
  55350,   28.5357857,   18.3037891,  -8.69996929
  55351,   28.5650406,   18.3931847,  -8.04995346
  55352,   28.5942974,   18.4825783,  -7.39993811
  55353,   28.6235542,   18.5719738,  -6.74992275
  55354,   28.6528091,   18.6613674,  -6.09990692
  55355,   28.6820679,   18.7507629,  -5.44989157
  55356,   28.7113247,   18.8401585,  -4.79987621
  55357,   28.7405796,   18.9295521,  -4.14986038
  55358,   28.7698364,   19.0189476,  -3.49984527
  55359,   28.3015709,   17.5881348,  -9.41821671
  55360,   28.3304157,   17.6762676,  -8.83643341
  55361,   28.3592587,   17.7644024,  -8.25464916
  55362,   28.3881016,   17.8525372,  -7.67286587
  55363,   28.4169464,     17.94067,  -7.09108257
  55364,   28.4457893,   18.0288048,   -6.5092988
  55365,   28.4746342,   18.1169376,  -5.92751551
  55366,   28.5034771,   18.2050724,  -5.34573174
  55367,   28.5323219,   18.2932072,  -4.76394844
  55368,   28.5611649,     18.38134,  -4.18216467
  55369,   28.0929527,   16.9506893,  -9.47304153
  55370,   28.1177235,   17.0263767,  -8.94608307
  55371,   28.1424942,    17.102066,  -8.41912365
  55372,   28.1672649,   17.1777554,  -7.89216518
  55373,   28.1920357,   17.2534428,   -7.3652072
  55374,   28.2168064,   17.3291321,  -6.83824873
  55375,   28.2415791,   17.4048195,  -6.31128979
  55376,   28.2663479,   17.4805069,  -5.78433132
  55377,   28.2911205,   17.5561962,  -5.25737286
  55378,   28.3158913,   17.6318855,  -4.73041391
  55379,   27.8816261,   16.3049698,  -9.51302719
  55380,   27.8996162,   16.3599396,  -9.02605343
  55381,   27.9176064,   16.4149113,  -8.53908062
  55382,   27.9355965,   16.4698811,  -8.05210686
  55383,   27.9535866,   16.5248508,  -7.56513405
  55384,   27.9715767,   16.5798206,  -7.07816076
  55385,   27.9895687,   16.6347923,  -6.59118795
  55386,   28.0075588,   16.6897621,  -6.10421467
  55387,   28.0255489,   16.7447319,  -5.61724138
  55388,    28.043539,   16.7997017,   -5.1302681
  55389,   27.6685238,   15.6538258,  -9.53731346
  55390,   27.6779575,   15.6826506,  -9.07462692
  55391,   27.6873913,   15.7114763,  -8.61194038
  55392,   27.6968269,   15.7403021,  -8.14925289
  55393,   27.7062607,   15.7691269,  -7.68656683
  55394,   27.7156944,   15.7979527,  -7.22387981
  55395,   27.7251282,   15.8267775,  -6.76119328
  55396,   27.7345619,   15.8556032,  -6.29850674
  55397,   27.7439957,    15.884429,   -5.8358202
  55398,   27.7534294,   15.9132538,  -5.37313318
  55399,   28.0347977,   19.4224148,  -9.18288708
  55400,   28.0468655,   19.4698296,  -8.36577415
  55401,   28.0589352,   19.5172443,  -7.54866171
  55402,   28.0710049,   19.5646591,  -6.73154879
  55403,   28.0830746,   19.6120739,  -5.91443586
  55404,   28.0951424,   19.6594906,  -5.09732294
  55405,   28.1072121,   19.7069054,  -4.28021002
  55406,   28.1192818,   19.7543201,  -3.46309733
  55407,   28.1313515,   19.8017349,  -2.64598465
  55408,   28.1434193,   19.8491497,  -1.82887173
  55409,   27.8831444,    18.826643,  -9.27052689
  55410,   27.9026546,   18.9032841,  -8.54105377
  55411,    27.922163,   18.9799271,  -7.81158113
  55412,   27.9416714,   19.0565681,  -7.08210802
  55413,   27.9611797,   19.1332111,  -6.35263491
  55414,     27.98069,   19.2098522,  -5.62316227
  55415,   28.0001984,   19.2864952,  -4.89368916
  55416,   28.0197067,   19.3631363,  -4.16421604
  55417,   28.0392151,   19.4397793,  -3.43474293
  55418,   28.0587254,   19.5164204,  -2.70526981
  55419,   27.7273026,   18.2143955,  -9.34998417
  55420,   27.7500553,   18.3037891,  -8.69996929
  55421,     27.77281,   18.3931847,  -8.04995346
  55422,   27.7955666,   18.4825783,  -7.39993811
  55423,   27.8183212,   18.5719738,  -6.74992275
  55424,   27.8410759,   18.6613674,  -6.09990692
  55425,   27.8638306,   18.7507629,  -5.44989157
  55426,   27.8865871,   18.8401585,  -4.79987621
  55427,   27.9093418,   18.9295521,  -4.14986086
  55428,   27.9320946,   19.0189476,  -3.49984527
  55429,   27.5678883,   17.5881348,  -9.41821671
  55430,   27.5903225,   17.6762676,  -8.83643341
  55431,   27.6127567,   17.7644024,  -8.25464916
  55432,    27.635191,   17.8525372,  -7.67286587
  55433,   27.6576252,     17.94067,  -7.09108257
  55434,   27.6800594,   18.0288048,   -6.5092988
  55435,   27.7024918,   18.1169376,  -5.92751551
  55436,    27.724926,   18.2050724,  -5.34573174
  55437,   27.7473621,   18.2932072,  -4.76394844
  55438,   27.7697945,     18.38134,  -4.18216467
  55439,   27.4056301,   16.9506893,  -9.47304153
  55440,   27.4248962,   17.0263767,  -8.94608307
  55441,   27.4441624,    17.102066,  -8.41912365
  55442,   27.4634285,   17.1777554,  -7.89216518
  55443,   27.4826946,   17.2534428,   -7.3652072
  55444,   27.5019608,   17.3291321,  -6.83824873
  55445,   27.5212269,   17.4048195,  -6.31128979
  55446,    27.540493,   17.4805069,  -5.78433132
  55447,   27.5597591,   17.5561962,  -5.25737286
  55448,   27.5790253,   17.6318855,  -4.73041391
  55449,   27.2412643,   16.3049698,  -9.51302719
  55450,   27.2552567,   16.3599396,  -9.02605343
  55451,    27.269249,   16.4149113,  -8.53908062
  55452,   27.2832413,   16.4698811,  -8.05210686
  55453,   27.2972336,   16.5248508,  -7.56513405
  55454,   27.3112259,   16.5798206,  -7.07816076
  55455,   27.3252201,   16.6347923,  -6.59118795
  55456,   27.3392124,   16.6897621,  -6.10421467
  55457,   27.3532047,   16.7447319,  -5.61724138
  55458,    27.367197,   16.7997017,   -5.1302681
  55459,   27.0755196,   15.6538258,  -9.53731346
  55460,   27.0828571,   15.6826506,  -9.07462692
  55461,   27.0901947,   15.7114763,  -8.61194038
  55462,   27.0975323,   15.7403021,  -8.14925289
  55463,   27.1048698,   15.7691269,  -7.68656683
  55464,   27.1122074,   15.7979517,  -7.22387981
  55465,    27.119545,   15.8267775,  -6.76119328
  55466,   27.1268806,   15.8556023,  -6.29850674
  55467,   27.1342182,    15.884428,   -5.8358202
  55468,   27.1415558,   15.9132528,  -5.37313318
  55469,   27.1677113,   19.4224148,  -9.18288708
  55470,   27.1763325,   19.4698296,  -8.36577415
  55471,   27.1849537,   19.5172443,  -7.54866171
  55472,    27.193573,   19.5646591,  -6.73154879
  55473,   27.2021942,   19.6120739,  -5.91443586
  55474,   27.2108173,   19.6594906,  -5.09732294
  55475,   27.2194386,   19.7069054,  -4.28021002
  55476,   27.2280579,   19.7543201,  -3.46309733
  55477,   27.2366791,   19.8017349,  -2.64598465
  55478,   27.2453003,   19.8491497,  -1.82887173
  55479,   27.0593891,    18.826643,  -9.27052689
  55480,   27.0733242,   18.9032841,  -8.54105377
  55481,   27.0872593,   18.9799271,  -7.81158113
  55482,   27.1011944,   19.0565681,  -7.08210802
  55483,   27.1151295,   19.1332111,  -6.35263491
  55484,   27.1290627,   19.2098522,  -5.62316227
  55485,   27.1429977,   19.2864952,  -4.89368916
  55486,   27.1569328,   19.3631363,  -4.16421604
  55487,   27.1708679,   19.4397793,  -3.43474317
  55488,    27.184803,   19.5164204,  -2.70526981
  55489,   26.9480724,   18.2143955,  -9.34998417
  55490,    26.964325,   18.3037891,  -8.69996929
  55491,   26.9805775,   18.3931847,  -8.04995346
  55492,   26.9968319,   18.4825783,  -7.39993811
  55493,   27.0130863,   18.5719738,  -6.74992275
  55494,   27.0293388,   18.6613674,  -6.09990692
  55495,   27.0455933,   18.7507629,  -5.44989204
  55496,   27.0618477,   18.8401585,  -4.79987621
  55497,   27.0781002,   18.9295521,  -4.14986086
  55498,   27.0943527,   19.0189476,  -3.49984527
  55499,   26.8342056,   17.5881348,  -9.41821671
  55500,   26.8502312,   17.6762676,  -8.83643341
  55501,   26.8662548,   17.7644024,  -8.25464916
  55502,   26.8822784,   17.8525372,  -7.67286587
  55503,   26.8983021,     17.94067,  -7.09108257
  55504,   26.9143276,   18.0288048,   -6.5092988
  55505,   26.9303513,   18.1169376,  -5.92751551
  55506,   26.9463749,   18.2050724,  -5.34573174
  55507,   26.9624004,   18.2932072,  -4.76394844
  55508,   26.9784241,     18.38134,  -4.18216467
  55509,   26.7183075,   16.9506893,  -9.47304153
  55510,    26.732069,   17.0263767,  -8.94608307
  55511,   26.7458305,    17.102066,  -8.41912365
  55512,   26.7595921,   17.1777554,  -7.89216566
  55513,   26.7733536,   17.2534428,   -7.3652072
  55514,   26.7871151,   17.3291321,  -6.83824873
  55515,   26.8008766,   17.4048195,  -6.31128979
  55516,   26.8146381,   17.4805069,  -5.78433132
  55517,   26.8283997,   17.5561962,  -5.25737286
  55518,   26.8421612,   17.6318855,  -4.73041391
  55519,   26.6009045,   16.3049698,  -9.51302719
  55520,    26.610899,   16.3599396,  -9.02605343
  55521,   26.6208935,   16.4149113,  -8.53908062
  55522,    26.630888,   16.4698811,  -8.05210686
  55523,   26.6408825,   16.5248508,  -7.56513405
  55524,    26.650877,   16.5798206,  -7.07816076
  55525,   26.6608715,   16.6347923,  -6.59118795
  55526,    26.670866,   16.6897621,  -6.10421467
  55527,   26.6808605,   16.7447319,  -5.61724138
  55528,    26.690855,   16.7997017,   -5.1302681
  55529,   26.4825134,   15.6538258,  -9.53731346
  55530,   26.4877548,   15.6826506,  -9.07462692
  55531,   26.4929943,   15.7114763,  -8.61194038
  55532,   26.4982376,   15.7403021,  -8.14925289
  55533,    26.503479,   15.7691269,  -7.68656683
  55534,   26.5087185,   15.7979517,  -7.22387981
  55535,   26.5139599,   15.8267775,  -6.76119328
  55536,   26.5192013,   15.8556023,  -6.29850674
  55537,   26.5244408,    15.884428,   -5.8358202
  55538,   26.5296822,   15.9132528,  -5.37313318
  55539,   26.3006268,   19.4224148,  -9.18288708
  55540,   26.3057995,   19.4698296,  -8.36577415
  55541,   26.3109722,   19.5172443,  -7.54866171
  55542,    26.316143,   19.5646591,  -6.73154879
  55543,   26.3213158,   19.6120739,  -5.91443586
  55544,   26.3264904,   19.6594906,  -5.09732294
  55545,   26.3316631,   19.7069054,  -4.28021002
  55546,    26.336834,   19.7543201,  -3.46309733
  55547,   26.3420067,   19.8017349,  -2.64598465
  55548,   26.3471794,   19.8491497,  -1.82887173
  55549,   26.2356339,    18.826643,  -9.27052689
  55550,   26.2439938,   18.9032841,  -8.54105377
  55551,   26.2523556,   18.9799271,  -7.81158113
  55552,   26.2607155,   19.0565681,  -7.08210802
  55553,   26.2690773,   19.1332111,  -6.35263491
  55554,   26.2774372,   19.2098522,  -5.62316227
  55555,    26.285799,   19.2864952,  -4.89368916
  55556,   26.2941589,   19.3631363,  -4.16421604
  55557,   26.3025208,   19.4397793,  -3.43474317
  55558,   26.3108807,   19.5164204,  -2.70526981
  55559,   26.1688423,   18.2143955,  -9.34998417
  55560,   26.1785946,   18.3037891,  -8.69996929
  55561,   26.1883469,   18.3931847,  -8.04995346
  55562,   26.1980991,   18.4825783,  -7.39993811
  55563,   26.2078514,   18.5719738,  -6.74992275
  55564,   26.2176037,   18.6613674,   -6.0999074
  55565,    26.227356,   18.7507629,  -5.44989204
  55566,   26.2371082,   18.8401585,  -4.79987621
  55567,   26.2468605,   18.9295521,  -4.14986086
  55568,   26.2566128,   19.0189476,  -3.49984527
  55569,   26.1005249,   17.5881348,  -9.41821671
  55570,   26.1101398,   17.6762676,  -8.83643341
  55571,   26.1197529,   17.7644024,  -8.25464916
  55572,   26.1293678,   17.8525372,  -7.67286587
  55573,   26.1389828,     17.94067,  -7.09108257
  55574,   26.1485977,   18.0288048,   -6.5092988
  55575,   26.1582108,   18.1169376,  -5.92751551
  55576,   26.1678257,   18.2050724,  -5.34573174
  55577,   26.1774406,   18.2932072,  -4.76394844
  55578,   26.1870556,     18.38134,  -4.18216467
  55579,   26.0309849,   16.9506893,  -9.47304153
  55580,   26.0392418,   17.0263767,  -8.94608307
  55581,   26.0474987,    17.102066,  -8.41912365
  55582,   26.0557556,   17.1777554,  -7.89216566
  55583,   26.0640125,   17.2534428,   -7.3652072
  55584,   26.0722694,   17.3291321,  -6.83824873
  55585,   26.0805264,   17.4048195,  -6.31128979
  55586,   26.0887833,   17.4805088,  -5.78433132
  55587,   26.0970402,   17.5561962,  -5.25737286
  55588,   26.1052971,   17.6318855,  -4.73041391
  55589,   25.9605427,   16.3049698,  -9.51302719
  55590,   25.9665394,   16.3599396,  -9.02605343
  55591,   25.9725361,   16.4149113,  -8.53908062
  55592,   25.9785328,   16.4698811,  -8.05210781
  55593,   25.9845295,   16.5248508,  -7.56513453
  55594,   25.9905262,   16.5798206,  -7.07816124
  55595,   25.9965229,   16.6347904,  -6.59118843
  55596,   26.0025196,   16.6897602,  -6.10421515
  55597,   26.0085163,     16.74473,  -5.61724186
  55598,    26.014513,   16.7996998,  -5.13026905
  55599,   25.8895092,   15.6538258,  -9.53731346
  55600,   25.8926525,   15.6826506,  -9.07462692
  55601,   25.8957977,   15.7114763,  -8.61194038
  55602,   25.8989429,   15.7403021,  -8.14925289
  55603,   25.9020882,   15.7691269,  -7.68656683
  55604,   25.9052315,   15.7979517,  -7.22387981
  55605,   25.9083767,   15.8267775,  -6.76119328
  55606,     25.91152,   15.8556023,  -6.29850674
  55607,   25.9146652,    15.884428,   -5.8358202
  55608,   25.9178085,   15.9132528,  -5.37313318
  55609,   25.4335423,   19.4224148,  -9.18288708
  55610,   25.4352665,   19.4698296,  -8.36577415
  55611,   25.4369907,   19.5172443,  -7.54866171
  55612,    25.438715,   19.5646591,  -6.73154879
  55613,   25.4404392,   19.6120739,  -5.91443586
  55614,   25.4421635,   19.6594906,  -5.09732294
  55615,   25.4438877,   19.7069054,  -4.28021002
  55616,    25.445612,   19.7543201,  -3.46309733
  55617,   25.4473362,   19.8017349,  -2.64598465
  55618,   25.4490604,   19.8491497,  -1.82887173
  55619,   25.4118767,    18.826643,  -9.27052689
  55620,   25.4146633,   18.9032841,  -8.54105377
  55621,   25.4174519,   18.9799271,  -7.81158113
  55622,   25.4202385,   19.0565681,  -7.08210802
  55623,   25.4230251,   19.1332111,  -6.35263491
  55624,   25.4258118,   19.2098522,  -5.62316227
  55625,   25.4285984,   19.2864952,  -4.89368916
  55626,    25.431385,   19.3631363,  -4.16421604
  55627,   25.4341736,   19.4397793,  -3.43474293
  55628,   25.4369602,   19.5164204,  -2.70526981
  55629,   25.3896141,   18.2143955,  -9.34998417
  55630,   25.3928661,   18.3037891,  -8.69996929
  55631,   25.3961163,   18.3931847,  -8.04995346
  55632,   25.3993664,   18.4825783,  -7.39993811
  55633,   25.4026165,   18.5719738,  -6.74992275
  55634,   25.4058685,   18.6613674,   -6.0999074
  55635,   25.4091187,   18.7507629,  -5.44989204
  55636,   25.4123707,   18.8401585,  -4.79987621
  55637,   25.4156189,   18.9295521,  -4.14986086
  55638,   25.4188709,   19.0189476,  -3.49984527
  55639,   25.3668404,   17.5881348,  -9.41821671
  55640,   25.3700447,   17.6762676,  -8.83643341
  55641,    25.373251,   17.7644024,  -8.25464916
  55642,   25.3764553,   17.8525372,  -7.67286587
  55643,   25.3796597,     17.94067,  -7.09108257
  55644,    25.382864,   18.0288048,   -6.5092988
  55645,   25.3860703,   18.1169376,  -5.92751551
  55646,   25.3892746,   18.2050724,  -5.34573174
  55647,   25.3924809,   18.2932072,  -4.76394844
  55648,   25.3956833,     18.38134,  -4.18216467
  55649,   25.3436623,   16.9506893,  -9.47304153
  55650,   25.3464146,   17.0263767,  -8.94608307
  55651,   25.3491669,    17.102066,   -8.4191246
  55652,   25.3519192,   17.1777554,  -7.89216566
  55653,   25.3546715,   17.2534428,   -7.3652072
  55654,   25.3574238,   17.3291321,  -6.83824873
  55655,   25.3601761,   17.4048195,  -6.31128979
  55656,   25.3629284,   17.4805088,  -5.78433132
  55657,   25.3656807,   17.5561981,  -5.25737286
  55658,    25.368433,   17.6318855,  -4.73041391
  55659,   25.3201809,   16.3049698,  -9.51302719
  55660,   25.3221798,   16.3599396,  -9.02605343
  55661,   25.3241787,   16.4149113,  -8.53908062
  55662,   25.3261776,   16.4698811,  -8.05210781
  55663,   25.3281765,   16.5248508,  -7.56513453
  55664,   25.3301754,   16.5798206,  -7.07816124
  55665,   25.3321743,   16.6347904,  -6.59118843
  55666,   25.3341732,   16.6897602,  -6.10421515
  55667,   25.3361721,   16.7447319,  -5.61724186
  55668,    25.338171,   16.7997017,  -5.13026857
  55669,   25.2965031,   15.6538258,  -9.53731346
  55670,   25.2975502,   15.6826506,  -9.07462692
  55671,   25.2985992,   15.7114763,  -8.61194038
  55672,   25.2996483,   15.7403021,  -8.14925289
  55673,   25.3006973,   15.7691269,  -7.68656683
  55674,   25.3017445,   15.7979517,  -7.22387981
  55675,   25.3027916,   15.8267775,  -6.76119328
  55676,   25.3038406,   15.8556023,  -6.29850674
  55677,   25.3048897,    15.884428,   -5.8358202
  55678,   25.3059368,   15.9132528,  -5.37313318
  55679,   24.5664577,   19.4224148,  -9.18288708
  55680,   24.5647335,   19.4698296,  -8.36577415
  55681,   24.5630093,   19.5172443,  -7.54866171
  55682,    24.561285,   19.5646591,  -6.73154879
  55683,   24.5595608,   19.6120739,  -5.91443586
  55684,   24.5578365,   19.6594906,  -5.09732294
  55685,   24.5561123,   19.7069054,  -4.28021002
  55686,    24.554388,   19.7543201,  -3.46309733
  55687,   24.5526638,   19.8017349,  -2.64598465
  55688,   24.5509396,   19.8491497,  -1.82887173
  55689,   24.5881233,    18.826643,  -9.27052689
  55690,   24.5853367,   18.9032841,  -8.54105377
  55691,   24.5825481,   18.9799271,  -7.81158113
  55692,   24.5797615,   19.0565681,  -7.08210802
  55693,   24.5769749,   19.1332111,  -6.35263491
  55694,   24.5741882,   19.2098522,  -5.62316227
  55695,   24.5714016,   19.2864952,  -4.89368916
  55696,    24.568615,   19.3631363,  -4.16421604
  55697,   24.5658264,   19.4397793,  -3.43474293
  55698,   24.5630398,   19.5164204,  -2.70526981
  55699,   24.6103859,   18.2143955,  -9.34998417
  55700,   24.6071339,   18.3037891,  -8.69996929
  55701,   24.6038837,   18.3931847,  -8.04995346
  55702,   24.6006336,   18.4825783,  -7.39993811
  55703,   24.5973835,   18.5719738,  -6.74992275
  55704,   24.5941315,   18.6613674,   -6.0999074
  55705,   24.5908813,   18.7507629,  -5.44989204
  55706,   24.5876312,   18.8401566,  -4.79987621
  55707,   24.5843811,   18.9295521,  -4.14986086
  55708,   24.5811291,   19.0189476,   -3.4998455
  55709,   24.6331596,   17.5881348,  -9.41821671
  55710,   24.6299534,   17.6762676,  -8.83643341
  55711,    24.626749,   17.7644024,  -8.25464916
  55712,   24.6235447,   17.8525372,  -7.67286587
  55713,   24.6203384,     17.94067,  -7.09108257
  55714,   24.6171341,   18.0288048,   -6.5092988
  55715,   24.6139297,   18.1169376,  -5.92751551
  55716,   24.6107235,   18.2050724,  -5.34573221
  55717,   24.6075211,   18.2932072,  -4.76394844
  55718,   24.6043148,     18.38134,  -4.18216515
  55719,   24.6563377,   16.9506893,  -9.47304153
  55720,   24.6535854,   17.0263767,  -8.94608307
  55721,   24.6508331,    17.102066,   -8.4191246
  55722,   24.6480808,   17.1777554,  -7.89216566
  55723,   24.6453285,   17.2534428,   -7.3652072
  55724,   24.6425781,   17.3291321,  -6.83824873
  55725,   24.6398258,   17.4048195,  -6.31128979
  55726,   24.6370735,   17.4805088,  -5.78433132
  55727,   24.6343212,   17.5561981,  -5.25737286
  55728,   24.6315689,   17.6318855,  -4.73041439
  55729,   24.6798191,   16.3049698,  -9.51302719
  55730,   24.6778202,   16.3599396,  -9.02605343
  55731,   24.6758213,   16.4149113,  -8.53908062
  55732,   24.6738224,   16.4698811,  -8.05210781
  55733,   24.6718235,   16.5248508,  -7.56513453
  55734,   24.6698246,   16.5798206,  -7.07816124
  55735,   24.6678276,   16.6347904,  -6.59118843
  55736,   24.6658287,   16.6897602,  -6.10421515
  55737,   24.6638279,   16.7447319,  -5.61724186
  55738,    24.661829,   16.7997017,  -5.13026857
  55739,   24.7034969,   15.6538258,  -9.53731346
  55740,   24.7024498,   15.6826506,  -9.07462692
  55741,   24.7014008,   15.7114763,  -8.61194038
  55742,   24.7003536,   15.7403021,  -8.14925289
  55743,   24.6993065,   15.7691269,  -7.68656683
  55744,   24.6982574,   15.7979517,  -7.22387981
  55745,   24.6972084,   15.8267775,  -6.76119328
  55746,   24.6961613,   15.8556023,  -6.29850674
  55747,   24.6951122,    15.884428,   -5.8358202
  55748,   24.6940651,   15.9132528,  -5.37313318
  55749,   23.6993732,   19.4224148,  -9.18288708
  55750,   23.6942005,   19.4698296,  -8.36577415
  55751,   23.6890278,   19.5172443,  -7.54866171
  55752,    23.683857,   19.5646591,  -6.73154879
  55753,   23.6786842,   19.6120739,  -5.91443586
  55754,   23.6735096,   19.6594906,  -5.09732294
  55755,   23.6683369,   19.7069054,  -4.28021002
  55756,    23.663166,   19.7543201,  -3.46309733
  55757,   23.6579933,   19.8017349,  -2.64598465
  55758,   23.6528206,   19.8491497,  -1.82887173
  55759,   23.7643661,    18.826643,  -9.27052689
  55760,   23.7560062,   18.9032841,  -8.54105377
  55761,   23.7476444,   18.9799271,  -7.81158113
  55762,   23.7392845,   19.0565681,  -7.08210802
  55763,   23.7309227,   19.1332111,  -6.35263491
  55764,   23.7225628,   19.2098522,  -5.62316227
  55765,    23.714201,   19.2864952,  -4.89368916
  55766,   23.7058411,   19.3631363,  -4.16421604
  55767,   23.6974792,   19.4397793,  -3.43474317
  55768,   23.6891193,   19.5164204,  -2.70527005
  55769,   23.8311577,   18.2143955,  -9.34998417
  55770,   23.8214054,   18.3037891,  -8.69996929
  55771,   23.8116531,   18.3931847,  -8.04995346
  55772,   23.8019009,   18.4825783,  -7.39993811
  55773,   23.7921486,   18.5719738,  -6.74992275
  55774,   23.7823963,   18.6613674,   -6.0999074
  55775,    23.772644,   18.7507629,  -5.44989204
  55776,   23.7628937,   18.8401566,  -4.79987621
  55777,   23.7531395,   18.9295521,  -4.14986086
  55778,   23.7433872,   19.0189476,   -3.4998455
  55779,   23.8994751,   17.5881348,  -9.41821671
  55780,   23.8898602,   17.6762676,  -8.83643341
  55781,   23.8802452,   17.7644024,  -8.25465012
  55782,   23.8706322,   17.8525372,  -7.67286587
  55783,   23.8610172,     17.94067,  -7.09108257
  55784,   23.8514023,   18.0288048,   -6.5092988
  55785,   23.8417873,   18.1169376,  -5.92751551
  55786,   23.8321724,   18.2050724,  -5.34573221
  55787,   23.8225594,   18.2932072,  -4.76394844
  55788,   23.8129425,   18.3813419,  -4.18216515
  55789,   23.9690151,   16.9506893,  -9.47304153
  55790,   23.9607582,   17.0263767,  -8.94608307
  55791,   23.9525013,    17.102066,   -8.4191246
  55792,   23.9442444,   17.1777554,  -7.89216566
  55793,   23.9359875,   17.2534428,   -7.3652072
  55794,   23.9277306,   17.3291321,  -6.83824873
  55795,   23.9194756,   17.4048195,  -6.31128979
  55796,   23.9112167,   17.4805088,  -5.78433132
  55797,   23.9029598,   17.5561981,  -5.25737286
  55798,   23.8947048,   17.6318855,  -4.73041439
  55799,   24.0394573,   16.3049698,  -9.51302719
  55800,   24.0334606,   16.3599396,  -9.02605343
  55801,   24.0274639,   16.4149113,  -8.53908062
  55802,   24.0214672,   16.4698811,  -8.05210781
  55803,   24.0154705,   16.5248508,  -7.56513453
  55804,   24.0094738,   16.5798206,  -7.07816124
  55805,    24.003479,   16.6347904,  -6.59118795
  55806,   23.9974823,   16.6897602,  -6.10421515
  55807,   23.9914837,   16.7447319,  -5.61724186
  55808,    23.985487,   16.7997017,  -5.13026857
  55809,   24.1104908,   15.6538248,  -9.53731346
  55810,   24.1073475,   15.6826506,  -9.07462692
  55811,   24.1042023,   15.7114754,  -8.61194038
  55812,    24.101059,   15.7403011,  -8.14925385
  55813,   24.0979137,   15.7691259,  -7.68656683
  55814,   24.0947704,   15.7979517,  -7.22388029
  55815,   24.0916233,   15.8267765,  -6.76119375
  55816,     24.08848,   15.8556023,  -6.29850721
  55817,   24.0853348,    15.884428,   -5.8358202
  55818,   24.0821915,   15.9132528,  -5.37313366
  55819,   22.8322887,   19.4224148,  -9.18288708
  55820,   22.8236675,   19.4698296,  -8.36577415
  55821,   22.8150463,   19.5172443,  -7.54866171
  55822,    22.806427,   19.5646591,  -6.73154879
  55823,   22.7978058,   19.6120739,  -5.91443586
  55824,   22.7891827,   19.6594906,  -5.09732294
  55825,   22.7805614,   19.7069054,  -4.28021002
  55826,   22.7719421,   19.7543201,  -3.46309733
  55827,   22.7633209,   19.8017349,  -2.64598465
  55828,   22.7546997,   19.8491497,  -1.82887173
  55829,   22.9406109,    18.826643,  -9.27052689
  55830,   22.9266758,   18.9032841,  -8.54105377
  55831,   22.9127407,   18.9799271,  -7.81158113
  55832,   22.8988056,   19.0565681,  -7.08210802
  55833,   22.8848705,   19.1332111,  -6.35263491
  55834,   22.8709373,   19.2098522,  -5.62316227
  55835,   22.8570023,   19.2864952,  -4.89368916
  55836,   22.8430672,   19.3631363,  -4.16421604
  55837,   22.8291321,   19.4397793,  -3.43474317
  55838,    22.815197,   19.5164204,  -2.70527005
  55839,   23.0519276,   18.2143955,  -9.34998417
  55840,    23.035675,   18.3037891,  -8.69996929
  55841,   23.0194225,   18.3931847,  -8.04995346
  55842,   23.0031681,   18.4825783,  -7.39993811
  55843,   22.9869137,   18.5719738,  -6.74992275
  55844,   22.9706612,   18.6613674,   -6.0999074
  55845,   22.9544067,   18.7507629,  -5.44989204
  55846,   22.9381542,   18.8401566,  -4.79987621
  55847,   22.9218998,   18.9295521,  -4.14986086
  55848,   22.9056473,   19.0189476,   -3.4998455
  55849,   23.1657944,   17.5881348,  -9.41821671
  55850,   23.1497688,   17.6762676,  -8.83643341
  55851,   23.1337452,   17.7644024,  -8.25465012
  55852,   23.1177197,   17.8525372,  -7.67286587
  55853,    23.101696,     17.94067,  -7.09108257
  55854,   23.0856724,   18.0288048,   -6.5092988
  55855,   23.0696468,   18.1169376,  -5.92751551
  55856,   23.0536232,   18.2050743,  -5.34573221
  55857,   23.0375996,   18.2932072,  -4.76394844
  55858,    23.021574,   18.3813419,  -4.18216515
  55859,   23.2816925,   16.9506893,  -9.47304153
  55860,    23.267931,   17.0263767,  -8.94608307
  55861,   23.2541695,    17.102066,   -8.4191246
  55862,   23.2404079,   17.1777554,  -7.89216566
  55863,   23.2266464,   17.2534428,   -7.3652072
  55864,   23.2128849,   17.3291321,  -6.83824873
  55865,   23.1991253,   17.4048195,  -6.31128979
  55866,   23.1853619,   17.4805088,  -5.78433132
  55867,   23.1716003,   17.5561981,  -5.25737286
  55868,   23.1578407,   17.6318855,  -4.73041439
  55869,   23.3990955,   16.3049698,  -9.51302719
  55870,    23.389101,   16.3599396,  -9.02605343
  55871,   23.3791065,   16.4149113,  -8.53908062
  55872,    23.369112,   16.4698811,  -8.05210781
  55873,   23.3591175,   16.5248508,  -7.56513453
  55874,    23.349123,   16.5798206,  -7.07816124
  55875,   23.3391304,   16.6347904,  -6.59118795
  55876,   23.3291359,   16.6897602,  -6.10421515
  55877,   23.3191395,   16.7447319,  -5.61724186
  55878,    23.309145,   16.7997017,  -5.13026857
  55879,   23.5174866,   15.6538248,  -9.53731346
  55880,   23.5122452,   15.6826506,  -9.07462692
  55881,   23.5070057,   15.7114754,  -8.61194038
  55882,   23.5017643,   15.7403011,  -8.14925385
  55883,   23.4965229,   15.7691259,  -7.68656683
  55884,   23.4912834,   15.7979517,  -7.22388029
  55885,   23.4860401,   15.8267765,  -6.76119375
  55886,   23.4807987,   15.8556023,  -6.29850721
  55887,   23.4755592,    15.884428,   -5.8358202
  55888,   23.4703178,   15.9132528,  -5.37313366
  55889,   21.9652023,   19.4224148,  -9.18288708
  55890,   21.9531345,   19.4698296,  -8.36577415
  55891,   21.9410648,   19.5172443,  -7.54866171
  55892,   21.9289951,   19.5646591,  -6.73154879
  55893,   21.9169254,   19.6120739,  -5.91443586
  55894,   21.9048576,   19.6594906,  -5.09732294
  55895,   21.8927879,   19.7069054,  -4.28021002
  55896,   21.8807182,   19.7543201,  -3.46309733
  55897,   21.8686485,   19.8017349,  -2.64598465
  55898,   21.8565807,   19.8491497,  -1.82887173
  55899,   22.1168556,    18.826643,  -9.27052689
  55900,   22.0973454,   18.9032841,  -8.54105377
  55901,    22.077837,   18.9799271,  -7.81158113
  55902,   22.0583286,   19.0565681,  -7.08210802
  55903,   22.0388203,   19.1332111,  -6.35263538
  55904,     22.01931,   19.2098522,  -5.62316227
  55905,   21.9998016,   19.2864952,  -4.89368916
  55906,   21.9802933,   19.3631363,  -4.16421604
  55907,   21.9607849,   19.4397793,  -3.43474317
  55908,   21.9412746,   19.5164204,  -2.70527005
  55909,   22.2726974,   18.2143955,  -9.34998417
  55910,   22.2499447,   18.3037891,  -8.69996929
  55911,     22.22719,   18.3931847,  -8.04995346
  55912,   22.2044334,   18.4825783,  -7.39993811
  55913,   22.1816788,   18.5719738,  -6.74992275
  55914,   22.1589241,   18.6613674,   -6.0999074
  55915,   22.1361694,   18.7507629,  -5.44989204
  55916,   22.1134148,   18.8401566,  -4.79987621
  55917,   22.0906582,   18.9295521,  -4.14986086
  55918,   22.0679054,   19.0189476,   -3.4998455
  55919,   22.4321117,   17.5881348,  -9.41821671
  55920,   22.4096775,   17.6762676,  -8.83643341
  55921,   22.3872433,   17.7644024,  -8.25465012
  55922,    22.364809,   17.8525352,  -7.67286587
  55923,   22.3423748,     17.94067,  -7.09108257
  55924,   22.3199406,   18.0288048,   -6.5092988
  55925,   22.2975082,   18.1169395,  -5.92751551
  55926,    22.275074,   18.2050743,  -5.34573221
  55927,   22.2526398,   18.2932072,  -4.76394844
  55928,   22.2302055,   18.3813419,  -4.18216515
  55929,   22.5943699,   16.9506893,  -9.47304153
  55930,   22.5751038,   17.0263767,  -8.94608307
  55931,   22.5558376,    17.102066,   -8.4191246
  55932,   22.5365715,   17.1777554,  -7.89216566
  55933,   22.5173054,   17.2534428,   -7.3652072
  55934,   22.4980392,   17.3291321,  -6.83824873
  55935,    22.478775,   17.4048195,  -6.31128979
  55936,    22.459507,   17.4805088,  -5.78433132
  55937,   22.4402409,   17.5561981,  -5.25737286
  55938,   22.4209766,   17.6318855,  -4.73041439
  55939,   22.7587357,   16.3049698,  -9.51302719
  55940,   22.7447433,   16.3599396,  -9.02605343
  55941,    22.730751,   16.4149113,  -8.53908062
  55942,   22.7167587,   16.4698811,  -8.05210781
  55943,   22.7027664,   16.5248508,  -7.56513453
  55944,   22.6887741,   16.5798206,  -7.07816124
  55945,   22.6747818,   16.6347904,  -6.59118795
  55946,   22.6607895,   16.6897602,  -6.10421515
  55947,   22.6467953,   16.7447319,  -5.61724186
  55948,    22.632803,   16.7997017,  -5.13026857
  55949,   22.9244804,   15.6538248,  -9.53731346
  55950,   22.9171429,   15.6826506,  -9.07462692
  55951,   22.9098072,   15.7114754,  -8.61194038
  55952,   22.9024696,   15.7403011,  -8.14925385
  55953,   22.8951321,   15.7691259,  -7.68656683
  55954,   22.8877964,   15.7979517,  -7.22388029
  55955,   22.8804569,   15.8267765,  -6.76119375
  55956,   22.8731194,   15.8556023,  -6.29850721
  55957,   22.8657837,    15.884428,   -5.8358202
  55958,   22.8584461,   15.9132528,  -5.37313366
  55959,   21.0981178,   19.4224148,  -9.18288708
  55960,   21.0826015,   19.4698296,  -8.36577415
  55961,   21.0670834,   19.5172443,  -7.54866171
  55962,   21.0515671,   19.5646591,  -6.73154879
  55963,   21.0360489,   19.6120739,  -5.91443586
  55964,   21.0205288,   19.6594906,  -5.09732294
  55965,   21.0050106,   19.7069054,  -4.28021002
  55966,   20.9894943,   19.7543201,  -3.46309733
  55967,   20.9739761,   19.8017349,  -2.64598465
  55968,   20.9584599,   19.8491497,  -1.82887173
  55969,   21.2930984,    18.826643,  -9.27052689
  55970,   21.2680168,   18.9032841,  -8.54105377
  55971,   21.2429333,   18.9799271,  -7.81158113
  55972,   21.2178497,   19.0565681,  -7.08210802
  55973,   21.1927681,   19.1332111,  -6.35263538
  55974,   21.1676846,   19.2098522,  -5.62316227
  55975,   21.1426029,   19.2864952,  -4.89368916
  55976,   21.1175194,   19.3631363,  -4.16421604
  55977,   21.0924358,   19.4397793,  -3.43474317
  55978,   21.0673542,   19.5164204,  -2.70527005
  55979,   21.4934711,   18.2143955,  -9.34998417
  55980,   21.4642143,   18.3037891,  -8.69996929
  55981,   21.4349594,   18.3931847,  -8.04995346
  55982,   21.4057026,   18.4825783,  -7.39993811
  55983,   21.3764458,   18.5719738,  -6.74992275
  55984,   21.3471909,   18.6613674,   -6.0999074
  55985,   21.3179321,   18.7507629,  -5.44989204
  55986,   21.2886772,   18.8401566,  -4.79987621
  55987,   21.2594204,   18.9295521,  -4.14986086
  55988,   21.2301636,   19.0189476,   -3.4998455
  55989,   21.6984291,   17.5881348,  -9.41821671
  55990,   21.6695843,   17.6762676,  -8.83643341
  55991,   21.6407413,   17.7644024,  -8.25465012
  55992,   21.6118965,   17.8525352,  -7.67286634
  55993,   21.5830536,     17.94067,  -7.09108305
  55994,   21.5542088,   18.0288048,  -6.50929928
