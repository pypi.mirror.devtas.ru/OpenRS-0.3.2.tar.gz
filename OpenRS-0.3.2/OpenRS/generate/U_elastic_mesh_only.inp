  37995,  -28.1673393,   50.9032707,  0.909090936
  37996,   28.1673393,   50.9032707,   1.81818187
  37997,   28.1239147,   51.8056145,   1.81818187
  37998,   28.0515938,   52.7061043,   1.81818187
  37999,   27.9504452,   53.6038094,   1.81818187
  38000,   27.8205776,   54.4978142,   1.81818187
  38001,   27.6621189,   55.3871994,   1.81818187
  38002,   27.4752407,   56.2710457,   1.81818187
  38003,    27.260128,   57.1484489,   1.81818187
  38004,    27.017004,   58.0185051,   1.81818187
  38005,   26.7461166,   58.8803215,   1.81818187
  38006,   26.4477463,    59.733017,   1.81818187
  38007,      26.1222,   60.5757065,   1.81818187
  38008,   25.7698097,   61.4075317,   1.81818187
  38009,   25.3909416,   62.2276344,   1.81818187
  38010,    24.985981,   63.0351715,   1.81818187
  38011,   24.5553455,   63.8293114,   1.81818187
  38012,   24.0994759,   64.6092453,   1.81818187
  38013,    23.618845,   65.3741684,   1.81818187
  38014,   23.1139469,    66.123291,   1.81818187
  38015,   22.5852947,   66.8558426,   1.81818187
  38016,   22.0334301,   67.5710754,   1.81818187
  38017,    21.458931,   68.2682571,   1.81818187
  38018,   20.8623772,   68.9466629,   1.81818187
  38019,   20.2443905,   69.6055984,   1.81818187
  38020,   19.6055965,   70.2443924,   1.81818187
  38021,   18.9466591,    70.862381,   1.81818187
  38022,   18.2682571,    71.458931,   1.81818187
  38023,   17.5710773,    72.033432,   1.81818187
  38024,   16.8558407,   72.5852966,   1.81818187
  38025,   16.1232853,    73.113945,   1.81818187
  38026,   15.3741636,   73.6188431,   1.81818187
  38027,   14.6092463,   74.0994797,   1.81818187
  38028,   13.8293123,   74.5553436,   1.81818187
  38029,   13.0351706,   74.9859772,   1.81818187
  38030,   12.2276316,   75.3909378,   1.81818187
  38031,   11.4075298,   75.7698135,   1.81818187
  38032,   10.5757065,      76.1222,   1.81818187
  38033,   9.73301506,   76.4477463,   1.81818187
  38034,   8.88032246,   76.7461166,   1.81818187
  38035,   8.01850605,   77.0170059,   1.81818187
  38036,   7.14844799,   77.2601242,   1.81818187
  38037,   6.27104378,   77.4752426,   1.81818187
  38038,   5.38719702,   77.6621246,   1.81818187
  38039,   4.49781466,   77.8205795,   1.81818187
  38040,   3.60381103,   77.9504471,   1.81818187
  38041,   2.70610356,     78.05159,   1.81818187
  38042,   1.80561531,   78.1239166,   1.81818187
  38043,  0.903271675,   78.1673355,   1.81818187
  38044,           0.,   78.1818161,   1.81818187
  38045, -0.903271675,   78.1673355,   1.81818187
  38046,  -1.80561531,   78.1239166,   1.81818187
  38047,  -2.70610356,     78.05159,   1.81818187
  38048,  -3.60381103,   77.9504471,   1.81818187
  38049,  -4.49781466,   77.8205795,   1.81818187
  38050,  -5.38719702,   77.6621246,   1.81818187
  38051,  -6.27104378,   77.4752426,   1.81818187
  38052,  -7.14844799,   77.2601242,   1.81818187
  38053,  -8.01850605,   77.0170059,   1.81818187
  38054,  -8.88032246,   76.7461166,   1.81818187
  38055,  -9.73301506,   76.4477463,   1.81818187
  38056,  -10.5757065,      76.1222,   1.81818187
  38057,  -11.4075298,   75.7698135,   1.81818187
  38058,  -12.2276316,   75.3909378,   1.81818187
  38059,  -13.0351706,   74.9859772,   1.81818187
  38060,  -13.8293123,   74.5553436,   1.81818187
  38061,  -14.6092463,   74.0994797,   1.81818187
  38062,  -15.3741636,   73.6188431,   1.81818187
  38063,  -16.1232853,    73.113945,   1.81818187
  38064,  -16.8558407,   72.5852966,   1.81818187
  38065,  -17.5710773,    72.033432,   1.81818187
  38066,  -18.2682571,    71.458931,   1.81818187
  38067,  -18.9466591,    70.862381,   1.81818187
  38068,  -19.6055965,   70.2443924,   1.81818187
  38069,  -20.2443905,   69.6055984,   1.81818187
  38070,  -20.8623772,   68.9466629,   1.81818187
  38071,   -21.458931,   68.2682571,   1.81818187
  38072,  -22.0334301,   67.5710754,   1.81818187
  38073,  -22.5852947,   66.8558426,   1.81818187
  38074,  -23.1139469,    66.123291,   1.81818187
  38075,   -23.618845,   65.3741684,   1.81818187
  38076,  -24.0994759,   64.6092453,   1.81818187
  38077,  -24.5553455,   63.8293114,   1.81818187
  38078,   -24.985981,   63.0351715,   1.81818187
  38079,  -25.3909416,   62.2276344,   1.81818187
  38080,  -25.7698097,   61.4075317,   1.81818187
  38081,     -26.1222,   60.5757065,   1.81818187
  38082,  -26.4477463,    59.733017,   1.81818187
  38083,  -26.7461166,   58.8803215,   1.81818187
  38084,   -27.017004,   58.0185051,   1.81818187
  38085,   -27.260128,   57.1484489,   1.81818187
  38086,  -27.4752407,   56.2710457,   1.81818187
  38087,  -27.6621189,   55.3871994,   1.81818187
  38088,  -27.8205776,   54.4978142,   1.81818187
  38089,  -27.9504452,   53.6038094,   1.81818187
  38090,  -28.0515938,   52.7061043,   1.81818187
  38091,  -28.1239147,   51.8056145,   1.81818187
  38092,  -28.1673393,   50.9032707,   1.81818187
  38093,   28.1673393,   50.9032707,   2.72727275
  38094,   28.1239147,   51.8056145,   2.72727275
  38095,   28.0515938,   52.7061043,   2.72727275
  38096,   27.9504452,   53.6038094,   2.72727275
  38097,   27.8205776,   54.4978142,   2.72727275
  38098,   27.6621189,   55.3871994,   2.72727275
  38099,   27.4752407,   56.2710457,   2.72727275
  38100,    27.260128,   57.1484489,   2.72727275
  38101,    27.017004,   58.0185051,   2.72727275
  38102,   26.7461166,   58.8803215,   2.72727275
  38103,   26.4477463,    59.733017,   2.72727275
  38104,      26.1222,   60.5757065,   2.72727275
  38105,   25.7698097,   61.4075317,   2.72727275
  38106,   25.3909416,   62.2276344,   2.72727275
  38107,    24.985981,   63.0351715,   2.72727275
  38108,   24.5553455,   63.8293114,   2.72727275
  38109,   24.0994759,   64.6092453,   2.72727275
  38110,    23.618845,   65.3741684,   2.72727275
  38111,   23.1139469,    66.123291,   2.72727275
  38112,   22.5852947,   66.8558426,   2.72727275
  38113,   22.0334301,   67.5710754,   2.72727275
  38114,    21.458931,   68.2682571,   2.72727275
  38115,   20.8623772,   68.9466629,   2.72727275
  38116,   20.2443905,   69.6055984,   2.72727275
  38117,   19.6055965,   70.2443924,   2.72727275
  38118,   18.9466591,    70.862381,   2.72727275
  38119,   18.2682571,    71.458931,   2.72727275
  38120,   17.5710773,    72.033432,   2.72727275
  38121,   16.8558407,   72.5852966,   2.72727275
  38122,   16.1232853,    73.113945,   2.72727275
  38123,   15.3741636,   73.6188431,   2.72727275
  38124,   14.6092463,   74.0994797,   2.72727275
  38125,   13.8293123,   74.5553436,   2.72727275
  38126,   13.0351706,   74.9859772,   2.72727275
  38127,   12.2276316,   75.3909378,   2.72727275
  38128,   11.4075298,   75.7698135,   2.72727275
  38129,   10.5757065,      76.1222,   2.72727275
  38130,   9.73301506,   76.4477463,   2.72727275
  38131,   8.88032246,   76.7461166,   2.72727275
  38132,   8.01850605,   77.0170059,   2.72727275
  38133,   7.14844799,   77.2601242,   2.72727275
  38134,   6.27104378,   77.4752426,   2.72727275
  38135,   5.38719702,   77.6621246,   2.72727275
  38136,   4.49781466,   77.8205795,   2.72727275
  38137,   3.60381103,   77.9504471,   2.72727275
  38138,   2.70610356,     78.05159,   2.72727275
  38139,   1.80561531,   78.1239166,   2.72727275
  38140,  0.903271675,   78.1673355,   2.72727275
  38141,           0.,   78.1818161,   2.72727275
  38142, -0.903271675,   78.1673355,   2.72727275
  38143,  -1.80561531,   78.1239166,   2.72727275
  38144,  -2.70610356,     78.05159,   2.72727275
  38145,  -3.60381103,   77.9504471,   2.72727275
  38146,  -4.49781466,   77.8205795,   2.72727275
  38147,  -5.38719702,   77.6621246,   2.72727275
  38148,  -6.27104378,   77.4752426,   2.72727275
  38149,  -7.14844799,   77.2601242,   2.72727275
  38150,  -8.01850605,   77.0170059,   2.72727275
  38151,  -8.88032246,   76.7461166,   2.72727275
  38152,  -9.73301506,   76.4477463,   2.72727275
  38153,  -10.5757065,      76.1222,   2.72727275
  38154,  -11.4075298,   75.7698135,   2.72727275
  38155,  -12.2276316,   75.3909378,   2.72727275
  38156,  -13.0351706,   74.9859772,   2.72727275
  38157,  -13.8293123,   74.5553436,   2.72727275
  38158,  -14.6092463,   74.0994797,   2.72727275
  38159,  -15.3741636,   73.6188431,   2.72727275
  38160,  -16.1232853,    73.113945,   2.72727275
  38161,  -16.8558407,   72.5852966,   2.72727275
  38162,  -17.5710773,    72.033432,   2.72727275
  38163,  -18.2682571,    71.458931,   2.72727275
  38164,  -18.9466591,    70.862381,   2.72727275
  38165,  -19.6055965,   70.2443924,   2.72727275
  38166,  -20.2443905,   69.6055984,   2.72727275
  38167,  -20.8623772,   68.9466629,   2.72727275
  38168,   -21.458931,   68.2682571,   2.72727275
  38169,  -22.0334301,   67.5710754,   2.72727275
  38170,  -22.5852947,   66.8558426,   2.72727275
  38171,  -23.1139469,    66.123291,   2.72727275
  38172,   -23.618845,   65.3741684,   2.72727275
  38173,  -24.0994759,   64.6092453,   2.72727275
  38174,  -24.5553455,   63.8293114,   2.72727275
  38175,   -24.985981,   63.0351715,   2.72727275
  38176,  -25.3909416,   62.2276344,   2.72727275
  38177,  -25.7698097,   61.4075317,   2.72727275
  38178,     -26.1222,   60.5757065,   2.72727275
  38179,  -26.4477463,    59.733017,   2.72727275
  38180,  -26.7461166,   58.8803215,   2.72727275
  38181,   -27.017004,   58.0185051,   2.72727275
  38182,   -27.260128,   57.1484489,   2.72727275
  38183,  -27.4752407,   56.2710457,   2.72727275
  38184,  -27.6621189,   55.3871994,   2.72727275
  38185,  -27.8205776,   54.4978142,   2.72727275
  38186,  -27.9504452,   53.6038094,   2.72727275
  38187,  -28.0515938,   52.7061043,   2.72727275
  38188,  -28.1239147,   51.8056145,   2.72727275
  38189,  -28.1673393,   50.9032707,   2.72727275
  38190,   28.1673393,   50.9032707,   3.63636374
  38191,   28.1239147,   51.8056145,   3.63636374
  38192,   28.0515938,   52.7061043,   3.63636374
  38193,   27.9504452,   53.6038094,   3.63636374
  38194,   27.8205776,   54.4978142,   3.63636374
  38195,   27.6621189,   55.3871994,   3.63636374
  38196,   27.4752407,   56.2710457,   3.63636374
  38197,    27.260128,   57.1484489,   3.63636374
  38198,    27.017004,   58.0185051,   3.63636374
  38199,   26.7461166,   58.8803215,   3.63636374
  38200,   26.4477463,    59.733017,   3.63636374
  38201,      26.1222,   60.5757065,   3.63636374
  38202,   25.7698097,   61.4075317,   3.63636374
  38203,   25.3909416,   62.2276344,   3.63636374
  38204,    24.985981,   63.0351715,   3.63636374
  38205,   24.5553455,   63.8293114,   3.63636374
  38206,   24.0994759,   64.6092453,   3.63636374
  38207,    23.618845,   65.3741684,   3.63636374
  38208,   23.1139469,    66.123291,   3.63636374
  38209,   22.5852947,   66.8558426,   3.63636374
  38210,   22.0334301,   67.5710754,   3.63636374
  38211,    21.458931,   68.2682571,   3.63636374
  38212,   20.8623772,   68.9466629,   3.63636374
  38213,   20.2443905,   69.6055984,   3.63636374
  38214,   19.6055965,   70.2443924,   3.63636374
  38215,   18.9466591,    70.862381,   3.63636374
  38216,   18.2682571,    71.458931,   3.63636374
  38217,   17.5710773,    72.033432,   3.63636374
  38218,   16.8558407,   72.5852966,   3.63636374
  38219,   16.1232853,    73.113945,   3.63636374
  38220,   15.3741636,   73.6188431,   3.63636374
  38221,   14.6092463,   74.0994797,   3.63636374
  38222,   13.8293123,   74.5553436,   3.63636374
  38223,   13.0351706,   74.9859772,   3.63636374
  38224,   12.2276316,   75.3909378,   3.63636374
  38225,   11.4075298,   75.7698135,   3.63636374
  38226,   10.5757065,      76.1222,   3.63636374
  38227,   9.73301506,   76.4477463,   3.63636374
  38228,   8.88032246,   76.7461166,   3.63636374
  38229,   8.01850605,   77.0170059,   3.63636374
  38230,   7.14844799,   77.2601242,   3.63636374
  38231,   6.27104378,   77.4752426,   3.63636374
  38232,   5.38719702,   77.6621246,   3.63636374
  38233,   4.49781466,   77.8205795,   3.63636374
  38234,   3.60381103,   77.9504471,   3.63636374
  38235,   2.70610356,     78.05159,   3.63636374
  38236,   1.80561531,   78.1239166,   3.63636374
  38237,  0.903271675,   78.1673355,   3.63636374
  38238,           0.,   78.1818161,   3.63636374
  38239, -0.903271675,   78.1673355,   3.63636374
  38240,  -1.80561531,   78.1239166,   3.63636374
  38241,  -2.70610356,     78.05159,   3.63636374
  38242,  -3.60381103,   77.9504471,   3.63636374
  38243,  -4.49781466,   77.8205795,   3.63636374
  38244,  -5.38719702,   77.6621246,   3.63636374
  38245,  -6.27104378,   77.4752426,   3.63636374
  38246,  -7.14844799,   77.2601242,   3.63636374
  38247,  -8.01850605,   77.0170059,   3.63636374
  38248,  -8.88032246,   76.7461166,   3.63636374
  38249,  -9.73301506,   76.4477463,   3.63636374
  38250,  -10.5757065,      76.1222,   3.63636374
  38251,  -11.4075298,   75.7698135,   3.63636374
  38252,  -12.2276316,   75.3909378,   3.63636374
  38253,  -13.0351706,   74.9859772,   3.63636374
  38254,  -13.8293123,   74.5553436,   3.63636374
  38255,  -14.6092463,   74.0994797,   3.63636374
  38256,  -15.3741636,   73.6188431,   3.63636374
  38257,  -16.1232853,    73.113945,   3.63636374
  38258,  -16.8558407,   72.5852966,   3.63636374
  38259,  -17.5710773,    72.033432,   3.63636374
  38260,  -18.2682571,    71.458931,   3.63636374
  38261,  -18.9466591,    70.862381,   3.63636374
  38262,  -19.6055965,   70.2443924,   3.63636374
  38263,  -20.2443905,   69.6055984,   3.63636374
  38264,  -20.8623772,   68.9466629,   3.63636374
  38265,   -21.458931,   68.2682571,   3.63636374
  38266,  -22.0334301,   67.5710754,   3.63636374
  38267,  -22.5852947,   66.8558426,   3.63636374
  38268,  -23.1139469,    66.123291,   3.63636374
  38269,   -23.618845,   65.3741684,   3.63636374
  38270,  -24.0994759,   64.6092453,   3.63636374
  38271,  -24.5553455,   63.8293114,   3.63636374
  38272,   -24.985981,   63.0351715,   3.63636374
  38273,  -25.3909416,   62.2276344,   3.63636374
  38274,  -25.7698097,   61.4075317,   3.63636374
  38275,     -26.1222,   60.5757065,   3.63636374
  38276,  -26.4477463,    59.733017,   3.63636374
  38277,  -26.7461166,   58.8803215,   3.63636374
  38278,   -27.017004,   58.0185051,   3.63636374
  38279,   -27.260128,   57.1484489,   3.63636374
  38280,  -27.4752407,   56.2710457,   3.63636374
  38281,  -27.6621189,   55.3871994,   3.63636374
  38282,  -27.8205776,   54.4978142,   3.63636374
  38283,  -27.9504452,   53.6038094,   3.63636374
  38284,  -28.0515938,   52.7061043,   3.63636374
  38285,  -28.1239147,   51.8056145,   3.63636374
  38286,  -28.1673393,   50.9032707,   3.63636374
  38287,   28.1673393,   50.9032707,    4.5454545
  38288,   28.1239147,   51.8056145,    4.5454545
  38289,   28.0515938,   52.7061043,    4.5454545
  38290,   27.9504452,   53.6038094,    4.5454545
  38291,   27.8205776,   54.4978142,    4.5454545
  38292,   27.6621189,   55.3871994,    4.5454545
  38293,   27.4752407,   56.2710457,    4.5454545
  38294,    27.260128,   57.1484489,    4.5454545
  38295,    27.017004,   58.0185051,    4.5454545
  38296,   26.7461166,   58.8803215,    4.5454545
  38297,   26.4477463,    59.733017,    4.5454545
  38298,      26.1222,   60.5757065,    4.5454545
  38299,   25.7698097,   61.4075317,    4.5454545
  38300,   25.3909416,   62.2276344,    4.5454545
  38301,    24.985981,   63.0351715,    4.5454545
  38302,   24.5553455,   63.8293114,    4.5454545
  38303,   24.0994759,   64.6092453,    4.5454545
  38304,    23.618845,   65.3741684,    4.5454545
  38305,   23.1139469,    66.123291,    4.5454545
  38306,   22.5852947,   66.8558426,    4.5454545
  38307,   22.0334301,   67.5710754,    4.5454545
  38308,    21.458931,   68.2682571,    4.5454545
  38309,   20.8623772,   68.9466629,    4.5454545
  38310,   20.2443905,   69.6055984,    4.5454545
  38311,   19.6055965,   70.2443924,    4.5454545
  38312,   18.9466591,    70.862381,    4.5454545
  38313,   18.2682571,    71.458931,    4.5454545
  38314,   17.5710773,    72.033432,    4.5454545
  38315,   16.8558407,   72.5852966,    4.5454545
  38316,   16.1232853,    73.113945,    4.5454545
  38317,   15.3741636,   73.6188431,    4.5454545
  38318,   14.6092463,   74.0994797,    4.5454545
  38319,   13.8293123,   74.5553436,    4.5454545
  38320,   13.0351706,   74.9859772,    4.5454545
  38321,   12.2276316,   75.3909378,    4.5454545
  38322,   11.4075298,   75.7698135,    4.5454545
  38323,   10.5757065,      76.1222,    4.5454545
  38324,   9.73301506,   76.4477463,    4.5454545
  38325,   8.88032246,   76.7461166,    4.5454545
  38326,   8.01850605,   77.0170059,    4.5454545
  38327,   7.14844799,   77.2601242,    4.5454545
  38328,   6.27104378,   77.4752426,    4.5454545
  38329,   5.38719702,   77.6621246,    4.5454545
  38330,   4.49781466,   77.8205795,    4.5454545
  38331,   3.60381103,   77.9504471,    4.5454545
  38332,   2.70610356,     78.05159,    4.5454545
  38333,   1.80561531,   78.1239166,    4.5454545
  38334,  0.903271675,   78.1673355,    4.5454545
  38335,           0.,   78.1818161,    4.5454545
  38336, -0.903271675,   78.1673355,    4.5454545
  38337,  -1.80561531,   78.1239166,    4.5454545
  38338,  -2.70610356,     78.05159,    4.5454545
  38339,  -3.60381103,   77.9504471,    4.5454545
  38340,  -4.49781466,   77.8205795,    4.5454545
  38341,  -5.38719702,   77.6621246,    4.5454545
  38342,  -6.27104378,   77.4752426,    4.5454545
  38343,  -7.14844799,   77.2601242,    4.5454545
  38344,  -8.01850605,   77.0170059,    4.5454545
  38345,  -8.88032246,   76.7461166,    4.5454545
  38346,  -9.73301506,   76.4477463,    4.5454545
  38347,  -10.5757065,      76.1222,    4.5454545
  38348,  -11.4075298,   75.7698135,    4.5454545
  38349,  -12.2276316,   75.3909378,    4.5454545
  38350,  -13.0351706,   74.9859772,    4.5454545
  38351,  -13.8293123,   74.5553436,    4.5454545
  38352,  -14.6092463,   74.0994797,    4.5454545
  38353,  -15.3741636,   73.6188431,    4.5454545
  38354,  -16.1232853,    73.113945,    4.5454545
  38355,  -16.8558407,   72.5852966,    4.5454545
  38356,  -17.5710773,    72.033432,    4.5454545
  38357,  -18.2682571,    71.458931,    4.5454545
  38358,  -18.9466591,    70.862381,    4.5454545
  38359,  -19.6055965,   70.2443924,    4.5454545
  38360,  -20.2443905,   69.6055984,    4.5454545
  38361,  -20.8623772,   68.9466629,    4.5454545
  38362,   -21.458931,   68.2682571,    4.5454545
  38363,  -22.0334301,   67.5710754,    4.5454545
  38364,  -22.5852947,   66.8558426,    4.5454545
  38365,  -23.1139469,    66.123291,    4.5454545
  38366,   -23.618845,   65.3741684,    4.5454545
  38367,  -24.0994759,   64.6092453,    4.5454545
  38368,  -24.5553455,   63.8293114,    4.5454545
  38369,   -24.985981,   63.0351715,    4.5454545
  38370,  -25.3909416,   62.2276344,    4.5454545
  38371,  -25.7698097,   61.4075317,    4.5454545
  38372,     -26.1222,   60.5757065,    4.5454545
  38373,  -26.4477463,    59.733017,    4.5454545
  38374,  -26.7461166,   58.8803215,    4.5454545
  38375,   -27.017004,   58.0185051,    4.5454545
  38376,   -27.260128,   57.1484489,    4.5454545
  38377,  -27.4752407,   56.2710457,    4.5454545
  38378,  -27.6621189,   55.3871994,    4.5454545
  38379,  -27.8205776,   54.4978142,    4.5454545
  38380,  -27.9504452,   53.6038094,    4.5454545
  38381,  -28.0515938,   52.7061043,    4.5454545
  38382,  -28.1239147,   51.8056145,    4.5454545
  38383,  -28.1673393,   50.9032707,    4.5454545
  38384,   28.1673393,   50.9032707,    5.4545455
  38385,   28.1239147,   51.8056145,    5.4545455
  38386,   28.0515938,   52.7061043,    5.4545455
  38387,   27.9504452,   53.6038094,    5.4545455
  38388,   27.8205776,   54.4978142,    5.4545455
  38389,   27.6621189,   55.3871994,    5.4545455
  38390,   27.4752407,   56.2710457,    5.4545455
  38391,    27.260128,   57.1484489,    5.4545455
  38392,    27.017004,   58.0185051,    5.4545455
  38393,   26.7461166,   58.8803215,    5.4545455
  38394,   26.4477463,    59.733017,    5.4545455
  38395,      26.1222,   60.5757065,    5.4545455
  38396,   25.7698097,   61.4075317,    5.4545455
  38397,   25.3909416,   62.2276344,    5.4545455
  38398,    24.985981,   63.0351715,    5.4545455
  38399,   24.5553455,   63.8293114,    5.4545455
  38400,   24.0994759,   64.6092453,    5.4545455
  38401,    23.618845,   65.3741684,    5.4545455
  38402,   23.1139469,    66.123291,    5.4545455
  38403,   22.5852947,   66.8558426,    5.4545455
  38404,   22.0334301,   67.5710754,    5.4545455
  38405,    21.458931,   68.2682571,    5.4545455
  38406,   20.8623772,   68.9466629,    5.4545455
  38407,   20.2443905,   69.6055984,    5.4545455
  38408,   19.6055965,   70.2443924,    5.4545455
  38409,   18.9466591,    70.862381,    5.4545455
  38410,   18.2682571,    71.458931,    5.4545455
  38411,   17.5710773,    72.033432,    5.4545455
  38412,   16.8558407,   72.5852966,    5.4545455
  38413,   16.1232853,    73.113945,    5.4545455
  38414,   15.3741636,   73.6188431,    5.4545455
  38415,   14.6092463,   74.0994797,    5.4545455
  38416,   13.8293123,   74.5553436,    5.4545455
  38417,   13.0351706,   74.9859772,    5.4545455
  38418,   12.2276316,   75.3909378,    5.4545455
  38419,   11.4075298,   75.7698135,    5.4545455
  38420,   10.5757065,      76.1222,    5.4545455
  38421,   9.73301506,   76.4477463,    5.4545455
  38422,   8.88032246,   76.7461166,    5.4545455
  38423,   8.01850605,   77.0170059,    5.4545455
  38424,   7.14844799,   77.2601242,    5.4545455
  38425,   6.27104378,   77.4752426,    5.4545455
  38426,   5.38719702,   77.6621246,    5.4545455
  38427,   4.49781466,   77.8205795,    5.4545455
  38428,   3.60381103,   77.9504471,    5.4545455
  38429,   2.70610356,     78.05159,    5.4545455
  38430,   1.80561531,   78.1239166,    5.4545455
  38431,  0.903271675,   78.1673355,    5.4545455
  38432,           0.,   78.1818161,    5.4545455
  38433, -0.903271675,   78.1673355,    5.4545455
  38434,  -1.80561531,   78.1239166,    5.4545455
  38435,  -2.70610356,     78.05159,    5.4545455
  38436,  -3.60381103,   77.9504471,    5.4545455
  38437,  -4.49781466,   77.8205795,    5.4545455
  38438,  -5.38719702,   77.6621246,    5.4545455
  38439,  -6.27104378,   77.4752426,    5.4545455
  38440,  -7.14844799,   77.2601242,    5.4545455
  38441,  -8.01850605,   77.0170059,    5.4545455
  38442,  -8.88032246,   76.7461166,    5.4545455
  38443,  -9.73301506,   76.4477463,    5.4545455
  38444,  -10.5757065,      76.1222,    5.4545455
  38445,  -11.4075298,   75.7698135,    5.4545455
  38446,  -12.2276316,   75.3909378,    5.4545455
  38447,  -13.0351706,   74.9859772,    5.4545455
  38448,  -13.8293123,   74.5553436,    5.4545455
  38449,  -14.6092463,   74.0994797,    5.4545455
  38450,  -15.3741636,   73.6188431,    5.4545455
  38451,  -16.1232853,    73.113945,    5.4545455
  38452,  -16.8558407,   72.5852966,    5.4545455
  38453,  -17.5710773,    72.033432,    5.4545455
  38454,  -18.2682571,    71.458931,    5.4545455
  38455,  -18.9466591,    70.862381,    5.4545455
  38456,  -19.6055965,   70.2443924,    5.4545455
  38457,  -20.2443905,   69.6055984,    5.4545455
  38458,  -20.8623772,   68.9466629,    5.4545455
  38459,   -21.458931,   68.2682571,    5.4545455
  38460,  -22.0334301,   67.5710754,    5.4545455
  38461,  -22.5852947,   66.8558426,    5.4545455
  38462,  -23.1139469,    66.123291,    5.4545455
  38463,   -23.618845,   65.3741684,    5.4545455
  38464,  -24.0994759,   64.6092453,    5.4545455
  38465,  -24.5553455,   63.8293114,    5.4545455
  38466,   -24.985981,   63.0351715,    5.4545455
  38467,  -25.3909416,   62.2276344,    5.4545455
  38468,  -25.7698097,   61.4075317,    5.4545455
  38469,     -26.1222,   60.5757065,    5.4545455
  38470,  -26.4477463,    59.733017,    5.4545455
  38471,  -26.7461166,   58.8803215,    5.4545455
  38472,   -27.017004,   58.0185051,    5.4545455
  38473,   -27.260128,   57.1484489,    5.4545455
  38474,  -27.4752407,   56.2710457,    5.4545455
  38475,  -27.6621189,   55.3871994,    5.4545455
  38476,  -27.8205776,   54.4978142,    5.4545455
  38477,  -27.9504452,   53.6038094,    5.4545455
  38478,  -28.0515938,   52.7061043,    5.4545455
  38479,  -28.1239147,   51.8056145,    5.4545455
  38480,  -28.1673393,   50.9032707,    5.4545455
  38481,   28.1673393,   50.9032707,   6.36363649
  38482,   28.1239147,   51.8056145,   6.36363649
  38483,   28.0515938,   52.7061043,   6.36363649
  38484,   27.9504452,   53.6038094,   6.36363649
  38485,   27.8205776,   54.4978142,   6.36363649
  38486,   27.6621189,   55.3871994,   6.36363649
  38487,   27.4752407,   56.2710457,   6.36363649
  38488,    27.260128,   57.1484489,   6.36363649
  38489,    27.017004,   58.0185051,   6.36363649
  38490,   26.7461166,   58.8803215,   6.36363649
  38491,   26.4477463,    59.733017,   6.36363649
  38492,      26.1222,   60.5757065,   6.36363649
  38493,   25.7698097,   61.4075317,   6.36363649
  38494,   25.3909416,   62.2276344,   6.36363649
  38495,    24.985981,   63.0351715,   6.36363649
  38496,   24.5553455,   63.8293114,   6.36363649
  38497,   24.0994759,   64.6092453,   6.36363649
  38498,    23.618845,   65.3741684,   6.36363649
  38499,   23.1139469,    66.123291,   6.36363649
  38500,   22.5852947,   66.8558426,   6.36363649
  38501,   22.0334301,   67.5710754,   6.36363649
  38502,    21.458931,   68.2682571,   6.36363649
  38503,   20.8623772,   68.9466629,   6.36363649
  38504,   20.2443905,   69.6055984,   6.36363649
  38505,   19.6055965,   70.2443924,   6.36363649
  38506,   18.9466591,    70.862381,   6.36363649
  38507,   18.2682571,    71.458931,   6.36363649
  38508,   17.5710773,    72.033432,   6.36363649
  38509,   16.8558407,   72.5852966,   6.36363649
  38510,   16.1232853,    73.113945,   6.36363649
  38511,   15.3741636,   73.6188431,   6.36363649
  38512,   14.6092463,   74.0994797,   6.36363649
  38513,   13.8293123,   74.5553436,   6.36363649
  38514,   13.0351706,   74.9859772,   6.36363649
  38515,   12.2276316,   75.3909378,   6.36363649
  38516,   11.4075298,   75.7698135,   6.36363649
  38517,   10.5757065,      76.1222,   6.36363649
  38518,   9.73301506,   76.4477463,   6.36363649
  38519,   8.88032246,   76.7461166,   6.36363649
  38520,   8.01850605,   77.0170059,   6.36363649
  38521,   7.14844799,   77.2601242,   6.36363649
  38522,   6.27104378,   77.4752426,   6.36363649
  38523,   5.38719702,   77.6621246,   6.36363649
  38524,   4.49781466,   77.8205795,   6.36363649
  38525,   3.60381103,   77.9504471,   6.36363649
  38526,   2.70610356,     78.05159,   6.36363649
  38527,   1.80561531,   78.1239166,   6.36363649
  38528,  0.903271675,   78.1673355,   6.36363649
  38529,           0.,   78.1818161,   6.36363649
  38530, -0.903271675,   78.1673355,   6.36363649
  38531,  -1.80561531,   78.1239166,   6.36363649
  38532,  -2.70610356,     78.05159,   6.36363649
  38533,  -3.60381103,   77.9504471,   6.36363649
  38534,  -4.49781466,   77.8205795,   6.36363649
  38535,  -5.38719702,   77.6621246,   6.36363649
  38536,  -6.27104378,   77.4752426,   6.36363649
  38537,  -7.14844799,   77.2601242,   6.36363649
  38538,  -8.01850605,   77.0170059,   6.36363649
  38539,  -8.88032246,   76.7461166,   6.36363649
  38540,  -9.73301506,   76.4477463,   6.36363649
  38541,  -10.5757065,      76.1222,   6.36363649
  38542,  -11.4075298,   75.7698135,   6.36363649
  38543,  -12.2276316,   75.3909378,   6.36363649
  38544,  -13.0351706,   74.9859772,   6.36363649
  38545,  -13.8293123,   74.5553436,   6.36363649
  38546,  -14.6092463,   74.0994797,   6.36363649
  38547,  -15.3741636,   73.6188431,   6.36363649
  38548,  -16.1232853,    73.113945,   6.36363649
  38549,  -16.8558407,   72.5852966,   6.36363649
  38550,  -17.5710773,    72.033432,   6.36363649
  38551,  -18.2682571,    71.458931,   6.36363649
  38552,  -18.9466591,    70.862381,   6.36363649
  38553,  -19.6055965,   70.2443924,   6.36363649
  38554,  -20.2443905,   69.6055984,   6.36363649
  38555,  -20.8623772,   68.9466629,   6.36363649
  38556,   -21.458931,   68.2682571,   6.36363649
  38557,  -22.0334301,   67.5710754,   6.36363649
  38558,  -22.5852947,   66.8558426,   6.36363649
  38559,  -23.1139469,    66.123291,   6.36363649
  38560,   -23.618845,   65.3741684,   6.36363649
  38561,  -24.0994759,   64.6092453,   6.36363649
  38562,  -24.5553455,   63.8293114,   6.36363649
  38563,   -24.985981,   63.0351715,   6.36363649
  38564,  -25.3909416,   62.2276344,   6.36363649
  38565,  -25.7698097,   61.4075317,   6.36363649
  38566,     -26.1222,   60.5757065,   6.36363649
  38567,  -26.4477463,    59.733017,   6.36363649
  38568,  -26.7461166,   58.8803215,   6.36363649
  38569,   -27.017004,   58.0185051,   6.36363649
  38570,   -27.260128,   57.1484489,   6.36363649
  38571,  -27.4752407,   56.2710457,   6.36363649
  38572,  -27.6621189,   55.3871994,   6.36363649
  38573,  -27.8205776,   54.4978142,   6.36363649
  38574,  -27.9504452,   53.6038094,   6.36363649
  38575,  -28.0515938,   52.7061043,   6.36363649
  38576,  -28.1239147,   51.8056145,   6.36363649
  38577,  -28.1673393,   50.9032707,   6.36363649
  38578,   28.1673393,   50.9032707,   7.27272749
  38579,   28.1239147,   51.8056145,   7.27272749
  38580,   28.0515938,   52.7061043,   7.27272749
  38581,   27.9504452,   53.6038094,   7.27272749
  38582,   27.8205776,   54.4978142,   7.27272749
  38583,   27.6621189,   55.3871994,   7.27272749
  38584,   27.4752407,   56.2710457,   7.27272749
  38585,    27.260128,   57.1484489,   7.27272749
  38586,    27.017004,   58.0185051,   7.27272749
  38587,   26.7461166,   58.8803215,   7.27272749
  38588,   26.4477463,    59.733017,   7.27272749
  38589,      26.1222,   60.5757065,   7.27272749
  38590,   25.7698097,   61.4075317,   7.27272749
  38591,   25.3909416,   62.2276344,   7.27272749
  38592,    24.985981,   63.0351715,   7.27272749
  38593,   24.5553455,   63.8293114,   7.27272749
  38594,   24.0994759,   64.6092453,   7.27272749
  38595,    23.618845,   65.3741684,   7.27272749
  38596,   23.1139469,    66.123291,   7.27272749
  38597,   22.5852947,   66.8558426,   7.27272749
  38598,   22.0334301,   67.5710754,   7.27272749
  38599,    21.458931,   68.2682571,   7.27272749
  38600,   20.8623772,   68.9466629,   7.27272749
  38601,   20.2443905,   69.6055984,   7.27272749
  38602,   19.6055965,   70.2443924,   7.27272749
  38603,   18.9466591,    70.862381,   7.27272749
  38604,   18.2682571,    71.458931,   7.27272749
  38605,   17.5710773,    72.033432,   7.27272749
  38606,   16.8558407,   72.5852966,   7.27272749
  38607,   16.1232853,    73.113945,   7.27272749
  38608,   15.3741636,   73.6188431,   7.27272749
  38609,   14.6092463,   74.0994797,   7.27272749
  38610,   13.8293123,   74.5553436,   7.27272749
  38611,   13.0351706,   74.9859772,   7.27272749
  38612,   12.2276316,   75.3909378,   7.27272749
  38613,   11.4075298,   75.7698135,   7.27272749
  38614,   10.5757065,      76.1222,   7.27272749
  38615,   9.73301506,   76.4477463,   7.27272749
  38616,   8.88032246,   76.7461166,   7.27272749
  38617,   8.01850605,   77.0170059,   7.27272749
  38618,   7.14844799,   77.2601242,   7.27272749
  38619,   6.27104378,   77.4752426,   7.27272749
  38620,   5.38719702,   77.6621246,   7.27272749
  38621,   4.49781466,   77.8205795,   7.27272749
  38622,   3.60381103,   77.9504471,   7.27272749
  38623,   2.70610356,     78.05159,   7.27272749
  38624,   1.80561531,   78.1239166,   7.27272749
  38625,  0.903271675,   78.1673355,   7.27272749
  38626,           0.,   78.1818161,   7.27272749
  38627, -0.903271675,   78.1673355,   7.27272749
  38628,  -1.80561531,   78.1239166,   7.27272749
  38629,  -2.70610356,     78.05159,   7.27272749
  38630,  -3.60381103,   77.9504471,   7.27272749
  38631,  -4.49781466,   77.8205795,   7.27272749
  38632,  -5.38719702,   77.6621246,   7.27272749
  38633,  -6.27104378,   77.4752426,   7.27272749
  38634,  -7.14844799,   77.2601242,   7.27272749
  38635,  -8.01850605,   77.0170059,   7.27272749
  38636,  -8.88032246,   76.7461166,   7.27272749
  38637,  -9.73301506,   76.4477463,   7.27272749
  38638,  -10.5757065,      76.1222,   7.27272749
  38639,  -11.4075298,   75.7698135,   7.27272749
  38640,  -12.2276316,   75.3909378,   7.27272749
  38641,  -13.0351706,   74.9859772,   7.27272749
  38642,  -13.8293123,   74.5553436,   7.27272749
  38643,  -14.6092463,   74.0994797,   7.27272749
  38644,  -15.3741636,   73.6188431,   7.27272749
  38645,  -16.1232853,    73.113945,   7.27272749
  38646,  -16.8558407,   72.5852966,   7.27272749
  38647,  -17.5710773,    72.033432,   7.27272749
  38648,  -18.2682571,    71.458931,   7.27272749
  38649,  -18.9466591,    70.862381,   7.27272749
  38650,  -19.6055965,   70.2443924,   7.27272749
  38651,  -20.2443905,   69.6055984,   7.27272749
  38652,  -20.8623772,   68.9466629,   7.27272749
  38653,   -21.458931,   68.2682571,   7.27272749
  38654,  -22.0334301,   67.5710754,   7.27272749
  38655,  -22.5852947,   66.8558426,   7.27272749
  38656,  -23.1139469,    66.123291,   7.27272749
  38657,   -23.618845,   65.3741684,   7.27272749
  38658,  -24.0994759,   64.6092453,   7.27272749
  38659,  -24.5553455,   63.8293114,   7.27272749
  38660,   -24.985981,   63.0351715,   7.27272749
  38661,  -25.3909416,   62.2276344,   7.27272749
  38662,  -25.7698097,   61.4075317,   7.27272749
  38663,     -26.1222,   60.5757065,   7.27272749
  38664,  -26.4477463,    59.733017,   7.27272749
  38665,  -26.7461166,   58.8803215,   7.27272749
  38666,   -27.017004,   58.0185051,   7.27272749
  38667,   -27.260128,   57.1484489,   7.27272749
  38668,  -27.4752407,   56.2710457,   7.27272749
  38669,  -27.6621189,   55.3871994,   7.27272749
  38670,  -27.8205776,   54.4978142,   7.27272749
  38671,  -27.9504452,   53.6038094,   7.27272749
  38672,  -28.0515938,   52.7061043,   7.27272749
  38673,  -28.1239147,   51.8056145,   7.27272749
  38674,  -28.1673393,   50.9032707,   7.27272749
  38675,   28.1673393,   50.9032707,   8.18181801
  38676,   28.1239147,   51.8056145,   8.18181801
  38677,   28.0515938,   52.7061043,   8.18181801
  38678,   27.9504452,   53.6038094,   8.18181801
  38679,   27.8205776,   54.4978142,   8.18181801
  38680,   27.6621189,   55.3871994,   8.18181801
  38681,   27.4752407,   56.2710457,   8.18181801
  38682,    27.260128,   57.1484489,   8.18181801
  38683,    27.017004,   58.0185051,   8.18181801
  38684,   26.7461166,   58.8803215,   8.18181801
  38685,   26.4477463,    59.733017,   8.18181801
  38686,      26.1222,   60.5757065,   8.18181801
  38687,   25.7698097,   61.4075317,   8.18181801
  38688,   25.3909416,   62.2276344,   8.18181801
  38689,    24.985981,   63.0351715,   8.18181801
  38690,   24.5553455,   63.8293114,   8.18181801
  38691,   24.0994759,   64.6092453,   8.18181801
  38692,    23.618845,   65.3741684,   8.18181801
  38693,   23.1139469,    66.123291,   8.18181801
  38694,   22.5852947,   66.8558426,   8.18181801
  38695,   22.0334301,   67.5710754,   8.18181801
  38696,    21.458931,   68.2682571,   8.18181801
  38697,   20.8623772,   68.9466629,   8.18181801
  38698,   20.2443905,   69.6055984,   8.18181801
  38699,   19.6055965,   70.2443924,   8.18181801
  38700,   18.9466591,    70.862381,   8.18181801
  38701,   18.2682571,    71.458931,   8.18181801
  38702,   17.5710773,    72.033432,   8.18181801
  38703,   16.8558407,   72.5852966,   8.18181801
  38704,   16.1232853,    73.113945,   8.18181801
  38705,   15.3741636,   73.6188431,   8.18181801
  38706,   14.6092463,   74.0994797,   8.18181801
  38707,   13.8293123,   74.5553436,   8.18181801
  38708,   13.0351706,   74.9859772,   8.18181801
  38709,   12.2276316,   75.3909378,   8.18181801
  38710,   11.4075298,   75.7698135,   8.18181801
  38711,   10.5757065,      76.1222,   8.18181801
  38712,   9.73301506,   76.4477463,   8.18181801
  38713,   8.88032246,   76.7461166,   8.18181801
  38714,   8.01850605,   77.0170059,   8.18181801
  38715,   7.14844799,   77.2601242,   8.18181801
  38716,   6.27104378,   77.4752426,   8.18181801
  38717,   5.38719702,   77.6621246,   8.18181801
  38718,   4.49781466,   77.8205795,   8.18181801
  38719,   3.60381103,   77.9504471,   8.18181801
  38720,   2.70610356,     78.05159,   8.18181801
  38721,   1.80561531,   78.1239166,   8.18181801
  38722,  0.903271675,   78.1673355,   8.18181801
  38723,           0.,   78.1818161,   8.18181801
  38724, -0.903271675,   78.1673355,   8.18181801
  38725,  -1.80561531,   78.1239166,   8.18181801
  38726,  -2.70610356,     78.05159,   8.18181801
  38727,  -3.60381103,   77.9504471,   8.18181801
  38728,  -4.49781466,   77.8205795,   8.18181801
  38729,  -5.38719702,   77.6621246,   8.18181801
  38730,  -6.27104378,   77.4752426,   8.18181801
  38731,  -7.14844799,   77.2601242,   8.18181801
  38732,  -8.01850605,   77.0170059,   8.18181801
  38733,  -8.88032246,   76.7461166,   8.18181801
  38734,  -9.73301506,   76.4477463,   8.18181801
  38735,  -10.5757065,      76.1222,   8.18181801
  38736,  -11.4075298,   75.7698135,   8.18181801
  38737,  -12.2276316,   75.3909378,   8.18181801
  38738,  -13.0351706,   74.9859772,   8.18181801
  38739,  -13.8293123,   74.5553436,   8.18181801
  38740,  -14.6092463,   74.0994797,   8.18181801
  38741,  -15.3741636,   73.6188431,   8.18181801
  38742,  -16.1232853,    73.113945,   8.18181801
  38743,  -16.8558407,   72.5852966,   8.18181801
  38744,  -17.5710773,    72.033432,   8.18181801
  38745,  -18.2682571,    71.458931,   8.18181801
  38746,  -18.9466591,    70.862381,   8.18181801
  38747,  -19.6055965,   70.2443924,   8.18181801
  38748,  -20.2443905,   69.6055984,   8.18181801
  38749,  -20.8623772,   68.9466629,   8.18181801
  38750,   -21.458931,   68.2682571,   8.18181801
  38751,  -22.0334301,   67.5710754,   8.18181801
  38752,  -22.5852947,   66.8558426,   8.18181801
  38753,  -23.1139469,    66.123291,   8.18181801
  38754,   -23.618845,   65.3741684,   8.18181801
  38755,  -24.0994759,   64.6092453,   8.18181801
  38756,  -24.5553455,   63.8293114,   8.18181801
  38757,   -24.985981,   63.0351715,   8.18181801
  38758,  -25.3909416,   62.2276344,   8.18181801
  38759,  -25.7698097,   61.4075317,   8.18181801
  38760,     -26.1222,   60.5757065,   8.18181801
  38761,  -26.4477463,    59.733017,   8.18181801
  38762,  -26.7461166,   58.8803215,   8.18181801
  38763,   -27.017004,   58.0185051,   8.18181801
  38764,   -27.260128,   57.1484489,   8.18181801
  38765,  -27.4752407,   56.2710457,   8.18181801
  38766,  -27.6621189,   55.3871994,   8.18181801
  38767,  -27.8205776,   54.4978142,   8.18181801
  38768,  -27.9504452,   53.6038094,   8.18181801
  38769,  -28.0515938,   52.7061043,   8.18181801
  38770,  -28.1239147,   51.8056145,   8.18181801
  38771,  -28.1673393,   50.9032707,   8.18181801
  38772,   28.1673393,   50.9032707,     9.090909
  38773,   28.1239147,   51.8056145,     9.090909
  38774,   28.0515938,   52.7061043,     9.090909
  38775,   27.9504452,   53.6038094,     9.090909
  38776,   27.8205776,   54.4978142,     9.090909
  38777,   27.6621189,   55.3871994,     9.090909
  38778,   27.4752407,   56.2710457,     9.090909
  38779,    27.260128,   57.1484489,     9.090909
  38780,    27.017004,   58.0185051,     9.090909
  38781,   26.7461166,   58.8803215,     9.090909
  38782,   26.4477463,    59.733017,     9.090909
  38783,      26.1222,   60.5757065,     9.090909
  38784,   25.7698097,   61.4075317,     9.090909
  38785,   25.3909416,   62.2276344,     9.090909
  38786,    24.985981,   63.0351715,     9.090909
  38787,   24.5553455,   63.8293114,     9.090909
  38788,   24.0994759,   64.6092453,     9.090909
  38789,    23.618845,   65.3741684,     9.090909
  38790,   23.1139469,    66.123291,     9.090909
  38791,   22.5852947,   66.8558426,     9.090909
  38792,   22.0334301,   67.5710754,     9.090909
  38793,    21.458931,   68.2682571,     9.090909
  38794,   20.8623772,   68.9466629,     9.090909
  38795,   20.2443905,   69.6055984,     9.090909
  38796,   19.6055965,   70.2443924,     9.090909
  38797,   18.9466591,    70.862381,     9.090909
  38798,   18.2682571,    71.458931,     9.090909
  38799,   17.5710773,    72.033432,     9.090909
  38800,   16.8558407,   72.5852966,     9.090909
  38801,   16.1232853,    73.113945,     9.090909
  38802,   15.3741636,   73.6188431,     9.090909
  38803,   14.6092463,   74.0994797,     9.090909
  38804,   13.8293123,   74.5553436,     9.090909
  38805,   13.0351706,   74.9859772,     9.090909
  38806,   12.2276316,   75.3909378,     9.090909
  38807,   11.4075298,   75.7698135,     9.090909
  38808,   10.5757065,      76.1222,     9.090909
  38809,   9.73301506,   76.4477463,     9.090909
  38810,   8.88032246,   76.7461166,     9.090909
  38811,   8.01850605,   77.0170059,     9.090909
  38812,   7.14844799,   77.2601242,     9.090909
  38813,   6.27104378,   77.4752426,     9.090909
  38814,   5.38719702,   77.6621246,     9.090909
  38815,   4.49781466,   77.8205795,     9.090909
  38816,   3.60381103,   77.9504471,     9.090909
  38817,   2.70610356,     78.05159,     9.090909
  38818,   1.80561531,   78.1239166,     9.090909
  38819,  0.903271675,   78.1673355,     9.090909
  38820,           0.,   78.1818161,     9.090909
  38821, -0.903271675,   78.1673355,     9.090909
  38822,  -1.80561531,   78.1239166,     9.090909
  38823,  -2.70610356,     78.05159,     9.090909
  38824,  -3.60381103,   77.9504471,     9.090909
  38825,  -4.49781466,   77.8205795,     9.090909
  38826,  -5.38719702,   77.6621246,     9.090909
  38827,  -6.27104378,   77.4752426,     9.090909
  38828,  -7.14844799,   77.2601242,     9.090909
  38829,  -8.01850605,   77.0170059,     9.090909
  38830,  -8.88032246,   76.7461166,     9.090909
  38831,  -9.73301506,   76.4477463,     9.090909
  38832,  -10.5757065,      76.1222,     9.090909
  38833,  -11.4075298,   75.7698135,     9.090909
  38834,  -12.2276316,   75.3909378,     9.090909
  38835,  -13.0351706,   74.9859772,     9.090909
  38836,  -13.8293123,   74.5553436,     9.090909
  38837,  -14.6092463,   74.0994797,     9.090909
  38838,  -15.3741636,   73.6188431,     9.090909
  38839,  -16.1232853,    73.113945,     9.090909
  38840,  -16.8558407,   72.5852966,     9.090909
  38841,  -17.5710773,    72.033432,     9.090909
  38842,  -18.2682571,    71.458931,     9.090909
  38843,  -18.9466591,    70.862381,     9.090909
  38844,  -19.6055965,   70.2443924,     9.090909
  38845,  -20.2443905,   69.6055984,     9.090909
  38846,  -20.8623772,   68.9466629,     9.090909
  38847,   -21.458931,   68.2682571,     9.090909
  38848,  -22.0334301,   67.5710754,     9.090909
  38849,  -22.5852947,   66.8558426,     9.090909
  38850,  -23.1139469,    66.123291,     9.090909
  38851,   -23.618845,   65.3741684,     9.090909
  38852,  -24.0994759,   64.6092453,     9.090909
  38853,  -24.5553455,   63.8293114,     9.090909
  38854,   -24.985981,   63.0351715,     9.090909
  38855,  -25.3909416,   62.2276344,     9.090909
  38856,  -25.7698097,   61.4075317,     9.090909
  38857,     -26.1222,   60.5757065,     9.090909
  38858,  -26.4477463,    59.733017,     9.090909
  38859,  -26.7461166,   58.8803215,     9.090909
  38860,   -27.017004,   58.0185051,     9.090909
  38861,   -27.260128,   57.1484489,     9.090909
  38862,  -27.4752407,   56.2710457,     9.090909
  38863,  -27.6621189,   55.3871994,     9.090909
  38864,  -27.8205776,   54.4978142,     9.090909
  38865,  -27.9504452,   53.6038094,     9.090909
  38866,  -28.0515938,   52.7061043,     9.090909
  38867,  -28.1239147,   51.8056145,     9.090909
  38868,  -28.1673393,   50.9032707,     9.090909
  38869,   27.2587147,   50.8741341,  0.909090936
  38870,    27.216692,   51.7473679,  0.909090936
  38871,   27.1467037,   52.6188087,  0.909090936
  38872,   27.0488186,   53.4875603,  0.909090936
  38873,   26.9231396,    54.352726,  0.909090936
  38874,   26.7697926,   55.2134171,  0.909090936
  38875,   26.5889435,   56.0687523,  0.909090936
  38876,   26.3807697,   56.9178505,  0.909090936
  38877,   26.1454868,   57.7598419,  0.909090936
  38878,   25.8833389,   58.5938606,  0.909090936
  38879,    25.594593,   59.4190483,  0.909090936
  38880,   25.2795486,   60.2345543,  0.909090936
  38881,   24.9385262,    61.039547,  0.909090936
  38882,   24.5718784,   61.8331947,  0.909090936
  38883,   24.1799812,   62.6146812,  0.909090936
  38884,    23.763237,   63.3832054,  0.909090936
  38885,    23.322073,   64.1379776,  0.909090936
  38886,   22.8569469,   64.8782272,  0.909090936
  38887,   22.3683357,   65.6031799,  0.909090936
  38888,   21.8567371,   66.3121033,  0.909090936
  38889,   21.3226757,   67.0042648,  0.909090936
  38890,   20.7667084,   67.6789551,  0.909090936
  38891,   20.1893978,   68.3354797,  0.909090936
  38892,   19.5913467,   68.9731598,  0.909090936
  38893,   18.9731579,   69.5913467,  0.909090936
  38894,   18.3354778,   70.1893997,  0.909090936
  38895,   17.6789589,   70.7667084,  0.909090936
  38896,   17.0042686,   71.3226776,  0.909090936
  38897,   16.3121033,   71.8567352,  0.909090936
  38898,   15.6031809,   72.3683319,  0.909090936
  38899,   14.8782225,   72.8569489,  0.909090936
  38900,   14.1379805,   73.3220749,  0.909090936
  38901,   13.3832054,    73.763237,  0.909090936
  38902,   12.6146812,   74.1799774,  0.909090936
  38903,   11.8331919,   74.5718765,  0.909090936
  38904,   11.0395451,   74.9385223,  0.909090936
  38905,   10.2345543,   75.2795486,  0.909090936
  38906,   9.41904736,   75.5945969,  0.909090936
  38907,   8.59386063,   75.8833389,  0.909090936
  38908,    7.7598443,   76.1454849,  0.909090936
  38909,   6.91785288,   76.3807678,  0.909090936
  38910,   6.06875229,   76.5889435,  0.909090936
  38911,   5.21341705,   76.7697983,  0.909090936
  38912,   4.35272408,   76.9231415,  0.909090936
  38913,   3.48755884,   77.0488205,  0.909090936
  38914,    2.6188097,   77.1467056,  0.909090936
  38915,   1.74736965,   77.2166901,  0.909090936
  38916,  0.874133945,   77.2587128,  0.909090936
  38917,           0.,    77.272728,  0.909090936
  38918, -0.874133945,   77.2587128,  0.909090936
  38919,  -1.74736965,   77.2166901,  0.909090936
  38920,   -2.6188097,   77.1467056,  0.909090936
  38921,  -3.48755884,   77.0488205,  0.909090936
  38922,  -4.35272408,   76.9231415,  0.909090936
  38923,  -5.21341705,   76.7697983,  0.909090936
  38924,  -6.06875229,   76.5889435,  0.909090936
  38925,  -6.91785288,   76.3807678,  0.909090936
  38926,   -7.7598443,   76.1454849,  0.909090936
  38927,  -8.59386063,   75.8833389,  0.909090936
  38928,  -9.41904736,   75.5945969,  0.909090936
  38929,  -10.2345543,   75.2795486,  0.909090936
  38930,  -11.0395451,   74.9385223,  0.909090936
  38931,  -11.8331919,   74.5718765,  0.909090936
  38932,  -12.6146812,   74.1799774,  0.909090936
  38933,  -13.3832054,    73.763237,  0.909090936
  38934,  -14.1379805,   73.3220749,  0.909090936
  38935,  -14.8782225,   72.8569489,  0.909090936
  38936,  -15.6031809,   72.3683319,  0.909090936
  38937,  -16.3121033,   71.8567352,  0.909090936
  38938,  -17.0042686,   71.3226776,  0.909090936
  38939,  -17.6789589,   70.7667084,  0.909090936
  38940,  -18.3354778,   70.1893997,  0.909090936
  38941,  -18.9731579,   69.5913467,  0.909090936
  38942,  -19.5913467,   68.9731598,  0.909090936
  38943,  -20.1893978,   68.3354797,  0.909090936
  38944,  -20.7667084,   67.6789551,  0.909090936
  38945,  -21.3226757,   67.0042648,  0.909090936
  38946,  -21.8567371,   66.3121033,  0.909090936
  38947,  -22.3683357,   65.6031799,  0.909090936
  38948,  -22.8569469,   64.8782272,  0.909090936
  38949,   -23.322073,   64.1379776,  0.909090936
  38950,   -23.763237,   63.3832054,  0.909090936
  38951,  -24.1799812,   62.6146812,  0.909090936
  38952,  -24.5718784,   61.8331947,  0.909090936
  38953,  -24.9385262,    61.039547,  0.909090936
  38954,  -25.2795486,   60.2345543,  0.909090936
  38955,   -25.594593,   59.4190483,  0.909090936
  38956,  -25.8833389,   58.5938606,  0.909090936
  38957,  -26.1454868,   57.7598419,  0.909090936
  38958,  -26.3807697,   56.9178505,  0.909090936
  38959,  -26.5889435,   56.0687523,  0.909090936
  38960,  -26.7697926,   55.2134171,  0.909090936
  38961,  -26.9231396,    54.352726,  0.909090936
  38962,  -27.0488186,   53.4875603,  0.909090936
  38963,  -27.1467037,   52.6188087,  0.909090936
  38964,   -27.216692,   51.7473679,  0.909090936
  38965,  -27.2587147,   50.8741341,  0.909090936
  38966,   27.2587147,   50.8741341,   1.81818187
  38967,    27.216692,   51.7473679,   1.81818187
  38968,   27.1467037,   52.6188087,   1.81818187
  38969,   27.0488186,   53.4875603,   1.81818187
  38970,   26.9231396,    54.352726,   1.81818187
  38971,   26.7697926,   55.2134171,   1.81818187
  38972,   26.5889435,   56.0687523,   1.81818187
  38973,   26.3807697,   56.9178505,   1.81818187
  38974,   26.1454868,   57.7598419,   1.81818187
  38975,   25.8833389,   58.5938606,   1.81818187
  38976,    25.594593,   59.4190483,   1.81818187
  38977,   25.2795486,   60.2345543,   1.81818187
  38978,   24.9385262,    61.039547,   1.81818187
  38979,   24.5718784,   61.8331947,   1.81818187
  38980,   24.1799812,   62.6146812,   1.81818187
  38981,    23.763237,   63.3832054,   1.81818187
  38982,    23.322073,   64.1379776,   1.81818187
  38983,   22.8569469,   64.8782272,   1.81818187
  38984,   22.3683357,   65.6031799,   1.81818187
  38985,   21.8567371,   66.3121033,   1.81818187
  38986,   21.3226757,   67.0042648,   1.81818187
  38987,   20.7667084,   67.6789551,   1.81818187
  38988,   20.1893978,   68.3354797,   1.81818187
  38989,   19.5913467,   68.9731598,   1.81818187
  38990,   18.9731579,   69.5913467,   1.81818187
  38991,   18.3354778,   70.1893997,   1.81818187
  38992,   17.6789589,   70.7667084,   1.81818187
  38993,   17.0042686,   71.3226776,   1.81818187
  38994,   16.3121033,   71.8567352,   1.81818187
  38995,   15.6031809,   72.3683319,   1.81818187
  38996,   14.8782225,   72.8569489,   1.81818187
  38997,   14.1379805,   73.3220749,   1.81818187
  38998,   13.3832054,    73.763237,   1.81818187
  38999,   12.6146812,   74.1799774,   1.81818187
  39000,   11.8331919,   74.5718765,   1.81818187
  39001,   11.0395451,   74.9385223,   1.81818187
  39002,   10.2345543,   75.2795486,   1.81818187
  39003,   9.41904736,   75.5945969,   1.81818187
  39004,   8.59386063,   75.8833389,   1.81818187
  39005,    7.7598443,   76.1454849,   1.81818187
  39006,   6.91785288,   76.3807678,   1.81818187
  39007,   6.06875229,   76.5889435,   1.81818187
  39008,   5.21341705,   76.7697983,   1.81818187
  39009,   4.35272408,   76.9231415,   1.81818187
  39010,   3.48755884,   77.0488205,   1.81818187
  39011,    2.6188097,   77.1467056,   1.81818187
  39012,   1.74736965,   77.2166901,   1.81818187
  39013,  0.874133945,   77.2587128,   1.81818187
  39014,           0.,    77.272728,   1.81818187
  39015, -0.874133945,   77.2587128,   1.81818187
  39016,  -1.74736965,   77.2166901,   1.81818187
  39017,   -2.6188097,   77.1467056,   1.81818187
  39018,  -3.48755884,   77.0488205,   1.81818187
  39019,  -4.35272408,   76.9231415,   1.81818187
  39020,  -5.21341705,   76.7697983,   1.81818187
  39021,  -6.06875229,   76.5889435,   1.81818187
  39022,  -6.91785288,   76.3807678,   1.81818187
  39023,   -7.7598443,   76.1454849,   1.81818187
  39024,  -8.59386063,   75.8833389,   1.81818187
  39025,  -9.41904736,   75.5945969,   1.81818187
  39026,  -10.2345543,   75.2795486,   1.81818187
  39027,  -11.0395451,   74.9385223,   1.81818187
  39028,  -11.8331919,   74.5718765,   1.81818187
  39029,  -12.6146812,   74.1799774,   1.81818187
  39030,  -13.3832054,    73.763237,   1.81818187
  39031,  -14.1379805,   73.3220749,   1.81818187
  39032,  -14.8782225,   72.8569489,   1.81818187
  39033,  -15.6031809,   72.3683319,   1.81818187
  39034,  -16.3121033,   71.8567352,   1.81818187
  39035,  -17.0042686,   71.3226776,   1.81818187
  39036,  -17.6789589,   70.7667084,   1.81818187
  39037,  -18.3354778,   70.1893997,   1.81818187
  39038,  -18.9731579,   69.5913467,   1.81818187
  39039,  -19.5913467,   68.9731598,   1.81818187
  39040,  -20.1893978,   68.3354797,   1.81818187
  39041,  -20.7667084,   67.6789551,   1.81818187
  39042,  -21.3226757,   67.0042648,   1.81818187
  39043,  -21.8567371,   66.3121033,   1.81818187
  39044,  -22.3683357,   65.6031799,   1.81818187
  39045,  -22.8569469,   64.8782272,   1.81818187
  39046,   -23.322073,   64.1379776,   1.81818187
  39047,   -23.763237,   63.3832054,   1.81818187
  39048,  -24.1799812,   62.6146812,   1.81818187
  39049,  -24.5718784,   61.8331947,   1.81818187
  39050,  -24.9385262,    61.039547,   1.81818187
  39051,  -25.2795486,   60.2345543,   1.81818187
  39052,   -25.594593,   59.4190483,   1.81818187
  39053,  -25.8833389,   58.5938606,   1.81818187
  39054,  -26.1454868,   57.7598419,   1.81818187
  39055,  -26.3807697,   56.9178505,   1.81818187
  39056,  -26.5889435,   56.0687523,   1.81818187
  39057,  -26.7697926,   55.2134171,   1.81818187
  39058,  -26.9231396,    54.352726,   1.81818187
  39059,  -27.0488186,   53.4875603,   1.81818187
  39060,  -27.1467037,   52.6188087,   1.81818187
  39061,   -27.216692,   51.7473679,   1.81818187
  39062,  -27.2587147,   50.8741341,   1.81818187
  39063,   27.2587147,   50.8741341,   2.72727275
  39064,    27.216692,   51.7473679,   2.72727275
  39065,   27.1467037,   52.6188087,   2.72727275
  39066,   27.0488186,   53.4875603,   2.72727275
  39067,   26.9231396,    54.352726,   2.72727275
  39068,   26.7697926,   55.2134171,   2.72727275
  39069,   26.5889435,   56.0687523,   2.72727275
  39070,   26.3807697,   56.9178505,   2.72727275
  39071,   26.1454868,   57.7598419,   2.72727275
  39072,   25.8833389,   58.5938606,   2.72727275
  39073,    25.594593,   59.4190483,   2.72727275
  39074,   25.2795486,   60.2345543,   2.72727275
  39075,   24.9385262,    61.039547,   2.72727275
  39076,   24.5718784,   61.8331947,   2.72727275
  39077,   24.1799812,   62.6146812,   2.72727275
  39078,    23.763237,   63.3832054,   2.72727275
  39079,    23.322073,   64.1379776,   2.72727275
  39080,   22.8569469,   64.8782272,   2.72727275
  39081,   22.3683357,   65.6031799,   2.72727275
  39082,   21.8567371,   66.3121033,   2.72727275
  39083,   21.3226757,   67.0042648,   2.72727275
  39084,   20.7667084,   67.6789551,   2.72727275
  39085,   20.1893978,   68.3354797,   2.72727275
  39086,   19.5913467,   68.9731598,   2.72727275
  39087,   18.9731579,   69.5913467,   2.72727275
  39088,   18.3354778,   70.1893997,   2.72727275
  39089,   17.6789589,   70.7667084,   2.72727275
  39090,   17.0042686,   71.3226776,   2.72727275
  39091,   16.3121033,   71.8567352,   2.72727275
  39092,   15.6031809,   72.3683319,   2.72727275
  39093,   14.8782225,   72.8569489,   2.72727275
  39094,   14.1379805,   73.3220749,   2.72727275
  39095,   13.3832054,    73.763237,   2.72727275
  39096,   12.6146812,   74.1799774,   2.72727275
  39097,   11.8331919,   74.5718765,   2.72727275
  39098,   11.0395451,   74.9385223,   2.72727275
  39099,   10.2345543,   75.2795486,   2.72727275
  39100,   9.41904736,   75.5945969,   2.72727275
  39101,   8.59386063,   75.8833389,   2.72727275
  39102,    7.7598443,   76.1454849,   2.72727275
  39103,   6.91785288,   76.3807678,   2.72727275
  39104,   6.06875229,   76.5889435,   2.72727275
  39105,   5.21341705,   76.7697983,   2.72727275
  39106,   4.35272408,   76.9231415,   2.72727275
  39107,   3.48755884,   77.0488205,   2.72727275
  39108,    2.6188097,   77.1467056,   2.72727275
  39109,   1.74736965,   77.2166901,   2.72727275
  39110,  0.874133945,   77.2587128,   2.72727275
  39111,           0.,    77.272728,   2.72727275
  39112, -0.874133945,   77.2587128,   2.72727275
  39113,  -1.74736965,   77.2166901,   2.72727275
  39114,   -2.6188097,   77.1467056,   2.72727275
  39115,  -3.48755884,   77.0488205,   2.72727275
  39116,  -4.35272408,   76.9231415,   2.72727275
  39117,  -5.21341705,   76.7697983,   2.72727275
  39118,  -6.06875229,   76.5889435,   2.72727275
  39119,  -6.91785288,   76.3807678,   2.72727275
  39120,   -7.7598443,   76.1454849,   2.72727275
  39121,  -8.59386063,   75.8833389,   2.72727275
  39122,  -9.41904736,   75.5945969,   2.72727275
  39123,  -10.2345543,   75.2795486,   2.72727275
  39124,  -11.0395451,   74.9385223,   2.72727275
  39125,  -11.8331919,   74.5718765,   2.72727275
  39126,  -12.6146812,   74.1799774,   2.72727275
  39127,  -13.3832054,    73.763237,   2.72727275
  39128,  -14.1379805,   73.3220749,   2.72727275
  39129,  -14.8782225,   72.8569489,   2.72727275
  39130,  -15.6031809,   72.3683319,   2.72727275
  39131,  -16.3121033,   71.8567352,   2.72727275
  39132,  -17.0042686,   71.3226776,   2.72727275
  39133,  -17.6789589,   70.7667084,   2.72727275
  39134,  -18.3354778,   70.1893997,   2.72727275
  39135,  -18.9731579,   69.5913467,   2.72727275
  39136,  -19.5913467,   68.9731598,   2.72727275
  39137,  -20.1893978,   68.3354797,   2.72727275
  39138,  -20.7667084,   67.6789551,   2.72727275
  39139,  -21.3226757,   67.0042648,   2.72727275
  39140,  -21.8567371,   66.3121033,   2.72727275
  39141,  -22.3683357,   65.6031799,   2.72727275
  39142,  -22.8569469,   64.8782272,   2.72727275
  39143,   -23.322073,   64.1379776,   2.72727275
  39144,   -23.763237,   63.3832054,   2.72727275
  39145,  -24.1799812,   62.6146812,   2.72727275
  39146,  -24.5718784,   61.8331947,   2.72727275
  39147,  -24.9385262,    61.039547,   2.72727275
  39148,  -25.2795486,   60.2345543,   2.72727275
  39149,   -25.594593,   59.4190483,   2.72727275
  39150,  -25.8833389,   58.5938606,   2.72727275
  39151,  -26.1454868,   57.7598419,   2.72727275
  39152,  -26.3807697,   56.9178505,   2.72727275
  39153,  -26.5889435,   56.0687523,   2.72727275
  39154,  -26.7697926,   55.2134171,   2.72727275
  39155,  -26.9231396,    54.352726,   2.72727275
  39156,  -27.0488186,   53.4875603,   2.72727275
  39157,  -27.1467037,   52.6188087,   2.72727275
  39158,   -27.216692,   51.7473679,   2.72727275
  39159,  -27.2587147,   50.8741341,   2.72727275
  39160,   27.2587147,   50.8741341,   3.63636374
  39161,    27.216692,   51.7473679,   3.63636374
  39162,   27.1467037,   52.6188087,   3.63636374
  39163,   27.0488186,   53.4875603,   3.63636374
  39164,   26.9231396,    54.352726,   3.63636374
  39165,   26.7697926,   55.2134171,   3.63636374
  39166,   26.5889435,   56.0687523,   3.63636374
  39167,   26.3807697,   56.9178505,   3.63636374
  39168,   26.1454868,   57.7598419,   3.63636374
  39169,   25.8833389,   58.5938606,   3.63636374
  39170,    25.594593,   59.4190483,   3.63636374
  39171,   25.2795486,   60.2345543,   3.63636374
  39172,   24.9385262,    61.039547,   3.63636374
  39173,   24.5718784,   61.8331947,   3.63636374
  39174,   24.1799812,   62.6146812,   3.63636374
  39175,    23.763237,   63.3832054,   3.63636374
  39176,    23.322073,   64.1379776,   3.63636374
  39177,   22.8569469,   64.8782272,   3.63636374
  39178,   22.3683357,   65.6031799,   3.63636374
  39179,   21.8567371,   66.3121033,   3.63636374
  39180,   21.3226757,   67.0042648,   3.63636374
  39181,   20.7667084,   67.6789551,   3.63636374
  39182,   20.1893978,   68.3354797,   3.63636374
  39183,   19.5913467,   68.9731598,   3.63636374
  39184,   18.9731579,   69.5913467,   3.63636374
  39185,   18.3354778,   70.1893997,   3.63636374
  39186,   17.6789589,   70.7667084,   3.63636374
  39187,   17.0042686,   71.3226776,   3.63636374
  39188,   16.3121033,   71.8567352,   3.63636374
  39189,   15.6031809,   72.3683319,   3.63636374
  39190,   14.8782225,   72.8569489,   3.63636374
  39191,   14.1379805,   73.3220749,   3.63636374
  39192,   13.3832054,    73.763237,   3.63636374
  39193,   12.6146812,   74.1799774,   3.63636374
  39194,   11.8331919,   74.5718765,   3.63636374
  39195,   11.0395451,   74.9385223,   3.63636374
  39196,   10.2345543,   75.2795486,   3.63636374
  39197,   9.41904736,   75.5945969,   3.63636374
  39198,   8.59386063,   75.8833389,   3.63636374
  39199,    7.7598443,   76.1454849,   3.63636374
  39200,   6.91785288,   76.3807678,   3.63636374
  39201,   6.06875229,   76.5889435,   3.63636374
  39202,   5.21341705,   76.7697983,   3.63636374
  39203,   4.35272408,   76.9231415,   3.63636374
  39204,   3.48755884,   77.0488205,   3.63636374
  39205,    2.6188097,   77.1467056,   3.63636374
  39206,   1.74736965,   77.2166901,   3.63636374
  39207,  0.874133945,   77.2587128,   3.63636374
  39208,           0.,    77.272728,   3.63636374
  39209, -0.874133945,   77.2587128,   3.63636374
  39210,  -1.74736965,   77.2166901,   3.63636374
  39211,   -2.6188097,   77.1467056,   3.63636374
  39212,  -3.48755884,   77.0488205,   3.63636374
  39213,  -4.35272408,   76.9231415,   3.63636374
  39214,  -5.21341705,   76.7697983,   3.63636374
  39215,  -6.06875229,   76.5889435,   3.63636374
  39216,  -6.91785288,   76.3807678,   3.63636374
  39217,   -7.7598443,   76.1454849,   3.63636374
  39218,  -8.59386063,   75.8833389,   3.63636374
  39219,  -9.41904736,   75.5945969,   3.63636374
  39220,  -10.2345543,   75.2795486,   3.63636374
  39221,  -11.0395451,   74.9385223,   3.63636374
  39222,  -11.8331919,   74.5718765,   3.63636374
  39223,  -12.6146812,   74.1799774,   3.63636374
  39224,  -13.3832054,    73.763237,   3.63636374
  39225,  -14.1379805,   73.3220749,   3.63636374
  39226,  -14.8782225,   72.8569489,   3.63636374
  39227,  -15.6031809,   72.3683319,   3.63636374
  39228,  -16.3121033,   71.8567352,   3.63636374
  39229,  -17.0042686,   71.3226776,   3.63636374
  39230,  -17.6789589,   70.7667084,   3.63636374
  39231,  -18.3354778,   70.1893997,   3.63636374
  39232,  -18.9731579,   69.5913467,   3.63636374
  39233,  -19.5913467,   68.9731598,   3.63636374
  39234,  -20.1893978,   68.3354797,   3.63636374
  39235,  -20.7667084,   67.6789551,   3.63636374
  39236,  -21.3226757,   67.0042648,   3.63636374
  39237,  -21.8567371,   66.3121033,   3.63636374
  39238,  -22.3683357,   65.6031799,   3.63636374
  39239,  -22.8569469,   64.8782272,   3.63636374
  39240,   -23.322073,   64.1379776,   3.63636374
  39241,   -23.763237,   63.3832054,   3.63636374
  39242,  -24.1799812,   62.6146812,   3.63636374
  39243,  -24.5718784,   61.8331947,   3.63636374
  39244,  -24.9385262,    61.039547,   3.63636374
  39245,  -25.2795486,   60.2345543,   3.63636374
  39246,   -25.594593,   59.4190483,   3.63636374
  39247,  -25.8833389,   58.5938606,   3.63636374
  39248,  -26.1454868,   57.7598419,   3.63636374
  39249,  -26.3807697,   56.9178505,   3.63636374
  39250,  -26.5889435,   56.0687523,   3.63636374
  39251,  -26.7697926,   55.2134171,   3.63636374
  39252,  -26.9231396,    54.352726,   3.63636374
  39253,  -27.0488186,   53.4875603,   3.63636374
  39254,  -27.1467037,   52.6188087,   3.63636374
  39255,   -27.216692,   51.7473679,   3.63636374
  39256,  -27.2587147,   50.8741341,   3.63636374
  39257,   27.2587147,   50.8741341,    4.5454545
  39258,    27.216692,   51.7473679,    4.5454545
  39259,   27.1467037,   52.6188087,    4.5454545
  39260,   27.0488186,   53.4875603,    4.5454545
  39261,   26.9231396,    54.352726,    4.5454545
  39262,   26.7697926,   55.2134171,    4.5454545
  39263,   26.5889435,   56.0687523,    4.5454545
  39264,   26.3807697,   56.9178505,    4.5454545
  39265,   26.1454868,   57.7598419,    4.5454545
  39266,   25.8833389,   58.5938606,    4.5454545
  39267,    25.594593,   59.4190483,    4.5454545
  39268,   25.2795486,   60.2345543,    4.5454545
  39269,   24.9385262,    61.039547,    4.5454545
  39270,   24.5718784,   61.8331947,    4.5454545
  39271,   24.1799812,   62.6146812,    4.5454545
  39272,    23.763237,   63.3832054,    4.5454545
  39273,    23.322073,   64.1379776,    4.5454545
  39274,   22.8569469,   64.8782272,    4.5454545
  39275,   22.3683357,   65.6031799,    4.5454545
  39276,   21.8567371,   66.3121033,    4.5454545
  39277,   21.3226757,   67.0042648,    4.5454545
  39278,   20.7667084,   67.6789551,    4.5454545
  39279,   20.1893978,   68.3354797,    4.5454545
  39280,   19.5913467,   68.9731598,    4.5454545
  39281,   18.9731579,   69.5913467,    4.5454545
  39282,   18.3354778,   70.1893997,    4.5454545
  39283,   17.6789589,   70.7667084,    4.5454545
  39284,   17.0042686,   71.3226776,    4.5454545
  39285,   16.3121033,   71.8567352,    4.5454545
  39286,   15.6031809,   72.3683319,    4.5454545
  39287,   14.8782225,   72.8569489,    4.5454545
  39288,   14.1379805,   73.3220749,    4.5454545
  39289,   13.3832054,    73.763237,    4.5454545
  39290,   12.6146812,   74.1799774,    4.5454545
  39291,   11.8331919,   74.5718765,    4.5454545
  39292,   11.0395451,   74.9385223,    4.5454545
  39293,   10.2345543,   75.2795486,    4.5454545
  39294,   9.41904736,   75.5945969,    4.5454545
  39295,   8.59386063,   75.8833389,    4.5454545
  39296,    7.7598443,   76.1454849,    4.5454545
  39297,   6.91785288,   76.3807678,    4.5454545
  39298,   6.06875229,   76.5889435,    4.5454545
  39299,   5.21341705,   76.7697983,    4.5454545
  39300,   4.35272408,   76.9231415,    4.5454545
  39301,   3.48755884,   77.0488205,    4.5454545
  39302,    2.6188097,   77.1467056,    4.5454545
  39303,   1.74736965,   77.2166901,    4.5454545
  39304,  0.874133945,   77.2587128,    4.5454545
  39305,           0.,    77.272728,    4.5454545
  39306, -0.874133945,   77.2587128,    4.5454545
  39307,  -1.74736965,   77.2166901,    4.5454545
  39308,   -2.6188097,   77.1467056,    4.5454545
  39309,  -3.48755884,   77.0488205,    4.5454545
  39310,  -4.35272408,   76.9231415,    4.5454545
  39311,  -5.21341705,   76.7697983,    4.5454545
  39312,  -6.06875229,   76.5889435,    4.5454545
  39313,  -6.91785288,   76.3807678,    4.5454545
  39314,   -7.7598443,   76.1454849,    4.5454545
  39315,  -8.59386063,   75.8833389,    4.5454545
  39316,  -9.41904736,   75.5945969,    4.5454545
  39317,  -10.2345543,   75.2795486,    4.5454545
  39318,  -11.0395451,   74.9385223,    4.5454545
  39319,  -11.8331919,   74.5718765,    4.5454545
  39320,  -12.6146812,   74.1799774,    4.5454545
  39321,  -13.3832054,    73.763237,    4.5454545
  39322,  -14.1379805,   73.3220749,    4.5454545
  39323,  -14.8782225,   72.8569489,    4.5454545
  39324,  -15.6031809,   72.3683319,    4.5454545
  39325,  -16.3121033,   71.8567352,    4.5454545
  39326,  -17.0042686,   71.3226776,    4.5454545
  39327,  -17.6789589,   70.7667084,    4.5454545
  39328,  -18.3354778,   70.1893997,    4.5454545
  39329,  -18.9731579,   69.5913467,    4.5454545
  39330,  -19.5913467,   68.9731598,    4.5454545
  39331,  -20.1893978,   68.3354797,    4.5454545
  39332,  -20.7667084,   67.6789551,    4.5454545
  39333,  -21.3226757,   67.0042648,    4.5454545
  39334,  -21.8567371,   66.3121033,    4.5454545
  39335,  -22.3683357,   65.6031799,    4.5454545
  39336,  -22.8569469,   64.8782272,    4.5454545
  39337,   -23.322073,   64.1379776,    4.5454545
  39338,   -23.763237,   63.3832054,    4.5454545
  39339,  -24.1799812,   62.6146812,    4.5454545
  39340,  -24.5718784,   61.8331947,    4.5454545
  39341,  -24.9385262,    61.039547,    4.5454545
  39342,  -25.2795486,   60.2345543,    4.5454545
  39343,   -25.594593,   59.4190483,    4.5454545
  39344,  -25.8833389,   58.5938606,    4.5454545
  39345,  -26.1454868,   57.7598419,    4.5454545
  39346,  -26.3807697,   56.9178505,    4.5454545
  39347,  -26.5889435,   56.0687523,    4.5454545
  39348,  -26.7697926,   55.2134171,    4.5454545
  39349,  -26.9231396,    54.352726,    4.5454545
  39350,  -27.0488186,   53.4875603,    4.5454545
  39351,  -27.1467037,   52.6188087,    4.5454545
  39352,   -27.216692,   51.7473679,    4.5454545
  39353,  -27.2587147,   50.8741341,    4.5454545
  39354,   27.2587147,   50.8741341,    5.4545455
  39355,    27.216692,   51.7473679,    5.4545455
  39356,   27.1467037,   52.6188087,    5.4545455
  39357,   27.0488186,   53.4875603,    5.4545455
  39358,   26.9231396,    54.352726,    5.4545455
  39359,   26.7697926,   55.2134171,    5.4545455
  39360,   26.5889435,   56.0687523,    5.4545455
  39361,   26.3807697,   56.9178505,    5.4545455
  39362,   26.1454868,   57.7598419,    5.4545455
  39363,   25.8833389,   58.5938606,    5.4545455
  39364,    25.594593,   59.4190483,    5.4545455
  39365,   25.2795486,   60.2345543,    5.4545455
  39366,   24.9385262,    61.039547,    5.4545455
  39367,   24.5718784,   61.8331947,    5.4545455
  39368,   24.1799812,   62.6146812,    5.4545455
  39369,    23.763237,   63.3832054,    5.4545455
  39370,    23.322073,   64.1379776,    5.4545455
  39371,   22.8569469,   64.8782272,    5.4545455
  39372,   22.3683357,   65.6031799,    5.4545455
  39373,   21.8567371,   66.3121033,    5.4545455
  39374,   21.3226757,   67.0042648,    5.4545455
  39375,   20.7667084,   67.6789551,    5.4545455
  39376,   20.1893978,   68.3354797,    5.4545455
  39377,   19.5913467,   68.9731598,    5.4545455
  39378,   18.9731579,   69.5913467,    5.4545455
  39379,   18.3354778,   70.1893997,    5.4545455
  39380,   17.6789589,   70.7667084,    5.4545455
  39381,   17.0042686,   71.3226776,    5.4545455
  39382,   16.3121033,   71.8567352,    5.4545455
  39383,   15.6031809,   72.3683319,    5.4545455
  39384,   14.8782225,   72.8569489,    5.4545455
  39385,   14.1379805,   73.3220749,    5.4545455
  39386,   13.3832054,    73.763237,    5.4545455
  39387,   12.6146812,   74.1799774,    5.4545455
  39388,   11.8331919,   74.5718765,    5.4545455
  39389,   11.0395451,   74.9385223,    5.4545455
  39390,   10.2345543,   75.2795486,    5.4545455
  39391,   9.41904736,   75.5945969,    5.4545455
  39392,   8.59386063,   75.8833389,    5.4545455
  39393,    7.7598443,   76.1454849,    5.4545455
  39394,   6.91785288,   76.3807678,    5.4545455
  39395,   6.06875229,   76.5889435,    5.4545455
  39396,   5.21341705,   76.7697983,    5.4545455
  39397,   4.35272408,   76.9231415,    5.4545455
  39398,   3.48755884,   77.0488205,    5.4545455
  39399,    2.6188097,   77.1467056,    5.4545455
  39400,   1.74736965,   77.2166901,    5.4545455
  39401,  0.874133945,   77.2587128,    5.4545455
  39402,           0.,    77.272728,    5.4545455
  39403, -0.874133945,   77.2587128,    5.4545455
  39404,  -1.74736965,   77.2166901,    5.4545455
  39405,   -2.6188097,   77.1467056,    5.4545455
  39406,  -3.48755884,   77.0488205,    5.4545455
  39407,  -4.35272408,   76.9231415,    5.4545455
  39408,  -5.21341705,   76.7697983,    5.4545455
  39409,  -6.06875229,   76.5889435,    5.4545455
  39410,  -6.91785288,   76.3807678,    5.4545455
  39411,   -7.7598443,   76.1454849,    5.4545455
  39412,  -8.59386063,   75.8833389,    5.4545455
  39413,  -9.41904736,   75.5945969,    5.4545455
  39414,  -10.2345543,   75.2795486,    5.4545455
  39415,  -11.0395451,   74.9385223,    5.4545455
  39416,  -11.8331919,   74.5718765,    5.4545455
  39417,  -12.6146812,   74.1799774,    5.4545455
  39418,  -13.3832054,    73.763237,    5.4545455
  39419,  -14.1379805,   73.3220749,    5.4545455
  39420,  -14.8782225,   72.8569489,    5.4545455
  39421,  -15.6031809,   72.3683319,    5.4545455
  39422,  -16.3121033,   71.8567352,    5.4545455
  39423,  -17.0042686,   71.3226776,    5.4545455
  39424,  -17.6789589,   70.7667084,    5.4545455
  39425,  -18.3354778,   70.1893997,    5.4545455
  39426,  -18.9731579,   69.5913467,    5.4545455
  39427,  -19.5913467,   68.9731598,    5.4545455
  39428,  -20.1893978,   68.3354797,    5.4545455
  39429,  -20.7667084,   67.6789551,    5.4545455
  39430,  -21.3226757,   67.0042648,    5.4545455
  39431,  -21.8567371,   66.3121033,    5.4545455
  39432,  -22.3683357,   65.6031799,    5.4545455
  39433,  -22.8569469,   64.8782272,    5.4545455
  39434,   -23.322073,   64.1379776,    5.4545455
  39435,   -23.763237,   63.3832054,    5.4545455
  39436,  -24.1799812,   62.6146812,    5.4545455
  39437,  -24.5718784,   61.8331947,    5.4545455
  39438,  -24.9385262,    61.039547,    5.4545455
  39439,  -25.2795486,   60.2345543,    5.4545455
  39440,   -25.594593,   59.4190483,    5.4545455
  39441,  -25.8833389,   58.5938606,    5.4545455
  39442,  -26.1454868,   57.7598419,    5.4545455
  39443,  -26.3807697,   56.9178505,    5.4545455
  39444,  -26.5889435,   56.0687523,    5.4545455
  39445,  -26.7697926,   55.2134171,    5.4545455
  39446,  -26.9231396,    54.352726,    5.4545455
  39447,  -27.0488186,   53.4875603,    5.4545455
  39448,  -27.1467037,   52.6188087,    5.4545455
  39449,   -27.216692,   51.7473679,    5.4545455
  39450,  -27.2587147,   50.8741341,    5.4545455
  39451,   27.2587147,   50.8741341,   6.36363649
  39452,    27.216692,   51.7473679,   6.36363649
  39453,   27.1467037,   52.6188087,   6.36363649
  39454,   27.0488186,   53.4875603,   6.36363649
  39455,   26.9231396,    54.352726,   6.36363649
  39456,   26.7697926,   55.2134171,   6.36363649
  39457,   26.5889435,   56.0687523,   6.36363649
  39458,   26.3807697,   56.9178505,   6.36363649
  39459,   26.1454868,   57.7598419,   6.36363649
  39460,   25.8833389,   58.5938606,   6.36363649
  39461,    25.594593,   59.4190483,   6.36363649
  39462,   25.2795486,   60.2345543,   6.36363649
  39463,   24.9385262,    61.039547,   6.36363649
  39464,   24.5718784,   61.8331947,   6.36363649
  39465,   24.1799812,   62.6146812,   6.36363649
  39466,    23.763237,   63.3832054,   6.36363649
  39467,    23.322073,   64.1379776,   6.36363649
  39468,   22.8569469,   64.8782272,   6.36363649
  39469,   22.3683357,   65.6031799,   6.36363649
  39470,   21.8567371,   66.3121033,   6.36363649
  39471,   21.3226757,   67.0042648,   6.36363649
  39472,   20.7667084,   67.6789551,   6.36363649
  39473,   20.1893978,   68.3354797,   6.36363649
  39474,   19.5913467,   68.9731598,   6.36363649
  39475,   18.9731579,   69.5913467,   6.36363649
  39476,   18.3354778,   70.1893997,   6.36363649
  39477,   17.6789589,   70.7667084,   6.36363649
  39478,   17.0042686,   71.3226776,   6.36363649
  39479,   16.3121033,   71.8567352,   6.36363649
  39480,   15.6031809,   72.3683319,   6.36363649
  39481,   14.8782225,   72.8569489,   6.36363649
  39482,   14.1379805,   73.3220749,   6.36363649
  39483,   13.3832054,    73.763237,   6.36363649
  39484,   12.6146812,   74.1799774,   6.36363649
  39485,   11.8331919,   74.5718765,   6.36363649
  39486,   11.0395451,   74.9385223,   6.36363649
  39487,   10.2345543,   75.2795486,   6.36363649
  39488,   9.41904736,   75.5945969,   6.36363649
  39489,   8.59386063,   75.8833389,   6.36363649
  39490,    7.7598443,   76.1454849,   6.36363649
  39491,   6.91785288,   76.3807678,   6.36363649
  39492,   6.06875229,   76.5889435,   6.36363649
  39493,   5.21341705,   76.7697983,   6.36363649
  39494,   4.35272408,   76.9231415,   6.36363649
  39495,   3.48755884,   77.0488205,   6.36363649
  39496,    2.6188097,   77.1467056,   6.36363649
  39497,   1.74736965,   77.2166901,   6.36363649
  39498,  0.874133945,   77.2587128,   6.36363649
  39499,           0.,    77.272728,   6.36363649
  39500, -0.874133945,   77.2587128,   6.36363649
  39501,  -1.74736965,   77.2166901,   6.36363649
  39502,   -2.6188097,   77.1467056,   6.36363649
  39503,  -3.48755884,   77.0488205,   6.36363649
  39504,  -4.35272408,   76.9231415,   6.36363649
  39505,  -5.21341705,   76.7697983,   6.36363649
  39506,  -6.06875229,   76.5889435,   6.36363649
  39507,  -6.91785288,   76.3807678,   6.36363649
  39508,   -7.7598443,   76.1454849,   6.36363649
  39509,  -8.59386063,   75.8833389,   6.36363649
  39510,  -9.41904736,   75.5945969,   6.36363649
  39511,  -10.2345543,   75.2795486,   6.36363649
  39512,  -11.0395451,   74.9385223,   6.36363649
  39513,  -11.8331919,   74.5718765,   6.36363649
  39514,  -12.6146812,   74.1799774,   6.36363649
  39515,  -13.3832054,    73.763237,   6.36363649
  39516,  -14.1379805,   73.3220749,   6.36363649
  39517,  -14.8782225,   72.8569489,   6.36363649
  39518,  -15.6031809,   72.3683319,   6.36363649
  39519,  -16.3121033,   71.8567352,   6.36363649
  39520,  -17.0042686,   71.3226776,   6.36363649
  39521,  -17.6789589,   70.7667084,   6.36363649
  39522,  -18.3354778,   70.1893997,   6.36363649
  39523,  -18.9731579,   69.5913467,   6.36363649
  39524,  -19.5913467,   68.9731598,   6.36363649
  39525,  -20.1893978,   68.3354797,   6.36363649
  39526,  -20.7667084,   67.6789551,   6.36363649
  39527,  -21.3226757,   67.0042648,   6.36363649
  39528,  -21.8567371,   66.3121033,   6.36363649
  39529,  -22.3683357,   65.6031799,   6.36363649
  39530,  -22.8569469,   64.8782272,   6.36363649
  39531,   -23.322073,   64.1379776,   6.36363649
  39532,   -23.763237,   63.3832054,   6.36363649
  39533,  -24.1799812,   62.6146812,   6.36363649
  39534,  -24.5718784,   61.8331947,   6.36363649
  39535,  -24.9385262,    61.039547,   6.36363649
  39536,  -25.2795486,   60.2345543,   6.36363649
  39537,   -25.594593,   59.4190483,   6.36363649
  39538,  -25.8833389,   58.5938606,   6.36363649
  39539,  -26.1454868,   57.7598419,   6.36363649
  39540,  -26.3807697,   56.9178505,   6.36363649
  39541,  -26.5889435,   56.0687523,   6.36363649
  39542,  -26.7697926,   55.2134171,   6.36363649
  39543,  -26.9231396,    54.352726,   6.36363649
  39544,  -27.0488186,   53.4875603,   6.36363649
  39545,  -27.1467037,   52.6188087,   6.36363649
  39546,   -27.216692,   51.7473679,   6.36363649
  39547,  -27.2587147,   50.8741341,   6.36363649
  39548,   27.2587147,   50.8741341,   7.27272749
  39549,    27.216692,   51.7473679,   7.27272749
  39550,   27.1467037,   52.6188087,   7.27272749
  39551,   27.0488186,   53.4875603,   7.27272749
  39552,   26.9231396,    54.352726,   7.27272749
  39553,   26.7697926,   55.2134171,   7.27272749
  39554,   26.5889435,   56.0687523,   7.27272749
  39555,   26.3807697,   56.9178505,   7.27272749
  39556,   26.1454868,   57.7598419,   7.27272749
  39557,   25.8833389,   58.5938606,   7.27272749
  39558,    25.594593,   59.4190483,   7.27272749
  39559,   25.2795486,   60.2345543,   7.27272749
  39560,   24.9385262,    61.039547,   7.27272749
  39561,   24.5718784,   61.8331947,   7.27272749
  39562,   24.1799812,   62.6146812,   7.27272749
  39563,    23.763237,   63.3832054,   7.27272749
  39564,    23.322073,   64.1379776,   7.27272749
  39565,   22.8569469,   64.8782272,   7.27272749
  39566,   22.3683357,   65.6031799,   7.27272749
  39567,   21.8567371,   66.3121033,   7.27272749
  39568,   21.3226757,   67.0042648,   7.27272749
  39569,   20.7667084,   67.6789551,   7.27272749
  39570,   20.1893978,   68.3354797,   7.27272749
  39571,   19.5913467,   68.9731598,   7.27272749
  39572,   18.9731579,   69.5913467,   7.27272749
  39573,   18.3354778,   70.1893997,   7.27272749
  39574,   17.6789589,   70.7667084,   7.27272749
  39575,   17.0042686,   71.3226776,   7.27272749
  39576,   16.3121033,   71.8567352,   7.27272749
  39577,   15.6031809,   72.3683319,   7.27272749
  39578,   14.8782225,   72.8569489,   7.27272749
  39579,   14.1379805,   73.3220749,   7.27272749
  39580,   13.3832054,    73.763237,   7.27272749
  39581,   12.6146812,   74.1799774,   7.27272749
  39582,   11.8331919,   74.5718765,   7.27272749
  39583,   11.0395451,   74.9385223,   7.27272749
  39584,   10.2345543,   75.2795486,   7.27272749
  39585,   9.41904736,   75.5945969,   7.27272749
  39586,   8.59386063,   75.8833389,   7.27272749
  39587,    7.7598443,   76.1454849,   7.27272749
  39588,   6.91785288,   76.3807678,   7.27272749
  39589,   6.06875229,   76.5889435,   7.27272749
  39590,   5.21341705,   76.7697983,   7.27272749
  39591,   4.35272408,   76.9231415,   7.27272749
  39592,   3.48755884,   77.0488205,   7.27272749
  39593,    2.6188097,   77.1467056,   7.27272749
  39594,   1.74736965,   77.2166901,   7.27272749
  39595,  0.874133945,   77.2587128,   7.27272749
  39596,           0.,    77.272728,   7.27272749
  39597, -0.874133945,   77.2587128,   7.27272749
  39598,  -1.74736965,   77.2166901,   7.27272749
  39599,   -2.6188097,   77.1467056,   7.27272749
  39600,  -3.48755884,   77.0488205,   7.27272749
  39601,  -4.35272408,   76.9231415,   7.27272749
  39602,  -5.21341705,   76.7697983,   7.27272749
  39603,  -6.06875229,   76.5889435,   7.27272749
  39604,  -6.91785288,   76.3807678,   7.27272749
  39605,   -7.7598443,   76.1454849,   7.27272749
  39606,  -8.59386063,   75.8833389,   7.27272749
  39607,  -9.41904736,   75.5945969,   7.27272749
  39608,  -10.2345543,   75.2795486,   7.27272749
  39609,  -11.0395451,   74.9385223,   7.27272749
  39610,  -11.8331919,   74.5718765,   7.27272749
  39611,  -12.6146812,   74.1799774,   7.27272749
  39612,  -13.3832054,    73.763237,   7.27272749
  39613,  -14.1379805,   73.3220749,   7.27272749
  39614,  -14.8782225,   72.8569489,   7.27272749
  39615,  -15.6031809,   72.3683319,   7.27272749
  39616,  -16.3121033,   71.8567352,   7.27272749
  39617,  -17.0042686,   71.3226776,   7.27272749
  39618,  -17.6789589,   70.7667084,   7.27272749
  39619,  -18.3354778,   70.1893997,   7.27272749
  39620,  -18.9731579,   69.5913467,   7.27272749
  39621,  -19.5913467,   68.9731598,   7.27272749
  39622,  -20.1893978,   68.3354797,   7.27272749
  39623,  -20.7667084,   67.6789551,   7.27272749
  39624,  -21.3226757,   67.0042648,   7.27272749
  39625,  -21.8567371,   66.3121033,   7.27272749
  39626,  -22.3683357,   65.6031799,   7.27272749
  39627,  -22.8569469,   64.8782272,   7.27272749
  39628,   -23.322073,   64.1379776,   7.27272749
  39629,   -23.763237,   63.3832054,   7.27272749
  39630,  -24.1799812,   62.6146812,   7.27272749
  39631,  -24.5718784,   61.8331947,   7.27272749
  39632,  -24.9385262,    61.039547,   7.27272749
  39633,  -25.2795486,   60.2345543,   7.27272749
  39634,   -25.594593,   59.4190483,   7.27272749
  39635,  -25.8833389,   58.5938606,   7.27272749
  39636,  -26.1454868,   57.7598419,   7.27272749
  39637,  -26.3807697,   56.9178505,   7.27272749
  39638,  -26.5889435,   56.0687523,   7.27272749
  39639,  -26.7697926,   55.2134171,   7.27272749
  39640,  -26.9231396,    54.352726,   7.27272749
  39641,  -27.0488186,   53.4875603,   7.27272749
  39642,  -27.1467037,   52.6188087,   7.27272749
  39643,   -27.216692,   51.7473679,   7.27272749
  39644,  -27.2587147,   50.8741341,   7.27272749
  39645,   27.2587147,   50.8741341,   8.18181801
  39646,    27.216692,   51.7473679,   8.18181801
  39647,   27.1467037,   52.6188087,   8.18181801
  39648,   27.0488186,   53.4875603,   8.18181801
  39649,   26.9231396,    54.352726,   8.18181801
  39650,   26.7697926,   55.2134171,   8.18181801
  39651,   26.5889435,   56.0687523,   8.18181801
  39652,   26.3807697,   56.9178505,   8.18181801
  39653,   26.1454868,   57.7598419,   8.18181801
  39654,   25.8833389,   58.5938606,   8.18181801
  39655,    25.594593,   59.4190483,   8.18181801
  39656,   25.2795486,   60.2345543,   8.18181801
  39657,   24.9385262,    61.039547,   8.18181801
  39658,   24.5718784,   61.8331947,   8.18181801
  39659,   24.1799812,   62.6146812,   8.18181801
  39660,    23.763237,   63.3832054,   8.18181801
  39661,    23.322073,   64.1379776,   8.18181801
  39662,   22.8569469,   64.8782272,   8.18181801
  39663,   22.3683357,   65.6031799,   8.18181801
  39664,   21.8567371,   66.3121033,   8.18181801
  39665,   21.3226757,   67.0042648,   8.18181801
  39666,   20.7667084,   67.6789551,   8.18181801
  39667,   20.1893978,   68.3354797,   8.18181801
  39668,   19.5913467,   68.9731598,   8.18181801
  39669,   18.9731579,   69.5913467,   8.18181801
  39670,   18.3354778,   70.1893997,   8.18181801
  39671,   17.6789589,   70.7667084,   8.18181801
  39672,   17.0042686,   71.3226776,   8.18181801
  39673,   16.3121033,   71.8567352,   8.18181801
  39674,   15.6031809,   72.3683319,   8.18181801
  39675,   14.8782225,   72.8569489,   8.18181801
  39676,   14.1379805,   73.3220749,   8.18181801
  39677,   13.3832054,    73.763237,   8.18181801
  39678,   12.6146812,   74.1799774,   8.18181801
  39679,   11.8331919,   74.5718765,   8.18181801
  39680,   11.0395451,   74.9385223,   8.18181801
  39681,   10.2345543,   75.2795486,   8.18181801
  39682,   9.41904736,   75.5945969,   8.18181801
  39683,   8.59386063,   75.8833389,   8.18181801
  39684,    7.7598443,   76.1454849,   8.18181801
  39685,   6.91785288,   76.3807678,   8.18181801
  39686,   6.06875229,   76.5889435,   8.18181801
  39687,   5.21341705,   76.7697983,   8.18181801
  39688,   4.35272408,   76.9231415,   8.18181801
  39689,   3.48755884,   77.0488205,   8.18181801
  39690,    2.6188097,   77.1467056,   8.18181801
  39691,   1.74736965,   77.2166901,   8.18181801
  39692,  0.874133945,   77.2587128,   8.18181801
  39693,           0.,    77.272728,   8.18181801
  39694, -0.874133945,   77.2587128,   8.18181801
  39695,  -1.74736965,   77.2166901,   8.18181801
  39696,   -2.6188097,   77.1467056,   8.18181801
  39697,  -3.48755884,   77.0488205,   8.18181801
  39698,  -4.35272408,   76.9231415,   8.18181801
  39699,  -5.21341705,   76.7697983,   8.18181801
  39700,  -6.06875229,   76.5889435,   8.18181801
  39701,  -6.91785288,   76.3807678,   8.18181801
  39702,   -7.7598443,   76.1454849,   8.18181801
  39703,  -8.59386063,   75.8833389,   8.18181801
  39704,  -9.41904736,   75.5945969,   8.18181801
  39705,  -10.2345543,   75.2795486,   8.18181801
  39706,  -11.0395451,   74.9385223,   8.18181801
  39707,  -11.8331919,   74.5718765,   8.18181801
  39708,  -12.6146812,   74.1799774,   8.18181801
  39709,  -13.3832054,    73.763237,   8.18181801
  39710,  -14.1379805,   73.3220749,   8.18181801
  39711,  -14.8782225,   72.8569489,   8.18181801
  39712,  -15.6031809,   72.3683319,   8.18181801
  39713,  -16.3121033,   71.8567352,   8.18181801
  39714,  -17.0042686,   71.3226776,   8.18181801
  39715,  -17.6789589,   70.7667084,   8.18181801
  39716,  -18.3354778,   70.1893997,   8.18181801
  39717,  -18.9731579,   69.5913467,   8.18181801
  39718,  -19.5913467,   68.9731598,   8.18181801
  39719,  -20.1893978,   68.3354797,   8.18181801
  39720,  -20.7667084,   67.6789551,   8.18181801
  39721,  -21.3226757,   67.0042648,   8.18181801
  39722,  -21.8567371,   66.3121033,   8.18181801
  39723,  -22.3683357,   65.6031799,   8.18181801
  39724,  -22.8569469,   64.8782272,   8.18181801
  39725,   -23.322073,   64.1379776,   8.18181801
  39726,   -23.763237,   63.3832054,   8.18181801
  39727,  -24.1799812,   62.6146812,   8.18181801
  39728,  -24.5718784,   61.8331947,   8.18181801
  39729,  -24.9385262,    61.039547,   8.18181801
  39730,  -25.2795486,   60.2345543,   8.18181801
  39731,   -25.594593,   59.4190483,   8.18181801
  39732,  -25.8833389,   58.5938606,   8.18181801
  39733,  -26.1454868,   57.7598419,   8.18181801
  39734,  -26.3807697,   56.9178505,   8.18181801
  39735,  -26.5889435,   56.0687523,   8.18181801
  39736,  -26.7697926,   55.2134171,   8.18181801
  39737,  -26.9231396,    54.352726,   8.18181801
  39738,  -27.0488186,   53.4875603,   8.18181801
  39739,  -27.1467037,   52.6188087,   8.18181801
  39740,   -27.216692,   51.7473679,   8.18181801
  39741,  -27.2587147,   50.8741341,   8.18181801
  39742,   27.2587147,   50.8741341,     9.090909
  39743,    27.216692,   51.7473679,     9.090909
  39744,   27.1467037,   52.6188087,     9.090909
  39745,   27.0488186,   53.4875603,     9.090909
  39746,   26.9231396,    54.352726,     9.090909
  39747,   26.7697926,   55.2134171,     9.090909
  39748,   26.5889435,   56.0687523,     9.090909
  39749,   26.3807697,   56.9178505,     9.090909
  39750,   26.1454868,   57.7598419,     9.090909
  39751,   25.8833389,   58.5938606,     9.090909
  39752,    25.594593,   59.4190483,     9.090909
  39753,   25.2795486,   60.2345543,     9.090909
  39754,   24.9385262,    61.039547,     9.090909
  39755,   24.5718784,   61.8331947,     9.090909
  39756,   24.1799812,   62.6146812,     9.090909
  39757,    23.763237,   63.3832054,     9.090909
  39758,    23.322073,   64.1379776,     9.090909
  39759,   22.8569469,   64.8782272,     9.090909
  39760,   22.3683357,   65.6031799,     9.090909
  39761,   21.8567371,   66.3121033,     9.090909
  39762,   21.3226757,   67.0042648,     9.090909
  39763,   20.7667084,   67.6789551,     9.090909
  39764,   20.1893978,   68.3354797,     9.090909
  39765,   19.5913467,   68.9731598,     9.090909
  39766,   18.9731579,   69.5913467,     9.090909
  39767,   18.3354778,   70.1893997,     9.090909
  39768,   17.6789589,   70.7667084,     9.090909
  39769,   17.0042686,   71.3226776,     9.090909
  39770,   16.3121033,   71.8567352,     9.090909
  39771,   15.6031809,   72.3683319,     9.090909
  39772,   14.8782225,   72.8569489,     9.090909
  39773,   14.1379805,   73.3220749,     9.090909
  39774,   13.3832054,    73.763237,     9.090909
  39775,   12.6146812,   74.1799774,     9.090909
  39776,   11.8331919,   74.5718765,     9.090909
  39777,   11.0395451,   74.9385223,     9.090909
  39778,   10.2345543,   75.2795486,     9.090909
  39779,   9.41904736,   75.5945969,     9.090909
  39780,   8.59386063,   75.8833389,     9.090909
  39781,    7.7598443,   76.1454849,     9.090909
  39782,   6.91785288,   76.3807678,     9.090909
  39783,   6.06875229,   76.5889435,     9.090909
  39784,   5.21341705,   76.7697983,     9.090909
  39785,   4.35272408,   76.9231415,     9.090909
  39786,   3.48755884,   77.0488205,     9.090909
  39787,    2.6188097,   77.1467056,     9.090909
  39788,   1.74736965,   77.2166901,     9.090909
  39789,  0.874133945,   77.2587128,     9.090909
  39790,           0.,    77.272728,     9.090909
  39791, -0.874133945,   77.2587128,     9.090909
  39792,  -1.74736965,   77.2166901,     9.090909
  39793,   -2.6188097,   77.1467056,     9.090909
  39794,  -3.48755884,   77.0488205,     9.090909
  39795,  -4.35272408,   76.9231415,     9.090909
  39796,  -5.21341705,   76.7697983,     9.090909
  39797,  -6.06875229,   76.5889435,     9.090909
  39798,  -6.91785288,   76.3807678,     9.090909
  39799,   -7.7598443,   76.1454849,     9.090909
  39800,  -8.59386063,   75.8833389,     9.090909
  39801,  -9.41904736,   75.5945969,     9.090909
  39802,  -10.2345543,   75.2795486,     9.090909
  39803,  -11.0395451,   74.9385223,     9.090909
  39804,  -11.8331919,   74.5718765,     9.090909
  39805,  -12.6146812,   74.1799774,     9.090909
  39806,  -13.3832054,    73.763237,     9.090909
  39807,  -14.1379805,   73.3220749,     9.090909
  39808,  -14.8782225,   72.8569489,     9.090909
  39809,  -15.6031809,   72.3683319,     9.090909
  39810,  -16.3121033,   71.8567352,     9.090909
  39811,  -17.0042686,   71.3226776,     9.090909
  39812,  -17.6789589,   70.7667084,     9.090909
  39813,  -18.3354778,   70.1893997,     9.090909
  39814,  -18.9731579,   69.5913467,     9.090909
  39815,  -19.5913467,   68.9731598,     9.090909
  39816,  -20.1893978,   68.3354797,     9.090909
  39817,  -20.7667084,   67.6789551,     9.090909
  39818,  -21.3226757,   67.0042648,     9.090909
  39819,  -21.8567371,   66.3121033,     9.090909
  39820,  -22.3683357,   65.6031799,     9.090909
  39821,  -22.8569469,   64.8782272,     9.090909
  39822,   -23.322073,   64.1379776,     9.090909
  39823,   -23.763237,   63.3832054,     9.090909
  39824,  -24.1799812,   62.6146812,     9.090909
  39825,  -24.5718784,   61.8331947,     9.090909
  39826,  -24.9385262,    61.039547,     9.090909
  39827,  -25.2795486,   60.2345543,     9.090909
  39828,   -25.594593,   59.4190483,     9.090909
  39829,  -25.8833389,   58.5938606,     9.090909
  39830,  -26.1454868,   57.7598419,     9.090909
  39831,  -26.3807697,   56.9178505,     9.090909
  39832,  -26.5889435,   56.0687523,     9.090909
  39833,  -26.7697926,   55.2134171,     9.090909
  39834,  -26.9231396,    54.352726,     9.090909
  39835,  -27.0488186,   53.4875603,     9.090909
  39836,  -27.1467037,   52.6188087,     9.090909
  39837,   -27.216692,   51.7473679,     9.090909
  39838,  -27.2587147,   50.8741341,     9.090909
  39839,   26.3500919,   50.8449974,  0.909090936
  39840,   26.3094692,   51.6891251,  0.909090936
  39841,   26.2418137,    52.531517,  0.909090936
  39842,    26.147192,   53.3713074,  0.909090936
  39843,   26.0257015,    54.207634,  0.909090936
  39844,   25.8774662,   55.0396347,  0.909090936
  39845,   25.7026443,   55.8664627,  0.909090936
  39846,   25.5014095,   56.6872559,  0.909090936
  39847,   25.2739716,   57.5011826,  0.909090936
  39848,   25.0205612,   58.3073997,  0.909090936
  39849,   24.7414398,   59.1050797,  0.909090936
  39850,   24.4368973,   59.8934021,  0.909090936
  39851,   24.1072426,   60.6715622,  0.909090936
  39852,   23.7528152,   61.4387512,  0.909090936
  39853,   23.3739815,    62.194191,  0.909090936
  39854,   22.9711304,   62.9370995,  0.909090936
  39855,   22.5446701,   63.6667137,  0.909090936
  39856,   22.0950489,   64.3822861,  0.909090936
  39857,   21.6227245,   65.0830765,  0.909090936
  39858,   21.1281796,   65.7683716,  0.909090936
  39859,   20.6119194,   66.4374619,  0.909090936
  39860,   20.0744839,   67.0896606,  0.909090936
  39861,   19.5164185,   67.7242966,  0.909090936
  39862,   18.9383011,   68.3407211,  0.909090936
  39863,   18.3407192,   68.9383011,  0.909090936
  39864,   17.7242966,   69.5164185,  0.909090936
  39865,   17.0896568,   70.0744858,  0.909090936
  39866,   16.4374599,   70.6119232,  0.909090936
  39867,   15.7683668,   71.1281738,  0.909090936
  39868,   15.0830746,   71.6227264,  0.909090936
  39869,   14.3822823,    72.095047,  0.909090936
  39870,   13.6667137,   72.5446701,  0.909090936
  39871,   12.9370985,   72.9711304,  0.909090936
  39872,   12.1941919,   73.3739853,  0.909090936
  39873,   11.4387522,   73.7528152,  0.909090936
  39874,   10.6715603,   74.1072388,  0.909090936
  39875,   9.89340305,   74.4368973,  0.909090936
  39876,    9.1050787,   74.7414398,  0.909090936
  39877,    8.3073988,   75.0205612,  0.909090936
  39878,   7.50118256,   75.2739716,  0.909090936
  39879,   6.68725777,   75.5014114,  0.909090936
  39880,   5.86646032,   75.7026443,  0.909090936
  39881,   5.03963661,   75.8774719,  0.909090936
  39882,   4.20763302,   76.0257034,  0.909090936
  39883,    3.3713069,   76.1471939,  0.909090936
  39884,   2.53151608,   76.2418137,  0.909090936
  39885,   1.68912399,   76.3094711,  0.909090936
  39886,  0.844996154,     76.35009,  0.909090936
  39887,           0.,   76.3636398,  0.909090936
  39888, -0.844996154,     76.35009,  0.909090936
  39889,  -1.68912399,   76.3094711,  0.909090936
  39890,  -2.53151608,   76.2418137,  0.909090936
  39891,   -3.3713069,   76.1471939,  0.909090936
  39892,  -4.20763302,   76.0257034,  0.909090936
  39893,  -5.03963661,   75.8774719,  0.909090936
  39894,  -5.86646032,   75.7026443,  0.909090936
  39895,  -6.68725777,   75.5014114,  0.909090936
  39896,  -7.50118256,   75.2739716,  0.909090936
  39897,   -8.3073988,   75.0205612,  0.909090936
  39898,   -9.1050787,   74.7414398,  0.909090936
  39899,  -9.89340305,   74.4368973,  0.909090936
  39900,  -10.6715603,   74.1072388,  0.909090936
  39901,  -11.4387522,   73.7528152,  0.909090936
  39902,  -12.1941919,   73.3739853,  0.909090936
  39903,  -12.9370985,   72.9711304,  0.909090936
  39904,  -13.6667137,   72.5446701,  0.909090936
  39905,  -14.3822823,    72.095047,  0.909090936
  39906,  -15.0830746,   71.6227264,  0.909090936
  39907,  -15.7683668,   71.1281738,  0.909090936
  39908,  -16.4374599,   70.6119232,  0.909090936
  39909,  -17.0896568,   70.0744858,  0.909090936
  39910,  -17.7242966,   69.5164185,  0.909090936
  39911,  -18.3407192,   68.9383011,  0.909090936
  39912,  -18.9383011,   68.3407211,  0.909090936
  39913,  -19.5164185,   67.7242966,  0.909090936
  39914,  -20.0744839,   67.0896606,  0.909090936
  39915,  -20.6119194,   66.4374619,  0.909090936
  39916,  -21.1281796,   65.7683716,  0.909090936
  39917,  -21.6227245,   65.0830765,  0.909090936
  39918,  -22.0950489,   64.3822861,  0.909090936
  39919,  -22.5446701,   63.6667137,  0.909090936
  39920,  -22.9711304,   62.9370995,  0.909090936
  39921,  -23.3739815,    62.194191,  0.909090936
  39922,  -23.7528152,   61.4387512,  0.909090936
  39923,  -24.1072426,   60.6715622,  0.909090936
  39924,  -24.4368973,   59.8934021,  0.909090936
  39925,  -24.7414398,   59.1050797,  0.909090936
  39926,  -25.0205612,   58.3073997,  0.909090936
  39927,  -25.2739716,   57.5011826,  0.909090936
  39928,  -25.5014095,   56.6872559,  0.909090936
  39929,  -25.7026443,   55.8664627,  0.909090936
  39930,  -25.8774662,   55.0396347,  0.909090936
  39931,  -26.0257015,    54.207634,  0.909090936
  39932,   -26.147192,   53.3713074,  0.909090936
  39933,  -26.2418137,    52.531517,  0.909090936
  39934,  -26.3094692,   51.6891251,  0.909090936
  39935,  -26.3500919,   50.8449974,  0.909090936
  39936,   26.3500919,   50.8449974,   1.81818187
  39937,   26.3094692,   51.6891251,   1.81818187
  39938,   26.2418137,    52.531517,   1.81818187
  39939,    26.147192,   53.3713074,   1.81818187
  39940,   26.0257015,    54.207634,   1.81818187
  39941,   25.8774662,   55.0396347,   1.81818187
  39942,   25.7026443,   55.8664627,   1.81818187
  39943,   25.5014095,   56.6872559,   1.81818187
  39944,   25.2739716,   57.5011826,   1.81818187
  39945,   25.0205612,   58.3073997,   1.81818187
  39946,   24.7414398,   59.1050797,   1.81818187
  39947,   24.4368973,   59.8934021,   1.81818187
  39948,   24.1072426,   60.6715622,   1.81818187
  39949,   23.7528152,   61.4387512,   1.81818187
  39950,   23.3739815,    62.194191,   1.81818187
  39951,   22.9711304,   62.9370995,   1.81818187
  39952,   22.5446701,   63.6667137,   1.81818187
  39953,   22.0950489,   64.3822861,   1.81818187
  39954,   21.6227245,   65.0830765,   1.81818187
  39955,   21.1281796,   65.7683716,   1.81818187
  39956,   20.6119194,   66.4374619,   1.81818187
  39957,   20.0744839,   67.0896606,   1.81818187
  39958,   19.5164185,   67.7242966,   1.81818187
  39959,   18.9383011,   68.3407211,   1.81818187
  39960,   18.3407192,   68.9383011,   1.81818187
  39961,   17.7242966,   69.5164185,   1.81818187
  39962,   17.0896568,   70.0744858,   1.81818187
  39963,   16.4374599,   70.6119232,   1.81818187
  39964,   15.7683668,   71.1281738,   1.81818187
  39965,   15.0830746,   71.6227264,   1.81818187
  39966,   14.3822823,    72.095047,   1.81818187
  39967,   13.6667137,   72.5446701,   1.81818187
  39968,   12.9370985,   72.9711304,   1.81818187
  39969,   12.1941919,   73.3739853,   1.81818187
  39970,   11.4387522,   73.7528152,   1.81818187
  39971,   10.6715603,   74.1072388,   1.81818187
  39972,   9.89340305,   74.4368973,   1.81818187
  39973,    9.1050787,   74.7414398,   1.81818187
  39974,    8.3073988,   75.0205612,   1.81818187
  39975,   7.50118256,   75.2739716,   1.81818187
  39976,   6.68725777,   75.5014114,   1.81818187
  39977,   5.86646032,   75.7026443,   1.81818187
  39978,   5.03963661,   75.8774719,   1.81818187
  39979,   4.20763302,   76.0257034,   1.81818187
  39980,    3.3713069,   76.1471939,   1.81818187
  39981,   2.53151608,   76.2418137,   1.81818187
  39982,   1.68912399,   76.3094711,   1.81818187
  39983,  0.844996154,     76.35009,   1.81818187
  39984,           0.,   76.3636398,   1.81818187
  39985, -0.844996154,     76.35009,   1.81818187
  39986,  -1.68912399,   76.3094711,   1.81818187
  39987,  -2.53151608,   76.2418137,   1.81818187
  39988,   -3.3713069,   76.1471939,   1.81818187
  39989,  -4.20763302,   76.0257034,   1.81818187
  39990,  -5.03963661,   75.8774719,   1.81818187
  39991,  -5.86646032,   75.7026443,   1.81818187
  39992,  -6.68725777,   75.5014114,   1.81818187
  39993,  -7.50118256,   75.2739716,   1.81818187
  39994,   -8.3073988,   75.0205612,   1.81818187
