  13995,   26.2857151,   19.2857151,          10.
  13996,   27.1428566,   19.2857151,          10.
  13997,          28.,   19.2857151,          10.
  13998,   28.8571434,   19.2857151,          10.
  13999,   22.1936531,   16.0749474,   4.88308191
  14000,   22.8172855,   16.0749474,   4.88308191
  14001,    23.440918,   16.0749474,   4.88308191
  14002,   24.0645523,   16.0749474,   4.88308191
  14003,   24.6881847,   16.0749474,   4.88308191
  14004,   25.3118172,   16.0749474,   4.88308191
  14005,   25.9354496,   16.0749474,   4.88308191
  14006,    26.559082,   16.0749474,   4.88308191
  14007,   27.1827145,   16.0749474,   4.88308191
  14008,   27.8063469,   16.0749474,   4.88308191
  14009,   21.8562851,   17.1057968,   4.53493309
  14010,   22.5548878,   17.1057968,   4.53493309
  14011,   23.2534924,   17.1057968,   4.53493309
  14012,    23.952095,   17.1057968,   4.53493309
  14013,   24.6506977,   17.1057968,   4.53493309
  14014,   25.3493023,   17.1057968,   4.53493309
  14015,    26.047905,   17.1057968,   4.53493309
  14016,   26.7465096,   17.1057968,   4.53493309
  14017,   27.4451122,   17.1057987,   4.53493261
  14018,   28.1437149,   17.1057987,   4.53493261
  14019,   21.5482197,   18.0471096,   3.96423054
  14020,   22.3152809,   18.0471096,   3.96423054
  14021,   23.0823441,   18.0471096,   3.96423054
  14022,   23.8494072,   18.0471096,   3.96423054
  14023,   24.6164684,   18.0471096,   3.96423054
  14024,   25.3835316,   18.0471096,   3.96423054
  14025,   26.1505928,   18.0471096,   3.96423054
  14026,   26.9176559,   18.0471096,   3.96423054
  14027,   27.6847191,   18.0471096,   3.96423054
  14028,   28.4517803,   18.0471096,   3.96423054
  14029,    21.284914,   18.8516521,   3.18822408
  14030,   22.1104889,   18.8516521,   3.18822432
  14031,   22.9360638,   18.8516521,   3.18822432
  14032,   23.7616386,   18.8516521,   3.18822432
  14033,   24.5872116,   18.8516521,   3.18822432
  14034,   25.4127865,   18.8516521,   3.18822432
  14035,   26.2383614,   18.8516521,   3.18822432
  14036,   27.0639362,   18.8516521,   3.18822432
  14037,   27.8895111,   18.8516521,   3.18822432
  14038,    28.715086,   18.8516521,   3.18822432
  14039,    21.081892,   19.4719944,   2.23634958
  14040,   21.9525833,   19.4719944,   2.23634958
  14041,   22.8232727,   19.4719944,   2.23634982
  14042,    23.693964,   19.4719944,   2.23634982
  14043,   24.5646553,   19.4719944,   2.23634982
  14044,   25.4353447,   19.4719944,   2.23634982
  14045,    26.306036,   19.4719944,   2.23635006
  14046,   27.1767254,   19.4719944,   2.23635006
  14047,   28.0474167,   19.4719944,   2.23635006
  14048,    28.918108,   19.4719944,   2.23635006
  14049,   20.9532299,   19.8651333,   1.15346622
  14050,   21.8525124,   19.8651333,   1.15346634
  14051,   22.7517948,   19.8651333,   1.15346634
  14052,   23.6510773,   19.8651333,   1.15346646
  14053,   24.5503578,   19.8651333,   1.15346658
  14054,   25.4496403,   19.8651333,    1.1534667
  14055,   26.3489227,   19.8651333,    1.1534667
  14056,   27.2482052,   19.8651333,    1.1534667
  14057,   28.1474876,   19.8651333,   1.15346682
  14058,   29.0467701,   19.8651333,   1.15346694
  14059,    -29.09091,   20.7894745,          10.
  14060,   -28.181818,   20.7894745,          10.
  14061,   -27.272728,   20.7894745,          10.
  14062,   -26.363636,   20.7894745,          10.
  14063,   -25.454546,   20.7894745,          10.
  14064,   -24.545454,   20.7894745,          10.
  14065,   -23.636364,   20.7894745,          10.
  14066,   -22.727272,   20.7894745,          10.
  14067,   -21.818182,   20.7894745,          10.
  14068,    -20.90909,   20.7894745,          10.
  14069,    -29.09091,   21.5789471,          10.
  14070,   -28.181818,   21.5789471,          10.
  14071,   -27.272728,   21.5789471,          10.
  14072,   -26.363636,   21.5789471,          10.
  14073,   -25.454546,   21.5789471,          10.
  14074,   -24.545454,   21.5789471,          10.
  14075,   -23.636364,   21.5789471,          10.
  14076,   -22.727272,   21.5789471,          10.
  14077,   -21.818182,   21.5789471,          10.
  14078,    -20.90909,   21.5789471,          10.
  14079,    -29.09091,   22.3684216,          10.
  14080,   -28.181818,   22.3684216,          10.
  14081,   -27.272728,   22.3684216,          10.
  14082,   -26.363636,   22.3684216,          10.
  14083,   -25.454546,   22.3684216,          10.
  14084,   -24.545454,   22.3684216,          10.
  14085,   -23.636364,   22.3684216,          10.
  14086,   -22.727272,   22.3684216,          10.
  14087,   -21.818182,   22.3684216,          10.
  14088,    -20.90909,   22.3684216,          10.
  14089,    -29.09091,   23.1578941,          10.
  14090,   -28.181818,   23.1578941,          10.
  14091,   -27.272728,   23.1578941,          10.
  14092,   -26.363636,   23.1578941,          10.
  14093,   -25.454546,   23.1578941,          10.
  14094,   -24.545454,   23.1578941,          10.
  14095,   -23.636364,   23.1578941,          10.
  14096,   -22.727272,   23.1578941,          10.
  14097,   -21.818182,   23.1578941,          10.
  14098,    -20.90909,   23.1578941,          10.
  14099,    -29.09091,   23.9473686,          10.
  14100,   -28.181818,   23.9473686,          10.
  14101,   -27.272728,   23.9473686,          10.
  14102,   -26.363636,   23.9473686,          10.
  14103,   -25.454546,   23.9473686,          10.
  14104,   -24.545454,   23.9473686,          10.
  14105,   -23.636364,   23.9473686,          10.
  14106,   -22.727272,   23.9473686,          10.
  14107,   -21.818182,   23.9473686,          10.
  14108,    -20.90909,   23.9473686,          10.
  14109,    -29.09091,   24.7368412,          10.
  14110,   -28.181818,   24.7368412,          10.
  14111,   -27.272728,   24.7368412,          10.
  14112,   -26.363636,   24.7368412,          10.
  14113,   -25.454546,   24.7368412,          10.
  14114,   -24.545454,   24.7368412,          10.
  14115,   -23.636364,   24.7368412,          10.
  14116,   -22.727272,   24.7368412,          10.
  14117,   -21.818182,   24.7368412,          10.
  14118,    -20.90909,   24.7368412,          10.
  14119,    -29.09091,   25.5263157,          10.
  14120,   -28.181818,   25.5263157,          10.
  14121,   -27.272728,   25.5263157,          10.
  14122,   -26.363636,   25.5263157,          10.
  14123,   -25.454546,   25.5263157,          10.
  14124,   -24.545454,   25.5263157,          10.
  14125,   -23.636364,   25.5263157,          10.
  14126,   -22.727272,   25.5263157,          10.
  14127,   -21.818182,   25.5263157,          10.
  14128,    -20.90909,   25.5263157,          10.
  14129,    -29.09091,   26.3157902,          10.
  14130,   -28.181818,   26.3157902,          10.
  14131,   -27.272728,   26.3157902,          10.
  14132,   -26.363636,   26.3157902,          10.
  14133,   -25.454546,   26.3157902,          10.
  14134,   -24.545454,   26.3157902,          10.
  14135,   -23.636364,   26.3157902,          10.
  14136,   -22.727272,   26.3157902,          10.
  14137,   -21.818182,   26.3157902,          10.
  14138,    -20.90909,   26.3157902,          10.
  14139,    -29.09091,   27.1052628,          10.
  14140,   -28.181818,   27.1052628,          10.
  14141,   -27.272728,   27.1052628,          10.
  14142,   -26.363636,   27.1052628,          10.
  14143,   -25.454546,   27.1052628,          10.
  14144,   -24.545454,   27.1052628,          10.
  14145,   -23.636364,   27.1052628,          10.
  14146,   -22.727272,   27.1052628,          10.
  14147,   -21.818182,   27.1052628,          10.
  14148,    -20.90909,   27.1052628,          10.
  14149,    -29.09091,   27.8947372,          10.
  14150,   -28.181818,   27.8947372,          10.
  14151,   -27.272728,   27.8947372,          10.
  14152,   -26.363636,   27.8947372,          10.
  14153,   -25.454546,   27.8947372,          10.
  14154,   -24.545454,   27.8947372,          10.
  14155,   -23.636364,   27.8947372,          10.
  14156,   -22.727272,   27.8947372,          10.
  14157,   -21.818182,   27.8947372,          10.
  14158,    -20.90909,   27.8947372,          10.
  14159,    -29.09091,   28.6842098,          10.
  14160,   -28.181818,   28.6842098,          10.
  14161,   -27.272728,   28.6842098,          10.
  14162,   -26.363636,   28.6842098,          10.
  14163,   -25.454546,   28.6842098,          10.
  14164,   -24.545454,   28.6842098,          10.
  14165,   -23.636364,   28.6842098,          10.
  14166,   -22.727272,   28.6842098,          10.
  14167,   -21.818182,   28.6842098,          10.
  14168,    -20.90909,   28.6842098,          10.
  14169,    -29.09091,   29.4736843,          10.
  14170,   -28.181818,   29.4736843,          10.
  14171,   -27.272728,   29.4736843,          10.
  14172,   -26.363636,   29.4736843,          10.
  14173,   -25.454546,   29.4736843,          10.
  14174,   -24.545454,   29.4736843,          10.
  14175,   -23.636364,   29.4736843,          10.
  14176,   -22.727272,   29.4736843,          10.
  14177,   -21.818182,   29.4736843,          10.
  14178,    -20.90909,   29.4736843,          10.
  14179,    -29.09091,   30.2631588,          10.
  14180,   -28.181818,   30.2631588,          10.
  14181,   -27.272728,   30.2631588,          10.
  14182,   -26.363636,   30.2631588,          10.
  14183,   -25.454546,   30.2631588,          10.
  14184,   -24.545454,   30.2631588,          10.
  14185,   -23.636364,   30.2631588,          10.
  14186,   -22.727272,   30.2631588,          10.
  14187,   -21.818182,   30.2631588,          10.
  14188,    -20.90909,   30.2631588,          10.
  14189,    -29.09091,   31.0526314,          10.
  14190,   -28.181818,   31.0526314,          10.
  14191,   -27.272728,   31.0526314,          10.
  14192,   -26.363636,   31.0526314,          10.
  14193,   -25.454546,   31.0526314,          10.
  14194,   -24.545454,   31.0526314,          10.
  14195,   -23.636364,   31.0526314,          10.
  14196,   -22.727272,   31.0526314,          10.
  14197,   -21.818182,   31.0526314,          10.
  14198,    -20.90909,   31.0526314,          10.
  14199,    -29.09091,   31.8421059,          10.
  14200,   -28.181818,   31.8421059,          10.
  14201,   -27.272728,   31.8421059,          10.
  14202,   -26.363636,   31.8421059,          10.
  14203,   -25.454546,   31.8421059,          10.
  14204,   -24.545454,   31.8421059,          10.
  14205,   -23.636364,   31.8421059,          10.
  14206,   -22.727272,   31.8421059,          10.
  14207,   -21.818182,   31.8421059,          10.
  14208,    -20.90909,   31.8421059,          10.
  14209,    -29.09091,   32.6315804,          10.
  14210,   -28.181818,   32.6315804,          10.
  14211,   -27.272728,   32.6315804,          10.
  14212,   -26.363636,   32.6315804,          10.
  14213,   -25.454546,   32.6315804,          10.
  14214,   -24.545454,   32.6315804,          10.
  14215,   -23.636364,   32.6315804,          10.
  14216,   -22.727272,   32.6315804,          10.
  14217,   -21.818182,   32.6315804,          10.
  14218,    -20.90909,   32.6315804,          10.
  14219,    -29.09091,    33.421051,          10.
  14220,   -28.181818,    33.421051,          10.
  14221,   -27.272728,    33.421051,          10.
  14222,   -26.363636,    33.421051,          10.
  14223,   -25.454546,    33.421051,          10.
  14224,   -24.545454,    33.421051,          10.
  14225,   -23.636364,    33.421051,          10.
  14226,   -22.727272,    33.421051,          10.
  14227,   -21.818182,    33.421051,          10.
  14228,    -20.90909,    33.421051,          10.
  14229,    -29.09091,   34.2105255,          10.
  14230,   -28.181818,   34.2105255,          10.
  14231,   -27.272728,   34.2105255,          10.
  14232,   -26.363636,   34.2105255,          10.
  14233,   -25.454546,   34.2105255,          10.
  14234,   -24.545454,   34.2105255,          10.
  14235,   -23.636364,   34.2105255,          10.
  14236,   -22.727272,   34.2105255,          10.
  14237,   -21.818182,   34.2105255,          10.
  14238,    -20.90909,   34.2105255,          10.
  14239,    -29.09091,          35.,          10.
  14240,   -28.181818,          35.,          10.
  14241,   -27.272728,          35.,          10.
  14242,   -26.363636,          35.,          10.
  14243,   -25.454546,          35.,          10.
  14244,   -24.545454,          35.,          10.
  14245,   -23.636364,          35.,          10.
  14246,   -22.727272,          35.,          10.
  14247,   -21.818182,          35.,          10.
  14248,    -20.90909,          35.,          10.
  14249,    -29.09091,   35.7894745,          10.
  14250,   -28.181818,   35.7894745,          10.
  14251,   -27.272728,   35.7894745,          10.
  14252,   -26.363636,   35.7894745,          10.
  14253,   -25.454546,   35.7894745,          10.
  14254,   -24.545454,   35.7894745,          10.
  14255,   -23.636364,   35.7894745,          10.
  14256,   -22.727272,   35.7894745,          10.
  14257,   -21.818182,   35.7894745,          10.
  14258,    -20.90909,   35.7894745,          10.
  14259,    -29.09091,    36.578949,          10.
  14260,   -28.181818,    36.578949,          10.
  14261,   -27.272728,    36.578949,          10.
  14262,   -26.363636,    36.578949,          10.
  14263,   -25.454546,    36.578949,          10.
  14264,   -24.545454,    36.578949,          10.
  14265,   -23.636364,    36.578949,          10.
  14266,   -22.727272,    36.578949,          10.
  14267,   -21.818182,    36.578949,          10.
  14268,    -20.90909,    36.578949,          10.
  14269,    -29.09091,   37.3684196,          10.
  14270,   -28.181818,   37.3684196,          10.
  14271,   -27.272728,   37.3684196,          10.
  14272,   -26.363636,   37.3684196,          10.
  14273,   -25.454546,   37.3684196,          10.
  14274,   -24.545454,   37.3684196,          10.
  14275,   -23.636364,   37.3684196,          10.
  14276,   -22.727272,   37.3684196,          10.
  14277,   -21.818182,   37.3684196,          10.
  14278,    -20.90909,   37.3684196,          10.
  14279,    -29.09091,   38.1578941,          10.
  14280,   -28.181818,   38.1578941,          10.
  14281,   -27.272728,   38.1578941,          10.
  14282,   -26.363636,   38.1578941,          10.
  14283,   -25.454546,   38.1578941,          10.
  14284,   -24.545454,   38.1578941,          10.
  14285,   -23.636364,   38.1578941,          10.
  14286,   -22.727272,   38.1578941,          10.
  14287,   -21.818182,   38.1578941,          10.
  14288,    -20.90909,   38.1578941,          10.
  14289,    -29.09091,   38.9473686,          10.
  14290,   -28.181818,   38.9473686,          10.
  14291,   -27.272728,   38.9473686,          10.
  14292,   -26.363636,   38.9473686,          10.
  14293,   -25.454546,   38.9473686,          10.
  14294,   -24.545454,   38.9473686,          10.
  14295,   -23.636364,   38.9473686,          10.
  14296,   -22.727272,   38.9473686,          10.
  14297,   -21.818182,   38.9473686,          10.
  14298,    -20.90909,   38.9473686,          10.
  14299,    -29.09091,   39.7368431,          10.
  14300,   -28.181818,   39.7368431,          10.
  14301,   -27.272728,   39.7368431,          10.
  14302,   -26.363636,   39.7368431,          10.
  14303,   -25.454546,   39.7368431,          10.
  14304,   -24.545454,   39.7368431,          10.
  14305,   -23.636364,   39.7368431,          10.
  14306,   -22.727272,   39.7368431,          10.
  14307,   -21.818182,   39.7368431,          10.
  14308,    -20.90909,   39.7368431,          10.
  14309,    -29.09091,   40.5263176,          10.
  14310,   -28.181818,   40.5263176,          10.
  14311,   -27.272728,   40.5263176,          10.
  14312,   -26.363636,   40.5263176,          10.
  14313,   -25.454546,   40.5263176,          10.
  14314,   -24.545454,   40.5263176,          10.
  14315,   -23.636364,   40.5263176,          10.
  14316,   -22.727272,   40.5263176,          10.
  14317,   -21.818182,   40.5263176,          10.
  14318,    -20.90909,   40.5263176,          10.
  14319,    -29.09091,   41.3157883,          10.
  14320,   -28.181818,   41.3157883,          10.
  14321,   -27.272728,   41.3157883,          10.
  14322,   -26.363636,   41.3157883,          10.
  14323,   -25.454546,   41.3157883,          10.
  14324,   -24.545454,   41.3157883,          10.
  14325,   -23.636364,   41.3157883,          10.
  14326,   -22.727272,   41.3157883,          10.
  14327,   -21.818182,   41.3157883,          10.
  14328,    -20.90909,   41.3157883,          10.
  14329,    -29.09091,   42.1052628,          10.
  14330,   -28.181818,   42.1052628,          10.
  14331,   -27.272728,   42.1052628,          10.
  14332,   -26.363636,   42.1052628,          10.
  14333,   -25.454546,   42.1052628,          10.
  14334,   -24.545454,   42.1052628,          10.
  14335,   -23.636364,   42.1052628,          10.
  14336,   -22.727272,   42.1052628,          10.
  14337,   -21.818182,   42.1052628,          10.
  14338,    -20.90909,   42.1052628,          10.
  14339,    -29.09091,   42.8947372,          10.
  14340,   -28.181818,   42.8947372,          10.
  14341,   -27.272728,   42.8947372,          10.
  14342,   -26.363636,   42.8947372,          10.
  14343,   -25.454546,   42.8947372,          10.
  14344,   -24.545454,   42.8947372,          10.
  14345,   -23.636364,   42.8947372,          10.
  14346,   -22.727272,   42.8947372,          10.
  14347,   -21.818182,   42.8947372,          10.
  14348,    -20.90909,   42.8947372,          10.
  14349,    -29.09091,   43.6842117,          10.
  14350,   -28.181818,   43.6842117,          10.
  14351,   -27.272728,   43.6842117,          10.
  14352,   -26.363636,   43.6842117,          10.
  14353,   -25.454546,   43.6842117,          10.
  14354,   -24.545454,   43.6842117,          10.
  14355,   -23.636364,   43.6842117,          10.
  14356,   -22.727272,   43.6842117,          10.
  14357,   -21.818182,   43.6842117,          10.
  14358,    -20.90909,   43.6842117,          10.
  14359,    -29.09091,   44.4736824,          10.
  14360,   -28.181818,   44.4736824,          10.
  14361,   -27.272728,   44.4736824,          10.
  14362,   -26.363636,   44.4736824,          10.
  14363,   -25.454546,   44.4736824,          10.
  14364,   -24.545454,   44.4736824,          10.
  14365,   -23.636364,   44.4736824,          10.
  14366,   -22.727272,   44.4736824,          10.
  14367,   -21.818182,   44.4736824,          10.
  14368,    -20.90909,   44.4736824,          10.
  14369,    -29.09091,   45.2631569,          10.
  14370,   -28.181818,   45.2631569,          10.
  14371,   -27.272728,   45.2631569,          10.
  14372,   -26.363636,   45.2631569,          10.
  14373,   -25.454546,   45.2631569,          10.
  14374,   -24.545454,   45.2631569,          10.
  14375,   -23.636364,   45.2631569,          10.
  14376,   -22.727272,   45.2631569,          10.
  14377,   -21.818182,   45.2631569,          10.
  14378,    -20.90909,   45.2631569,          10.
  14379,    -29.09091,   46.0526314,          10.
  14380,   -28.181818,   46.0526314,          10.
  14381,   -27.272728,   46.0526314,          10.
  14382,   -26.363636,   46.0526314,          10.
  14383,   -25.454546,   46.0526314,          10.
  14384,   -24.545454,   46.0526314,          10.
  14385,   -23.636364,   46.0526314,          10.
  14386,   -22.727272,   46.0526314,          10.
  14387,   -21.818182,   46.0526314,          10.
  14388,    -20.90909,   46.0526314,          10.
  14389,    -29.09091,   46.8421059,          10.
  14390,   -28.181818,   46.8421059,          10.
  14391,   -27.272728,   46.8421059,          10.
  14392,   -26.363636,   46.8421059,          10.
  14393,   -25.454546,   46.8421059,          10.
  14394,   -24.545454,   46.8421059,          10.
  14395,   -23.636364,   46.8421059,          10.
  14396,   -22.727272,   46.8421059,          10.
  14397,   -21.818182,   46.8421059,          10.
  14398,    -20.90909,   46.8421059,          10.
  14399,    -29.09091,   47.6315804,          10.
  14400,   -28.181818,   47.6315804,          10.
  14401,   -27.272728,   47.6315804,          10.
  14402,   -26.363636,   47.6315804,          10.
  14403,   -25.454546,   47.6315804,          10.
  14404,   -24.545454,   47.6315804,          10.
  14405,   -23.636364,   47.6315804,          10.
  14406,   -22.727272,   47.6315804,          10.
  14407,   -21.818182,   47.6315804,          10.
  14408,    -20.90909,   47.6315804,          10.
  14409,    -29.09091,    48.421051,          10.
  14410,   -28.181818,    48.421051,          10.
  14411,   -27.272728,    48.421051,          10.
  14412,   -26.363636,    48.421051,          10.
  14413,   -25.454546,    48.421051,          10.
  14414,   -24.545454,    48.421051,          10.
  14415,   -23.636364,    48.421051,          10.
  14416,   -22.727272,    48.421051,          10.
  14417,   -21.818182,    48.421051,          10.
  14418,    -20.90909,    48.421051,          10.
  14419,    -29.09091,   49.2105255,          10.
  14420,   -28.181818,   49.2105255,          10.
  14421,   -27.272728,   49.2105255,          10.
  14422,   -26.363636,   49.2105255,          10.
  14423,   -25.454546,   49.2105255,          10.
  14424,   -24.545454,   49.2105255,          10.
  14425,   -23.636364,   49.2105255,          10.
  14426,   -22.727272,   49.2105255,          10.
  14427,   -21.818182,   49.2105255,          10.
  14428,    -20.90909,   49.2105255,          10.
  14429,         -30.,   20.7211208,  0.909090936
  14430,         -30.,   21.4422417,  0.909090936
  14431,         -30.,   22.1633625,  0.909090936
  14432,         -30.,   22.8844833,  0.909090936
  14433,         -30.,   23.6056042,  0.909090936
  14434,         -30.,    24.326725,  0.909090936
  14435,         -30.,   25.0478477,  0.909090936
  14436,         -30.,   25.8468895,  0.909090936
  14437,         -30.,   26.6459332,  0.909090936
  14438,         -30.,   27.4449768,  0.909090936
  14439,         -30.,   28.2440186,  0.909090936
  14440,         -30.,   29.0430622,  0.909090936
  14441,         -30.,   29.8421059,  0.909090936
  14442,         -30.,   30.6411476,  0.909090936
  14443,         -30.,   31.4401913,  0.909090936
  14444,         -30.,   32.2392349,  0.909090936
  14445,         -30.,   33.0382767,  0.909090936
  14446,         -30.,   33.8373222,  0.909090936
  14447,         -30.,    34.636364,  0.909090936
  14448,         -30.,   35.4354057,  0.909090936
  14449,         -30.,   36.2344513,  0.909090936
  14450,         -30.,    37.033493,  0.909090936
  14451,         -30.,   37.8325348,  0.909090936
  14452,         -30.,   38.6315804,  0.909090936
  14453,         -30.,   39.4306221,  0.909090936
  14454,         -30.,   40.2296638,  0.909090936
  14455,         -30.,   41.0287094,  0.909090936
  14456,         -30.,   41.8277512,  0.909090936
  14457,         -30.,   42.6267929,  0.909090936
  14458,         -30.,   43.4258385,  0.909090936
  14459,         -30.,   44.2248802,  0.909090936
  14460,         -30.,    45.023922,  0.909090936
  14461,         -30.,   45.8532677,  0.909090936
  14462,         -30.,   46.6826172,  0.909090936
  14463,         -30.,   47.5119629,  0.909090936
  14464,         -30.,   48.3413086,  0.909090936
  14465,         -30.,   49.1706543,  0.909090936
  14466,         -30.,   20.7279568,   1.81818187
  14467,         -30.,   21.4559116,   1.81818187
  14468,         -30.,   22.1838684,   1.81818187
  14469,         -30.,   22.9118252,   1.81818187
  14470,         -30.,    23.639782,   1.81818187
  14471,         -30.,   24.3677368,   1.81818187
  14472,         -30.,   25.0956936,   1.81818187
  14473,         -30.,   25.8937798,   1.81818187
  14474,         -30.,   26.6918659,   1.81818187
  14475,         -30.,   27.4899521,   1.81818187
  14476,         -30.,   28.2880383,   1.81818187
  14477,         -30.,   29.0861244,   1.81818187
  14478,         -30.,   29.8842106,   1.81818187
  14479,         -30.,   30.6822968,   1.81818187
  14480,         -30.,   31.4803829,   1.81818187
  14481,         -30.,   32.2784691,   1.81818187
  14482,         -30.,   33.0765533,   1.81818187
  14483,         -30.,   33.8746414,   1.81818187
  14484,         -30.,   34.6727257,   1.81818187
  14485,         -30.,   35.4708138,   1.81818187
  14486,         -30.,    36.268898,   1.81818187
  14487,         -30.,   37.0669861,   1.81818187
  14488,         -30.,   37.8650703,   1.81818187
  14489,         -30.,   38.6631584,   1.81818187
  14490,         -30.,   39.4612427,   1.81818187
  14491,         -30.,   40.2593307,   1.81818187
  14492,         -30.,    41.057415,   1.81818187
  14493,         -30.,   41.8555031,   1.81818187
  14494,         -30.,   42.6535873,   1.81818187
  14495,         -30.,   43.4516754,   1.81818187
  14496,         -30.,   44.2497597,   1.81818187
  14497,         -30.,   45.0478477,   1.81818187
  14498,         -30.,   45.8732071,   1.81818187
  14499,         -30.,   46.6985664,   1.81818187
  14500,         -30.,    47.523922,   1.81818187
  14501,         -30.,   48.3492813,   1.81818187
  14502,         -30.,   49.1746407,   1.81818187
  14503,         -30.,   20.7347908,   2.72727275
  14504,         -30.,   21.4695835,   2.72727275
  14505,         -30.,   22.2043743,   2.72727275
  14506,         -30.,    22.939167,   2.72727275
  14507,         -30.,   23.6739578,   2.72727275
  14508,         -30.,   24.4087486,   2.72727275
  14509,         -30.,   25.1435413,   2.72727275
  14510,         -30.,     25.94067,   2.72727275
  14511,         -30.,   26.7377987,   2.72727275
  14512,         -30.,   27.5349274,   2.72727275
  14513,         -30.,    28.332058,   2.72727275
  14514,         -30.,   29.1291866,   2.72727275
  14515,         -30.,   29.9263153,   2.72727275
  14516,         -30.,   30.7234459,   2.72727275
  14517,         -30.,   31.5205746,   2.72727275
  14518,         -30.,   32.3177032,   2.72727275
  14519,         -30.,   33.1148338,   2.72727275
  14520,         -30.,   33.9119606,   2.72727275
  14521,         -30.,   34.7090912,   2.72727275
  14522,         -30.,   35.5062218,   2.72727275
  14523,         -30.,   36.3033485,   2.72727275
  14524,         -30.,   37.1004791,   2.72727275
  14525,         -30.,   37.8976059,   2.72727275
  14526,         -30.,   38.6947365,   2.72727275
  14527,         -30.,   39.4918671,   2.72727275
  14528,         -30.,   40.2889938,   2.72727275
  14529,         -30.,   41.0861244,   2.72727275
  14530,         -30.,    41.883255,   2.72727275
  14531,         -30.,   42.6803818,   2.72727275
  14532,         -30.,   43.4775124,   2.72727275
  14533,         -30.,   44.2746429,   2.72727275
  14534,         -30.,   45.0717697,   2.72727275
  14535,         -30.,   45.8931427,   2.72727275
  14536,         -30.,   46.7145119,   2.72727275
  14537,         -30.,   47.5358849,   2.72727275
  14538,         -30.,   48.3572578,   2.72727275
  14539,         -30.,    49.178627,   2.72727275
  14540,         -30.,   20.7416267,   3.63636374
  14541,         -30.,   21.4832535,   3.63636374
  14542,         -30.,   22.2248802,   3.63636374
  14543,         -30.,    22.966507,   3.63636374
  14544,         -30.,   23.7081337,   3.63636374
  14545,         -30.,   24.4497604,   3.63636374
  14546,         -30.,   25.1913872,   3.63636374
  14547,         -30.,   25.9875603,   3.63636374
  14548,         -30.,   26.7837315,   3.63636374
  14549,         -30.,   27.5799046,   3.63636374
  14550,         -30.,   28.3760757,   3.63636374
  14551,         -30.,   29.1722488,   3.63636374
  14552,         -30.,   29.9684219,   3.63636374
  14553,         -30.,   30.7645931,   3.63636374
  14554,         -30.,   31.5607662,   3.63636374
  14555,         -30.,   32.3569374,   3.63636374
  14556,         -30.,   33.1531105,   3.63636374
  14557,         -30.,   33.9492836,   3.63636374
  14558,         -30.,   34.7454529,   3.63636374
  14559,         -30.,    35.541626,   3.63636374
  14560,         -30.,   36.3377991,   3.63636374
  14561,         -30.,   37.1339722,   3.63636374
  14562,         -30.,   37.9301453,   3.63636374
  14563,         -30.,   38.7263145,   3.63636374
  14564,         -30.,   39.5224876,   3.63636374
  14565,         -30.,   40.3186607,   3.63636374
  14566,         -30.,   41.1148338,   3.63636374
  14567,         -30.,   41.9110031,   3.63636374
  14568,         -30.,   42.7071762,   3.63636374
  14569,         -30.,   43.5033493,   3.63636374
  14570,         -30.,   44.2995224,   3.63636374
  14571,         -30.,   45.0956955,   3.63636374
  14572,         -30.,   45.9130783,   3.63636374
  14573,         -30.,   46.7304611,   3.63636374
  14574,         -30.,   47.5478477,   3.63636374
  14575,         -30.,   48.3652306,   3.63636374
  14576,         -30.,   49.1826172,   3.63636374
  14577,         -30.,   20.7484627,    4.5454545
  14578,         -30.,   21.4969234,    4.5454545
  14579,         -30.,   22.2453861,    4.5454545
  14580,         -30.,   22.9938488,    4.5454545
  14581,         -30.,   23.7423096,    4.5454545
  14582,         -30.,   24.4907722,    4.5454545
  14583,         -30.,   25.2392349,    4.5454545
  14584,         -30.,   26.0344505,    4.5454545
  14585,         -30.,   26.8296642,    4.5454545
  14586,         -30.,   27.6248798,    4.5454545
  14587,         -30.,   28.4200954,    4.5454545
  14588,         -30.,   29.2153111,    4.5454545
  14589,         -30.,   30.0105267,    4.5454545
  14590,         -30.,   30.8057423,    4.5454545
  14591,         -30.,   31.6009579,    4.5454545
  14592,         -30.,   32.3961716,    4.5454545
  14593,         -30.,   33.1913872,    4.5454545
  14594,         -30.,   33.9866028,    4.5454545
  14595,         -30.,   34.7818184,    4.5454545
  14596,         -30.,    35.577034,    4.5454545
  14597,         -30.,   36.3722496,    4.5454545
  14598,         -30.,   37.1674652,    4.5454545
  14599,         -30.,   37.9626808,    4.5454545
  14600,         -30.,   38.7578964,    4.5454545
  14601,         -30.,   39.5531082,    4.5454545
  14602,         -30.,   40.3483238,    4.5454545
  14603,         -30.,   41.1435394,    4.5454545
  14604,         -30.,    41.938755,    4.5454545
  14605,         -30.,   42.7339706,    4.5454545
  14606,         -30.,   43.5291862,    4.5454545
  14607,         -30.,   44.3244019,    4.5454545
  14608,         -30.,   45.1196175,    4.5454545
  14609,         -30.,   45.9330139,    4.5454545
  14610,         -30.,   46.7464104,    4.5454545
  14611,         -30.,   47.5598068,    4.5454545
  14612,         -30.,   48.3732071,    4.5454545
  14613,         -30.,   49.1866035,    4.5454545
  14614,         -30.,   20.7552967,    5.4545455
  14615,         -30.,   21.5105953,    5.4545455
  14616,         -30.,    22.265892,    5.4545455
  14617,         -30.,   23.0211887,    5.4545455
  14618,         -30.,   23.7764874,    5.4545455
  14619,         -30.,   24.5317841,    5.4545455
  14620,         -30.,   25.2870808,    5.4545455
  14621,         -30.,   26.0813389,    5.4545455
  14622,         -30.,   26.8755989,    5.4545455
  14623,         -30.,    27.669857,    5.4545455
  14624,         -30.,   28.4641151,    5.4545455
  14625,         -30.,   29.2583733,    5.4545455
  14626,         -30.,   30.0526314,    5.4545455
  14627,         -30.,   30.8468895,    5.4545455
  14628,         -30.,   31.6411476,    5.4545455
  14629,         -30.,   32.4354057,    5.4545455
  14630,         -30.,   33.2296638,    5.4545455
  14631,         -30.,    34.023922,    5.4545455
  14632,         -30.,   34.8181801,    5.4545455
  14633,         -30.,    35.612442,    5.4545455
  14634,         -30.,   36.4067001,    5.4545455
  14635,         -30.,   37.2009583,    5.4545455
  14636,         -30.,   37.9952164,    5.4545455
  14637,         -30.,   38.7894745,    5.4545455
  14638,         -30.,   39.5837326,    5.4545455
  14639,         -30.,   40.3779907,    5.4545455
  14640,         -30.,   41.1722488,    5.4545455
  14641,         -30.,    41.966507,    5.4545455
  14642,         -30.,   42.7607651,    5.4545455
  14643,         -30.,   43.5550232,    5.4545455
  14644,         -30.,   44.3492813,    5.4545455
  14645,         -30.,   45.1435394,    5.4545455
  14646,         -30.,   45.9529495,    5.4545455
  14647,         -30.,   46.7623596,    5.4545455
  14648,         -30.,   47.5717697,    5.4545455
  14649,         -30.,   48.3811798,    5.4545455
  14650,         -30.,   49.1905899,    5.4545455
  14651,         -30.,   20.7621326,   6.36363649
  14652,         -30.,   21.5242653,   6.36363649
  14653,         -30.,   22.2863979,   6.36363649
  14654,         -30.,   23.0485306,   6.36363649
  14655,         -30.,   23.8106632,   6.36363649
  14656,         -30.,   24.5727959,   6.36363649
  14657,         -30.,   25.3349285,   6.36363649
  14658,         -30.,   26.1282291,   6.36363649
  14659,         -30.,   26.9215317,   6.36363649
  14660,         -30.,   27.7148323,   6.36363649
  14661,         -30.,   28.5081348,   6.36363649
  14662,         -30.,   29.3014355,   6.36363649
  14663,         -30.,   30.0947361,   6.36363649
  14664,         -30.,   30.8880386,   6.36363649
  14665,         -30.,   31.6813393,   6.36363649
  14666,         -30.,   32.4746399,   6.36363649
  14667,         -30.,   33.2679443,   6.36363649
  14668,         -30.,    34.061245,   6.36363649
  14669,         -30.,   34.8545456,   6.36363649
  14670,         -30.,   35.6478462,   6.36363649
  14671,         -30.,   36.4411469,   6.36363649
  14672,         -30.,   37.2344513,   6.36363649
  14673,         -30.,   38.0277519,   6.36363649
  14674,         -30.,   38.8210526,   6.36363649
  14675,         -30.,   39.6143532,   6.36363649
  14676,         -30.,   40.4076538,   6.36363649
  14677,         -30.,   41.2009583,   6.36363649
  14678,         -30.,   41.9942589,   6.36363649
  14679,         -30.,   42.7875595,   6.36363649
  14680,         -30.,   43.5808601,   6.36363649
  14681,         -30.,   44.3741646,   6.36363649
  14682,         -30.,   45.1674652,   6.36363649
  14683,         -30.,   45.9728851,   6.36363649
  14684,         -30.,   46.7783089,   6.36363649
  14685,         -30.,   47.5837326,   6.36363649
  14686,         -30.,   48.3891563,   6.36363649
  14687,         -30.,   49.1945763,   6.36363649
  14688,         -30.,   20.7689686,   7.27272749
  14689,         -30.,   21.5379353,   7.27272749
  14690,         -30.,   22.3069038,   7.27272749
  14691,         -30.,   23.0758724,   7.27272749
  14692,         -30.,   23.8448391,   7.27272749
  14693,         -30.,   24.6138077,   7.27272749
  14694,         -30.,   25.3827744,   7.27272749
  14695,         -30.,   26.1751194,   7.27272749
  14696,         -30.,   26.9674644,   7.27272749
  14697,         -30.,   27.7598095,   7.27272749
  14698,         -30.,   28.5521526,   7.27272749
  14699,         -30.,   29.3444977,   7.27272749
  14700,         -30.,   30.1368427,   7.27272749
  14701,         -30.,   30.9291859,   7.27272749
  14702,         -30.,   31.7215309,   7.27272749
  14703,         -30.,   32.5138741,   7.27272749
  14704,         -30.,    33.306221,   7.27272749
  14705,         -30.,   34.0985641,   7.27272749
  14706,         -30.,   34.8909073,   7.27272749
  14707,         -30.,   35.6832542,   7.27272749
  14708,         -30.,   36.4755974,   7.27272749
  14709,         -30.,   37.2679443,   7.27272749
  14710,         -30.,   38.0602875,   7.27272749
  14711,         -30.,   38.8526306,   7.27272749
  14712,         -30.,   39.6449776,   7.27272749
  14713,         -30.,   40.4373207,   7.27272749
  14714,         -30.,   41.2296638,   7.27272749
  14715,         -30.,   42.0220108,   7.27272749
  14716,         -30.,   42.8143539,   7.27272749
  14717,         -30.,   43.6066971,   7.27272749
  14718,         -30.,    44.399044,   7.27272749
  14719,         -30.,   45.1913872,   7.27272749
  14720,         -30.,   45.9928246,   7.27272749
  14721,         -30.,   46.7942581,   7.27272749
  14722,         -30.,   47.5956955,   7.27272749
  14723,         -30.,   48.3971291,   7.27272749
  14724,         -30.,   49.1985664,   7.27272749
  14725,         -30.,   20.7758026,   8.18181801
  14726,         -30.,   21.5516071,   8.18181801
  14727,         -30.,   22.3274097,   8.18181801
  14728,         -30.,   23.1032124,   8.18181801
  14729,         -30.,    23.879015,   8.18181801
  14730,         -30.,   24.6548195,   8.18181801
  14731,         -30.,   25.4306221,   8.18181801
  14732,         -30.,   26.2220097,   8.18181801
  14733,         -30.,   27.0133972,   8.18181801
  14734,         -30.,   27.8047848,   8.18181801
  14735,         -30.,   28.5961723,   8.18181801
  14736,         -30.,   29.3875599,   8.18181801
  14737,         -30.,   30.1789474,   8.18181801
  14738,         -30.,    30.970335,   8.18181801
  14739,         -30.,   31.7617226,   8.18181801
  14740,         -30.,   32.5531082,   8.18181801
  14741,         -30.,   33.3444977,   8.18181801
  14742,         -30.,   34.1358833,   8.18181801
  14743,         -30.,   34.9272728,   8.18181801
  14744,         -30.,   35.7186584,   8.18181801
  14745,         -30.,   36.5100479,   8.18181801
  14746,         -30.,   37.3014336,   8.18181801
  14747,         -30.,    38.092823,   8.18181801
  14748,         -30.,   38.8842087,   8.18181801
  14749,         -30.,   39.6755981,   8.18181801
  14750,         -30.,   40.4669838,   8.18181801
  14751,         -30.,   41.2583733,   8.18181801
  14752,         -30.,   42.0497589,   8.18181801
  14753,         -30.,   42.8411484,   8.18181801
  14754,         -30.,    43.632534,   8.18181801
  14755,         -30.,   44.4239235,   8.18181801
  14756,         -30.,   45.2153091,   8.18181801
  14757,         -30.,   46.0127602,   8.18181801
  14758,         -30.,   46.8102074,   8.18181801
  14759,         -30.,   47.6076546,   8.18181801
  14760,         -30.,   48.4051018,   8.18181801
  14761,         -30.,   49.2025528,   8.18181801
  14762,         -30.,   20.7826385,     9.090909
  14763,         -30.,   21.5652771,     9.090909
  14764,         -30.,   22.3479156,     9.090909
  14765,         -30.,   23.1305542,     9.090909
  14766,         -30.,   23.9131927,     9.090909
  14767,         -30.,   24.6958313,     9.090909
  14768,         -30.,   25.4784698,     9.090909
  14769,         -30.,   26.2688999,     9.090909
  14770,         -30.,     27.05933,     9.090909
  14771,         -30.,   27.8497601,     9.090909
  14772,         -30.,    28.640192,     9.090909
  14773,         -30.,   29.4306221,     9.090909
  14774,         -30.,   30.2210522,     9.090909
  14775,         -30.,   31.0114841,     9.090909
  14776,         -30.,   31.8019142,     9.090909
  14777,         -30.,   32.5923462,     9.090909
  14778,         -30.,   33.3827744,     9.090909
  14779,         -30.,   34.1732063,     9.090909
  14780,         -30.,   34.9636345,     9.090909
  14781,         -30.,   35.7540665,     9.090909
  14782,         -30.,   36.5444984,     9.090909
  14783,         -30.,   37.3349266,     9.090909
  14784,         -30.,   38.1253586,     9.090909
  14785,         -30.,   38.9157906,     9.090909
  14786,         -30.,   39.7062187,     9.090909
  14787,         -30.,   40.4966507,     9.090909
  14788,         -30.,   41.2870827,     9.090909
  14789,         -30.,   42.0775108,     9.090909
  14790,         -30.,   42.8679428,     9.090909
  14791,         -30.,   43.6583748,     9.090909
  14792,         -30.,   44.4488029,     9.090909
  14793,         -30.,   45.2392349,     9.090909
  14794,         -30.,   46.0326958,     9.090909
  14795,         -30.,   46.8261566,     9.090909
  14796,         -30.,   47.6196175,     9.090909
  14797,         -30.,   48.4130783,     9.090909
  14798,         -30.,   49.2065392,     9.090909
  14799,         -20.,   20.7211208,  0.909090936
  14800,         -20.,   21.4422417,  0.909090936
  14801,         -20.,   22.1633625,  0.909090936
  14802,         -20.,   22.8844833,  0.909090936
  14803,         -20.,   23.6056042,  0.909090936
  14804,         -20.,    24.326725,  0.909090936
  14805,         -20.,   25.0478477,  0.909090936
  14806,         -20.,   25.8468895,  0.909090936
  14807,         -20.,   26.6459332,  0.909090936
  14808,         -20.,   27.4449768,  0.909090936
  14809,         -20.,   28.2440186,  0.909090936
  14810,         -20.,   29.0430622,  0.909090936
  14811,         -20.,   29.8421059,  0.909090936
  14812,         -20.,   30.6411476,  0.909090936
  14813,         -20.,   31.4401913,  0.909090936
  14814,         -20.,   32.2392349,  0.909090936
  14815,         -20.,   33.0382767,  0.909090936
  14816,         -20.,   33.8373222,  0.909090936
  14817,         -20.,    34.636364,  0.909090936
  14818,         -20.,   35.4354057,  0.909090936
  14819,         -20.,   36.2344513,  0.909090936
  14820,         -20.,    37.033493,  0.909090936
  14821,         -20.,   37.8325348,  0.909090936
  14822,         -20.,   38.6315804,  0.909090936
  14823,         -20.,   39.4306221,  0.909090936
  14824,         -20.,   40.2296638,  0.909090936
  14825,         -20.,   41.0287094,  0.909090936
  14826,         -20.,   41.8277512,  0.909090936
  14827,         -20.,   42.6267929,  0.909090936
  14828,         -20.,   43.4258385,  0.909090936
  14829,         -20.,   44.2248802,  0.909090936
  14830,         -20.,    45.023922,  0.909090936
  14831,         -20.,   45.8532677,  0.909090936
  14832,         -20.,   46.6826172,  0.909090936
  14833,         -20.,   47.5119629,  0.909090936
  14834,         -20.,   48.3413086,  0.909090936
  14835,         -20.,   49.1706543,  0.909090936
  14836,         -20.,   20.7279568,   1.81818187
  14837,         -20.,   21.4559116,   1.81818187
  14838,         -20.,   22.1838684,   1.81818187
  14839,         -20.,   22.9118252,   1.81818187
  14840,         -20.,    23.639782,   1.81818187
  14841,         -20.,   24.3677368,   1.81818187
  14842,         -20.,   25.0956936,   1.81818187
  14843,         -20.,   25.8937798,   1.81818187
  14844,         -20.,   26.6918659,   1.81818187
  14845,         -20.,   27.4899521,   1.81818187
  14846,         -20.,   28.2880383,   1.81818187
  14847,         -20.,   29.0861244,   1.81818187
  14848,         -20.,   29.8842106,   1.81818187
  14849,         -20.,   30.6822968,   1.81818187
  14850,         -20.,   31.4803829,   1.81818187
  14851,         -20.,   32.2784691,   1.81818187
  14852,         -20.,   33.0765533,   1.81818187
  14853,         -20.,   33.8746414,   1.81818187
  14854,         -20.,   34.6727257,   1.81818187
  14855,         -20.,   35.4708138,   1.81818187
  14856,         -20.,    36.268898,   1.81818187
  14857,         -20.,   37.0669861,   1.81818187
  14858,         -20.,   37.8650703,   1.81818187
  14859,         -20.,   38.6631584,   1.81818187
  14860,         -20.,   39.4612427,   1.81818187
  14861,         -20.,   40.2593307,   1.81818187
  14862,         -20.,    41.057415,   1.81818187
  14863,         -20.,   41.8555031,   1.81818187
  14864,         -20.,   42.6535873,   1.81818187
  14865,         -20.,   43.4516754,   1.81818187
  14866,         -20.,   44.2497597,   1.81818187
  14867,         -20.,   45.0478477,   1.81818187
  14868,         -20.,   45.8732071,   1.81818187
  14869,         -20.,   46.6985664,   1.81818187
  14870,         -20.,    47.523922,   1.81818187
  14871,         -20.,   48.3492813,   1.81818187
  14872,         -20.,   49.1746407,   1.81818187
  14873,         -20.,   20.7347908,   2.72727275
  14874,         -20.,   21.4695835,   2.72727275
  14875,         -20.,   22.2043743,   2.72727275
  14876,         -20.,    22.939167,   2.72727275
  14877,         -20.,   23.6739578,   2.72727275
  14878,         -20.,   24.4087486,   2.72727275
  14879,         -20.,   25.1435413,   2.72727275
  14880,         -20.,     25.94067,   2.72727275
  14881,         -20.,   26.7377987,   2.72727275
  14882,         -20.,   27.5349274,   2.72727275
  14883,         -20.,    28.332058,   2.72727275
  14884,         -20.,   29.1291866,   2.72727275
  14885,         -20.,   29.9263153,   2.72727275
  14886,         -20.,   30.7234459,   2.72727275
  14887,         -20.,   31.5205746,   2.72727275
  14888,         -20.,   32.3177032,   2.72727275
  14889,         -20.,   33.1148338,   2.72727275
  14890,         -20.,   33.9119606,   2.72727275
  14891,         -20.,   34.7090912,   2.72727275
  14892,         -20.,   35.5062218,   2.72727275
  14893,         -20.,   36.3033485,   2.72727275
  14894,         -20.,   37.1004791,   2.72727275
  14895,         -20.,   37.8976059,   2.72727275
  14896,         -20.,   38.6947365,   2.72727275
  14897,         -20.,   39.4918671,   2.72727275
  14898,         -20.,   40.2889938,   2.72727275
  14899,         -20.,   41.0861244,   2.72727275
  14900,         -20.,    41.883255,   2.72727275
  14901,         -20.,   42.6803818,   2.72727275
  14902,         -20.,   43.4775124,   2.72727275
  14903,         -20.,   44.2746429,   2.72727275
  14904,         -20.,   45.0717697,   2.72727275
  14905,         -20.,   45.8931427,   2.72727275
  14906,         -20.,   46.7145119,   2.72727275
  14907,         -20.,   47.5358849,   2.72727275
  14908,         -20.,   48.3572578,   2.72727275
  14909,         -20.,    49.178627,   2.72727275
  14910,         -20.,   20.7416267,   3.63636374
  14911,         -20.,   21.4832535,   3.63636374
  14912,         -20.,   22.2248802,   3.63636374
  14913,         -20.,    22.966507,   3.63636374
  14914,         -20.,   23.7081337,   3.63636374
  14915,         -20.,   24.4497604,   3.63636374
  14916,         -20.,   25.1913872,   3.63636374
  14917,         -20.,   25.9875603,   3.63636374
  14918,         -20.,   26.7837315,   3.63636374
  14919,         -20.,   27.5799046,   3.63636374
  14920,         -20.,   28.3760757,   3.63636374
  14921,         -20.,   29.1722488,   3.63636374
  14922,         -20.,   29.9684219,   3.63636374
  14923,         -20.,   30.7645931,   3.63636374
  14924,         -20.,   31.5607662,   3.63636374
  14925,         -20.,   32.3569374,   3.63636374
  14926,         -20.,   33.1531105,   3.63636374
  14927,         -20.,   33.9492836,   3.63636374
  14928,         -20.,   34.7454529,   3.63636374
  14929,         -20.,    35.541626,   3.63636374
  14930,         -20.,   36.3377991,   3.63636374
  14931,         -20.,   37.1339722,   3.63636374
  14932,         -20.,   37.9301453,   3.63636374
  14933,         -20.,   38.7263145,   3.63636374
  14934,         -20.,   39.5224876,   3.63636374
  14935,         -20.,   40.3186607,   3.63636374
  14936,         -20.,   41.1148338,   3.63636374
  14937,         -20.,   41.9110031,   3.63636374
  14938,         -20.,   42.7071762,   3.63636374
  14939,         -20.,   43.5033493,   3.63636374
  14940,         -20.,   44.2995224,   3.63636374
  14941,         -20.,   45.0956955,   3.63636374
  14942,         -20.,   45.9130783,   3.63636374
  14943,         -20.,   46.7304611,   3.63636374
  14944,         -20.,   47.5478477,   3.63636374
  14945,         -20.,   48.3652306,   3.63636374
  14946,         -20.,   49.1826172,   3.63636374
  14947,         -20.,   20.7484627,    4.5454545
  14948,         -20.,   21.4969234,    4.5454545
  14949,         -20.,   22.2453861,    4.5454545
  14950,         -20.,   22.9938488,    4.5454545
  14951,         -20.,   23.7423096,    4.5454545
  14952,         -20.,   24.4907722,    4.5454545
  14953,         -20.,   25.2392349,    4.5454545
  14954,         -20.,   26.0344505,    4.5454545
  14955,         -20.,   26.8296642,    4.5454545
  14956,         -20.,   27.6248798,    4.5454545
  14957,         -20.,   28.4200954,    4.5454545
  14958,         -20.,   29.2153111,    4.5454545
  14959,         -20.,   30.0105267,    4.5454545
  14960,         -20.,   30.8057423,    4.5454545
  14961,         -20.,   31.6009579,    4.5454545
  14962,         -20.,   32.3961716,    4.5454545
  14963,         -20.,   33.1913872,    4.5454545
  14964,         -20.,   33.9866028,    4.5454545
  14965,         -20.,   34.7818184,    4.5454545
  14966,         -20.,    35.577034,    4.5454545
  14967,         -20.,   36.3722496,    4.5454545
  14968,         -20.,   37.1674652,    4.5454545
  14969,         -20.,   37.9626808,    4.5454545
  14970,         -20.,   38.7578964,    4.5454545
  14971,         -20.,   39.5531082,    4.5454545
  14972,         -20.,   40.3483238,    4.5454545
  14973,         -20.,   41.1435394,    4.5454545
  14974,         -20.,    41.938755,    4.5454545
  14975,         -20.,   42.7339706,    4.5454545
  14976,         -20.,   43.5291862,    4.5454545
  14977,         -20.,   44.3244019,    4.5454545
  14978,         -20.,   45.1196175,    4.5454545
  14979,         -20.,   45.9330139,    4.5454545
  14980,         -20.,   46.7464104,    4.5454545
  14981,         -20.,   47.5598068,    4.5454545
  14982,         -20.,   48.3732071,    4.5454545
  14983,         -20.,   49.1866035,    4.5454545
  14984,         -20.,   20.7552967,    5.4545455
  14985,         -20.,   21.5105953,    5.4545455
  14986,         -20.,    22.265892,    5.4545455
  14987,         -20.,   23.0211887,    5.4545455
  14988,         -20.,   23.7764874,    5.4545455
  14989,         -20.,   24.5317841,    5.4545455
  14990,         -20.,   25.2870808,    5.4545455
  14991,         -20.,   26.0813389,    5.4545455
  14992,         -20.,   26.8755989,    5.4545455
  14993,         -20.,    27.669857,    5.4545455
  14994,         -20.,   28.4641151,    5.4545455
  14995,         -20.,   29.2583733,    5.4545455
  14996,         -20.,   30.0526314,    5.4545455
  14997,         -20.,   30.8468895,    5.4545455
  14998,         -20.,   31.6411476,    5.4545455
  14999,         -20.,   32.4354057,    5.4545455
  15000,         -20.,   33.2296638,    5.4545455
  15001,         -20.,    34.023922,    5.4545455
  15002,         -20.,   34.8181801,    5.4545455
  15003,         -20.,    35.612442,    5.4545455
  15004,         -20.,   36.4067001,    5.4545455
  15005,         -20.,   37.2009583,    5.4545455
  15006,         -20.,   37.9952164,    5.4545455
  15007,         -20.,   38.7894745,    5.4545455
  15008,         -20.,   39.5837326,    5.4545455
  15009,         -20.,   40.3779907,    5.4545455
  15010,         -20.,   41.1722488,    5.4545455
  15011,         -20.,    41.966507,    5.4545455
  15012,         -20.,   42.7607651,    5.4545455
  15013,         -20.,   43.5550232,    5.4545455
  15014,         -20.,   44.3492813,    5.4545455
  15015,         -20.,   45.1435394,    5.4545455
  15016,         -20.,   45.9529495,    5.4545455
  15017,         -20.,   46.7623596,    5.4545455
  15018,         -20.,   47.5717697,    5.4545455
  15019,         -20.,   48.3811798,    5.4545455
  15020,         -20.,   49.1905899,    5.4545455
  15021,         -20.,   20.7621326,   6.36363649
  15022,         -20.,   21.5242653,   6.36363649
  15023,         -20.,   22.2863979,   6.36363649
  15024,         -20.,   23.0485306,   6.36363649
  15025,         -20.,   23.8106632,   6.36363649
  15026,         -20.,   24.5727959,   6.36363649
  15027,         -20.,   25.3349285,   6.36363649
  15028,         -20.,   26.1282291,   6.36363649
  15029,         -20.,   26.9215317,   6.36363649
  15030,         -20.,   27.7148323,   6.36363649
  15031,         -20.,   28.5081348,   6.36363649
  15032,         -20.,   29.3014355,   6.36363649
  15033,         -20.,   30.0947361,   6.36363649
  15034,         -20.,   30.8880386,   6.36363649
  15035,         -20.,   31.6813393,   6.36363649
  15036,         -20.,   32.4746399,   6.36363649
  15037,         -20.,   33.2679443,   6.36363649
  15038,         -20.,    34.061245,   6.36363649
  15039,         -20.,   34.8545456,   6.36363649
  15040,         -20.,   35.6478462,   6.36363649
  15041,         -20.,   36.4411469,   6.36363649
  15042,         -20.,   37.2344513,   6.36363649
  15043,         -20.,   38.0277519,   6.36363649
  15044,         -20.,   38.8210526,   6.36363649
  15045,         -20.,   39.6143532,   6.36363649
  15046,         -20.,   40.4076538,   6.36363649
  15047,         -20.,   41.2009583,   6.36363649
  15048,         -20.,   41.9942589,   6.36363649
  15049,         -20.,   42.7875595,   6.36363649
  15050,         -20.,   43.5808601,   6.36363649
  15051,         -20.,   44.3741646,   6.36363649
  15052,         -20.,   45.1674652,   6.36363649
  15053,         -20.,   45.9728851,   6.36363649
  15054,         -20.,   46.7783089,   6.36363649
  15055,         -20.,   47.5837326,   6.36363649
  15056,         -20.,   48.3891563,   6.36363649
  15057,         -20.,   49.1945763,   6.36363649
  15058,         -20.,   20.7689686,   7.27272749
  15059,         -20.,   21.5379353,   7.27272749
  15060,         -20.,   22.3069038,   7.27272749
  15061,         -20.,   23.0758724,   7.27272749
  15062,         -20.,   23.8448391,   7.27272749
  15063,         -20.,   24.6138077,   7.27272749
  15064,         -20.,   25.3827744,   7.27272749
  15065,         -20.,   26.1751194,   7.27272749
  15066,         -20.,   26.9674644,   7.27272749
  15067,         -20.,   27.7598095,   7.27272749
  15068,         -20.,   28.5521526,   7.27272749
  15069,         -20.,   29.3444977,   7.27272749
  15070,         -20.,   30.1368427,   7.27272749
  15071,         -20.,   30.9291859,   7.27272749
  15072,         -20.,   31.7215309,   7.27272749
  15073,         -20.,   32.5138741,   7.27272749
  15074,         -20.,    33.306221,   7.27272749
  15075,         -20.,   34.0985641,   7.27272749
  15076,         -20.,   34.8909073,   7.27272749
  15077,         -20.,   35.6832542,   7.27272749
  15078,         -20.,   36.4755974,   7.27272749
  15079,         -20.,   37.2679443,   7.27272749
  15080,         -20.,   38.0602875,   7.27272749
  15081,         -20.,   38.8526306,   7.27272749
  15082,         -20.,   39.6449776,   7.27272749
  15083,         -20.,   40.4373207,   7.27272749
  15084,         -20.,   41.2296638,   7.27272749
  15085,         -20.,   42.0220108,   7.27272749
  15086,         -20.,   42.8143539,   7.27272749
  15087,         -20.,   43.6066971,   7.27272749
  15088,         -20.,    44.399044,   7.27272749
  15089,         -20.,   45.1913872,   7.27272749
  15090,         -20.,   45.9928246,   7.27272749
  15091,         -20.,   46.7942581,   7.27272749
  15092,         -20.,   47.5956955,   7.27272749
  15093,         -20.,   48.3971291,   7.27272749
  15094,         -20.,   49.1985664,   7.27272749
  15095,         -20.,   20.7758026,   8.18181801
  15096,         -20.,   21.5516071,   8.18181801
  15097,         -20.,   22.3274097,   8.18181801
  15098,         -20.,   23.1032124,   8.18181801
  15099,         -20.,    23.879015,   8.18181801
  15100,         -20.,   24.6548195,   8.18181801
  15101,         -20.,   25.4306221,   8.18181801
  15102,         -20.,   26.2220097,   8.18181801
  15103,         -20.,   27.0133972,   8.18181801
  15104,         -20.,   27.8047848,   8.18181801
  15105,         -20.,   28.5961723,   8.18181801
  15106,         -20.,   29.3875599,   8.18181801
  15107,         -20.,   30.1789474,   8.18181801
  15108,         -20.,    30.970335,   8.18181801
  15109,         -20.,   31.7617226,   8.18181801
  15110,         -20.,   32.5531082,   8.18181801
  15111,         -20.,   33.3444977,   8.18181801
  15112,         -20.,   34.1358833,   8.18181801
  15113,         -20.,   34.9272728,   8.18181801
  15114,         -20.,   35.7186584,   8.18181801
  15115,         -20.,   36.5100479,   8.18181801
  15116,         -20.,   37.3014336,   8.18181801
  15117,         -20.,    38.092823,   8.18181801
  15118,         -20.,   38.8842087,   8.18181801
  15119,         -20.,   39.6755981,   8.18181801
  15120,         -20.,   40.4669838,   8.18181801
  15121,         -20.,   41.2583733,   8.18181801
  15122,         -20.,   42.0497589,   8.18181801
  15123,         -20.,   42.8411484,   8.18181801
  15124,         -20.,    43.632534,   8.18181801
  15125,         -20.,   44.4239235,   8.18181801
  15126,         -20.,   45.2153091,   8.18181801
  15127,         -20.,   46.0127602,   8.18181801
  15128,         -20.,   46.8102074,   8.18181801
  15129,         -20.,   47.6076546,   8.18181801
  15130,         -20.,   48.4051018,   8.18181801
  15131,         -20.,   49.2025528,   8.18181801
  15132,         -20.,   20.7826385,     9.090909
  15133,         -20.,   21.5652771,     9.090909
  15134,         -20.,   22.3479156,     9.090909
  15135,         -20.,   23.1305542,     9.090909
  15136,         -20.,   23.9131927,     9.090909
  15137,         -20.,   24.6958313,     9.090909
  15138,         -20.,   25.4784698,     9.090909
  15139,         -20.,   26.2688999,     9.090909
  15140,         -20.,     27.05933,     9.090909
  15141,         -20.,   27.8497601,     9.090909
  15142,         -20.,    28.640192,     9.090909
  15143,         -20.,   29.4306221,     9.090909
  15144,         -20.,   30.2210522,     9.090909
  15145,         -20.,   31.0114841,     9.090909
  15146,         -20.,   31.8019142,     9.090909
  15147,         -20.,   32.5923462,     9.090909
  15148,         -20.,   33.3827744,     9.090909
  15149,         -20.,   34.1732063,     9.090909
  15150,         -20.,   34.9636345,     9.090909
  15151,         -20.,   35.7540665,     9.090909
  15152,         -20.,   36.5444984,     9.090909
  15153,         -20.,   37.3349266,     9.090909
  15154,         -20.,   38.1253586,     9.090909
  15155,         -20.,   38.9157906,     9.090909
  15156,         -20.,   39.7062187,     9.090909
  15157,         -20.,   40.4966507,     9.090909
  15158,         -20.,   41.2870827,     9.090909
  15159,         -20.,   42.0775108,     9.090909
  15160,         -20.,   42.8679428,     9.090909
  15161,         -20.,   43.6583748,     9.090909
  15162,         -20.,   44.4488029,     9.090909
  15163,         -20.,   45.2392349,     9.090909
  15164,         -20.,   46.0326958,     9.090909
  15165,         -20.,   46.8261566,     9.090909
  15166,         -20.,   47.6196175,     9.090909
  15167,         -20.,   48.4130783,     9.090909
  15168,         -20.,   49.2065392,     9.090909
  15169,    -29.09091,          20.,  0.909090936
  15170,   -28.181818,          20.,  0.909090936
  15171,   -27.272728,          20.,  0.909090936
  15172,   -26.363636,          20.,  0.909090936
  15173,   -25.454546,          20.,  0.909090936
  15174,   -24.545454,          20.,  0.909090936
  15175,   -23.636364,          20.,  0.909090936
  15176,   -22.727272,          20.,  0.909090936
  15177,   -21.818182,          20.,  0.909090936
  15178,    -20.90909,          20.,  0.909090936
  15179,    -29.09091,          20.,   1.81818187
  15180,   -28.181818,          20.,   1.81818187
  15181,   -27.272728,          20.,   1.81818187
  15182,   -26.363636,          20.,   1.81818187
  15183,   -25.454546,          20.,   1.81818187
  15184,   -24.545454,          20.,   1.81818187
  15185,   -23.636364,          20.,   1.81818187
  15186,   -22.727272,          20.,   1.81818187
  15187,   -21.818182,          20.,   1.81818187
  15188,    -20.90909,          20.,   1.81818187
  15189,    -29.09091,          20.,   2.72727275
  15190,   -28.181818,          20.,   2.72727275
  15191,   -27.272728,          20.,   2.72727275
  15192,   -26.363636,          20.,   2.72727275
  15193,   -25.454546,          20.,   2.72727275
  15194,   -24.545454,          20.,   2.72727275
  15195,   -23.636364,          20.,   2.72727275
  15196,   -22.727272,          20.,   2.72727275
  15197,   -21.818182,          20.,   2.72727275
  15198,    -20.90909,          20.,   2.72727275
  15199,    -29.09091,          20.,   3.63636374
  15200,   -28.181818,          20.,   3.63636374
  15201,   -27.272728,          20.,   3.63636374
  15202,   -26.363636,          20.,   3.63636374
  15203,   -25.454546,          20.,   3.63636374
  15204,   -24.545454,          20.,   3.63636374
  15205,   -23.636364,          20.,   3.63636374
  15206,   -22.727272,          20.,   3.63636374
  15207,   -21.818182,          20.,   3.63636374
  15208,    -20.90909,          20.,   3.63636374
  15209,    -29.09091,          20.,    4.5454545
  15210,   -28.181818,          20.,    4.5454545
  15211,   -27.272728,          20.,    4.5454545
  15212,   -26.363636,          20.,    4.5454545
  15213,   -25.454546,          20.,    4.5454545
  15214,   -24.545454,          20.,    4.5454545
  15215,   -23.636364,          20.,    4.5454545
  15216,   -22.727272,          20.,    4.5454545
  15217,   -21.818182,          20.,    4.5454545
  15218,    -20.90909,          20.,    4.5454545
  15219,    -29.09091,          20.,    5.4545455
  15220,   -28.181818,          20.,    5.4545455
  15221,   -27.272728,          20.,    5.4545455
  15222,   -26.363636,          20.,    5.4545455
  15223,   -25.454546,          20.,    5.4545455
  15224,   -24.545454,          20.,    5.4545455
  15225,   -23.636364,          20.,    5.4545455
  15226,   -22.727272,          20.,    5.4545455
  15227,   -21.818182,          20.,    5.4545455
  15228,    -20.90909,          20.,    5.4545455
  15229,    -29.09091,          20.,   6.36363649
  15230,   -28.181818,          20.,   6.36363649
  15231,   -27.272728,          20.,   6.36363649
  15232,   -26.363636,          20.,   6.36363649
  15233,   -25.454546,          20.,   6.36363649
  15234,   -24.545454,          20.,   6.36363649
  15235,   -23.636364,          20.,   6.36363649
  15236,   -22.727272,          20.,   6.36363649
  15237,   -21.818182,          20.,   6.36363649
  15238,    -20.90909,          20.,   6.36363649
  15239,    -29.09091,          20.,   7.27272749
  15240,   -28.181818,          20.,   7.27272749
  15241,   -27.272728,          20.,   7.27272749
  15242,   -26.363636,          20.,   7.27272749
  15243,   -25.454546,          20.,   7.27272749
  15244,   -24.545454,          20.,   7.27272749
  15245,   -23.636364,          20.,   7.27272749
  15246,   -22.727272,          20.,   7.27272749
  15247,   -21.818182,          20.,   7.27272749
  15248,    -20.90909,          20.,   7.27272749
  15249,    -29.09091,          20.,   8.18181801
  15250,   -28.181818,          20.,   8.18181801
  15251,   -27.272728,          20.,   8.18181801
  15252,   -26.363636,          20.,   8.18181801
  15253,   -25.454546,          20.,   8.18181801
  15254,   -24.545454,          20.,   8.18181801
  15255,   -23.636364,          20.,   8.18181801
  15256,   -22.727272,          20.,   8.18181801
  15257,   -21.818182,          20.,   8.18181801
  15258,    -20.90909,          20.,   8.18181801
  15259,    -29.09091,          20.,     9.090909
  15260,   -28.181818,          20.,     9.090909
  15261,   -27.272728,          20.,     9.090909
  15262,   -26.363636,          20.,     9.090909
  15263,   -25.454546,          20.,     9.090909
  15264,   -24.545454,          20.,     9.090909
  15265,   -23.636364,          20.,     9.090909
  15266,   -22.727272,          20.,     9.090909
  15267,   -21.818182,          20.,     9.090909
  15268,    -20.90909,          20.,     9.090909
  15269,   -22.545454,          15.,    5.4545455
  15270,    -23.09091,          15.,    5.4545455
  15271,   -23.636364,          15.,    5.4545455
  15272,   -24.181818,          15.,    5.4545455
  15273,   -24.727272,          15.,    5.4545455
  15274,   -25.272728,          15.,    5.4545455
  15275,   -25.818182,          15.,    5.4545455
  15276,   -26.363636,          15.,    5.4545455
  15277,    -26.90909,          15.,    5.4545455
  15278,   -27.454546,          15.,    5.4545455
  15279,   -22.545454,          15.,     5.909091
  15280,    -23.09091,          15.,     5.909091
  15281,   -23.636364,          15.,     5.909091
  15282,   -24.181818,          15.,     5.909091
  15283,   -24.727272,          15.,     5.909091
  15284,   -25.272728,          15.,     5.909091
  15285,   -25.818182,          15.,     5.909091
  15286,   -26.363636,          15.,     5.909091
  15287,    -26.90909,          15.,     5.909091
  15288,   -27.454546,          15.,     5.909091
  15289,   -22.545454,          15.,   6.36363649
  15290,    -23.09091,          15.,   6.36363649
  15291,   -23.636364,          15.,   6.36363649
  15292,   -24.181818,          15.,   6.36363649
  15293,   -24.727272,          15.,   6.36363649
  15294,   -25.272728,          15.,   6.36363649
  15295,   -25.818182,          15.,   6.36363649
  15296,   -26.363636,          15.,   6.36363649
  15297,    -26.90909,          15.,   6.36363649
  15298,   -27.454546,          15.,   6.36363649
  15299,   -22.545454,          15.,   6.81818199
  15300,    -23.09091,          15.,   6.81818199
  15301,   -23.636364,          15.,   6.81818199
  15302,   -24.181818,          15.,   6.81818199
  15303,   -24.727272,          15.,   6.81818199
  15304,   -25.272728,          15.,   6.81818199
  15305,   -25.818182,          15.,   6.81818199
  15306,   -26.363636,          15.,   6.81818199
  15307,    -26.90909,          15.,   6.81818199
  15308,   -27.454546,          15.,   6.81818199
  15309,   -22.545454,          15.,   7.27272749
  15310,    -23.09091,          15.,   7.27272749
  15311,   -23.636364,          15.,   7.27272749
  15312,   -24.181818,          15.,   7.27272749
  15313,   -24.727272,          15.,   7.27272749
  15314,   -25.272728,          15.,   7.27272749
  15315,   -25.818182,          15.,   7.27272749
  15316,   -26.363636,          15.,   7.27272749
  15317,    -26.90909,          15.,   7.27272749
  15318,   -27.454546,          15.,   7.27272749
  15319,   -22.545454,          15.,   7.72727251
  15320,    -23.09091,          15.,   7.72727251
  15321,   -23.636364,          15.,   7.72727251
  15322,   -24.181818,          15.,   7.72727251
  15323,   -24.727272,          15.,   7.72727251
  15324,   -25.272728,          15.,   7.72727251
  15325,   -25.818182,          15.,   7.72727251
  15326,   -26.363636,          15.,   7.72727251
  15327,    -26.90909,          15.,   7.72727251
  15328,   -27.454546,          15.,   7.72727251
  15329,   -22.545454,          15.,   8.18181801
  15330,    -23.09091,          15.,   8.18181801
  15331,   -23.636364,          15.,   8.18181801
  15332,   -24.181818,          15.,   8.18181801
  15333,   -24.727272,          15.,   8.18181801
  15334,   -25.272728,          15.,   8.18181801
  15335,   -25.818182,          15.,   8.18181801
  15336,   -26.363636,          15.,   8.18181801
  15337,    -26.90909,          15.,   8.18181801
  15338,   -27.454546,          15.,   8.18181801
  15339,   -22.545454,          15.,   8.63636398
  15340,    -23.09091,          15.,   8.63636398
  15341,   -23.636364,          15.,   8.63636398
  15342,   -24.181818,          15.,   8.63636398
  15343,   -24.727272,          15.,   8.63636398
  15344,   -25.272728,          15.,   8.63636398
  15345,   -25.818182,          15.,   8.63636398
  15346,   -26.363636,          15.,   8.63636398
  15347,    -26.90909,          15.,   8.63636398
  15348,   -27.454546,          15.,   8.63636398
  15349,   -22.545454,          15.,     9.090909
  15350,    -23.09091,          15.,     9.090909
  15351,   -23.636364,          15.,     9.090909
  15352,   -24.181818,          15.,     9.090909
  15353,   -24.727272,          15.,     9.090909
  15354,   -25.272728,          15.,     9.090909
  15355,   -25.818182,          15.,     9.090909
  15356,   -26.363636,          15.,     9.090909
  15357,    -26.90909,          15.,     9.090909
  15358,   -27.454546,          15.,     9.090909
  15359,   -22.545454,          15.,   9.54545498
  15360,    -23.09091,          15.,   9.54545498
  15361,   -23.636364,          15.,   9.54545498
  15362,   -24.181818,          15.,   9.54545498
  15363,   -24.727272,          15.,   9.54545498
  15364,   -25.272728,          15.,   9.54545498
  15365,   -25.818182,          15.,   9.54545498
  15366,   -26.363636,          15.,   9.54545498
  15367,    -26.90909,          15.,   9.54545498
  15368,   -27.454546,          15.,   9.54545498
  15369,  -21.6346989,   15.9132519,   5.37313366
  15370,  -21.6462288,   15.8844271,    5.8358202
  15371,  -21.6577587,   15.8556013,   6.29850721
  15372,  -21.6692886,   15.8267765,   6.76119375
  15373,  -21.6808205,   15.7979507,   7.22388029
  15374,  -21.6923504,   15.7691259,   7.68656683
  15375,  -21.7038803,   15.7403011,   8.14925385
  15376,  -21.7154102,   15.7114754,   8.61194038
  15377,  -21.7269402,   15.6826506,   9.07462692
  15378,  -21.7384701,   15.6538248,   9.53731346
  15379,  -21.2801189,   16.7997017,   5.13026857
  15380,  -21.3021069,   16.7447319,   5.61724186
  15381,  -21.3240967,   16.6897602,   6.10421515
  15382,  -21.3460846,   16.6347904,   6.59118795
  15383,  -21.3680725,   16.5798206,   7.07816124
  15384,  -21.3900604,   16.5248508,   7.56513453
  15385,  -21.4120483,   16.4698811,   8.05210781
  15386,  -21.4340363,   16.4149113,   8.53908062
  15387,  -21.4560242,   16.3599396,   9.02605343
  15388,  -21.4780121,   16.3049698,   9.51302719
  15389,  -20.9472466,   17.6318855,   4.73041439
  15390,    -20.97752,   17.5561981,   5.25737286
  15391,  -21.0077972,   17.4805088,   5.78433132
  15392,  -21.0380726,   17.4048195,   6.31128979
  15393,  -21.0683479,   17.3291321,   6.83824873
  15394,  -21.0986233,   17.2534428,    7.3652072
  15395,  -21.1288986,   17.1777554,   7.89216566
  15396,   -21.159174,    17.102066,    8.4191246
  15397,  -21.1894493,   17.0263767,   8.94608307
  15398,  -21.2197247,   16.9506893,   9.47304153
  15399,  -20.6474648,     18.38134,   4.18216562
  15400,  -20.6827183,   18.2932053,   4.76394892
  15401,  -20.7179718,   18.2050724,   5.34573269
  15402,  -20.7532253,   18.1169376,   5.92751598
  15403,  -20.7884789,   18.0288048,   6.50929928
  15404,  -20.8237324,     17.94067,   7.09108305
  15405,  -20.8589859,   17.8525352,   7.67286634
  15406,  -20.8942394,   17.7644024,   8.25465012
  15407,   -20.929493,   17.6762676,   8.83643341
  15408,  -20.9647465,   17.5881348,   9.41821671
  15409,  -20.3924217,   19.0189476,    3.4998455
  15410,  -20.4281788,   18.9295521,   4.14986086
  15411,  -20.4639378,   18.8401566,   4.79987621
  15412,  -20.4996948,   18.7507629,   5.44989204
  15413,  -20.5354538,   18.6613674,    6.0999074
  15414,  -20.5712109,   18.5719738,   6.74992275
  15415,  -20.6069679,   18.4825783,   7.39993811
  15416,  -20.6427269,   18.3931847,   8.04995346
  15417,   -20.678484,   18.3037891,   8.69996929
  15418,   -20.714241,   18.2143955,   9.34998417
  15419,  -20.1934319,   19.5164204,   2.70527029
  15420,  -20.2240887,   19.4397793,    3.4347434
  15421,  -20.2547455,   19.3631363,   4.16421604
  15422,  -20.2854023,   19.2864952,   4.89368916
  15423,  -20.3160591,   19.2098522,   5.62316227
  15424,  -20.3467159,   19.1332111,   6.35263538
  15425,  -20.3773727,   19.0565681,   7.08210802
  15426,  -20.4080296,   18.9799271,   7.81158113
  15427,  -20.4386864,   18.9032841,   8.54105377
  15428,  -20.4693432,    18.826643,   9.27052689
  15429,  -20.0603409,   19.8491497,   1.82887173
  15430,  -20.0793056,   19.8017349,   2.64598465
  15431,  -20.0982723,   19.7543201,   3.46309733
  15432,  -20.1172371,   19.7069054,   4.28021002
  15433,  -20.1362038,   19.6594906,   5.09732294
  15434,  -20.1551704,   19.6120739,   5.91443586
  15435,  -20.1741371,   19.5646591,   6.73154879
  15436,  -20.1931019,   19.5172443,   7.54866171
  15437,  -20.2120686,   19.4698296,   8.36577415
  15438,  -20.2310333,   19.4224148,   9.18288708
  15439,  -28.3653011,   15.9132538,   5.37313318
  15440,  -28.3537712,    15.884429,    5.8358202
  15441,  -28.3422413,   15.8556032,   6.29850674
  15442,  -28.3307114,   15.8267775,   6.76119328
  15443,  -28.3191814,   15.7979527,   7.22387981
  15444,  -28.3076515,   15.7691269,   7.68656683
  15445,  -28.2961216,   15.7403021,   8.14925289
  15446,  -28.2845898,   15.7114763,   8.61194038
  15447,  -28.2730598,   15.6826506,   9.07462692
  15448,  -28.2615299,   15.6538258,   9.53731346
  15449,  -28.7198811,   16.7997017,    5.1302681
  15450,  -28.6978931,   16.7447319,   5.61724138
  15451,  -28.6759052,   16.6897621,   6.10421467
  15452,  -28.6539173,   16.6347923,   6.59118795
  15453,  -28.6319275,   16.5798206,   7.07816076
  15454,  -28.6099396,   16.5248508,   7.56513405
  15455,  -28.5879517,   16.4698811,   8.05210686
  15456,  -28.5659637,   16.4149113,   8.53908062
  15457,  -28.5439758,   16.3599396,   9.02605343
  15458,  -28.5219879,   16.3049698,   9.51302719
  15459,  -29.0527554,   17.6318874,   4.73041344
  15460,    -29.02248,   17.5561981,   5.25737238
  15461,  -28.9922028,   17.4805088,   5.78433084
  15462,  -28.9619293,   17.4048214,   6.31128931
  15463,  -28.9316521,   17.3291321,   6.83824825
  15464,  -28.9013767,   17.2534428,   7.36520672
  15465,  -28.8711014,   17.1777554,   7.89216518
  15466,   -28.840826,    17.102066,   8.41912365
  15467,  -28.8105507,   17.0263767,   8.94608307
  15468,  -28.7802753,   16.9506893,   9.47304153
  15469,  -29.3525352,     18.38134,   4.18216467
  15470,  -29.3172836,   18.2932072,   4.76394844
  15471,  -29.2820282,   18.2050724,   5.34573174
  15472,  -29.2467747,   18.1169376,   5.92751551
  15473,  -29.2115211,   18.0288048,    6.5092988
  15474,  -29.1762676,     17.94067,   7.09108257
  15475,  -29.1410141,   17.8525372,   7.67286587
  15476,  -29.1057606,   17.7644024,   8.25464916
  15477,   -29.070507,   17.6762676,   8.83643341
  15478,  -29.0352535,   17.5881348,   9.41821671
  15479,  -29.6075783,   19.0189476,   3.49984503
  15480,  -29.5718212,   18.9295521,   4.14986038
  15481,  -29.5360641,   18.8401585,   4.79987621
  15482,  -29.5003052,   18.7507629,   5.44989157
  15483,  -29.4645462,   18.6613674,   6.09990692
  15484,  -29.4287891,   18.5719738,   6.74992275
  15485,  -29.3930321,   18.4825783,   7.39993811
  15486,  -29.3572731,   18.3931847,   8.04995346
  15487,   -29.321516,   18.3037891,   8.69996929
  15488,   -29.285759,   18.2143955,   9.34998417
  15489,  -29.8065681,   19.5164204,   2.70527005
  15490,  -29.7759113,   19.4397793,   3.43474317
  15491,  -29.7452545,   19.3631363,   4.16421604
  15492,  -29.7145977,   19.2864952,   4.89368916
  15493,  -29.6839409,   19.2098522,   5.62316227
  15494,  -29.6532841,   19.1332111,   6.35263491
  15495,  -29.6226273,   19.0565681,   7.08210802
  15496,  -29.5919704,   18.9799271,   7.81158113
  15497,  -29.5613136,   18.9032841,   8.54105377
  15498,  -29.5306568,    18.826643,   9.27052689
  15499,  -29.9396591,   19.8491497,   1.82887173
  15500,  -29.9206944,   19.8017349,   2.64598465
  15501,  -29.9017277,   19.7543201,   3.46309733
  15502,  -29.8827629,   19.7069054,   4.28021002
  15503,  -29.8637962,   19.6594906,   5.09732294
  15504,  -29.8448296,   19.6120739,   5.91443586
  15505,  -29.8258629,   19.5646591,   6.73154879
  15506,  -29.8068981,   19.5172443,   7.54866171
  15507,  -29.7879314,   19.4698296,   8.36577415
  15508,  -29.7689667,   19.4224148,   9.18288708
  15509,  -22.2371387,   15.9420776,   4.91044712
  15510,  -22.8511086,   15.9420776,   4.91044712
  15511,  -23.4650764,   15.9420776,   4.91044712
  15512,  -24.0790462,   15.9420776,   4.91044712
  15513,  -24.6930161,   15.9420786,   4.91044664
  15514,  -25.3069859,   15.9420786,   4.91044664
  15515,  -25.9209538,   15.9420786,   4.91044664
  15516,  -26.5349236,   15.9420786,   4.91044664
  15517,  -27.1488934,   15.9420786,   4.91044664
  15518,  -27.7628632,   15.9420795,   4.91044664
  15519,  -21.9384708,   16.8546715,   4.64329576
  15520,  -22.6188107,   16.8546715,   4.64329576
  15521,  -23.2991505,   16.8546715,   4.64329576
  15522,  -23.9794903,   16.8546715,   4.64329576
  15523,  -24.6598301,   16.8546715,   4.64329576
  15524,  -25.3401699,   16.8546715,   4.64329576
  15525,  -26.0205097,   16.8546715,   4.64329576
  15526,  -26.7008495,   16.8546734,   4.64329481
  15527,  -27.3811893,   16.8546734,   4.64329481
  15528,  -28.0615292,   16.8546734,   4.64329481
  15529,  -21.6593399,   17.7075748,   4.20345545
  15530,  -22.4017086,   17.7075748,   4.20345545
  15531,  -23.1440773,   17.7075748,   4.20345545
  15532,   -23.886446,   17.7075748,   4.20345545
  15533,  -24.6288166,   17.7075748,   4.20345545
  15534,  -25.3711853,   17.7075748,   4.20345545
  15535,   -26.113554,   17.7075748,   4.20345545
  15536,  -26.8559227,   17.7075748,   4.20345545
  15537,  -27.5982914,   17.7075748,   4.20345545
  15538,   -28.340662,   17.7075748,   4.20345545
  15539,  -21.4099903,   18.4694729,   3.60038257
  15540,  -22.2077713,   18.4694748,   3.60038161
  15541,  -23.0055504,   18.4694748,   3.60038161
  15542,  -23.8033295,   18.4694748,   3.60038161
  15543,  -24.6011105,   18.4694748,   3.60038161
  15544,  -25.3988895,   18.4694748,   3.60038137
  15545,  -26.1966705,   18.4694748,   3.60038137
  15546,  -26.9944496,   18.4694748,   3.60038137
  15547,  -27.7922306,   18.4694748,   3.60038137
  15548,  -28.5900097,   18.4694748,   3.60038137
  15549,  -21.2009068,   19.1083412,   2.84982991
  15550,  -22.0451488,   19.1083412,   2.84982991
  15551,  -22.8893929,   19.1083412,   2.84982991
  15552,  -23.7336349,   19.1083412,   2.84982991
  15553,   -24.577879,   19.1083412,   2.84982991
  15554,   -25.422121,   19.1083412,   2.84982991
  15555,  -26.2663651,   19.1083412,   2.84982991
  15556,  -27.1106071,   19.1083412,   2.84982991
  15557,  -27.9548512,   19.1083412,   2.84982991
  15558,  -28.7990932,   19.1083412,   2.84982991
  15559,  -21.0422707,   19.5930634,   1.97579706
  15560,  -21.9217663,   19.5930634,   1.97579706
  15561,  -22.8012619,   19.5930634,   1.97579706
  15562,  -23.6807575,   19.5930634,   1.97579706
  15563,  -24.5602531,   19.5930634,   1.97579694
  15564,  -25.4397469,   19.5930634,   1.97579694
  15565,  -26.3192425,   19.5930634,   1.97579694
  15566,  -27.1987381,   19.5930634,   1.97579694
  15567,  -28.0782337,   19.5930634,   1.97579682
  15568,  -28.9577293,   19.5930634,   1.97579682
  15569,  -20.9429417,   19.8965645,   1.01175892
  15570,   -21.844511,   19.8965645,   1.01175892
  15571,  -22.7460785,   19.8965645,   1.01175892
  15572,  -23.6476479,   19.8965645,   1.01175892
  15573,  -24.5492153,   19.8965645,   1.01175892
  15574,  -25.4507847,   19.8965645,   1.01175892
  15575,  -26.3523521,   19.8965645,   1.01175892
  15576,  -27.2539215,   19.8965645,   1.01175892
  15577,   -28.155489,   19.8965645,   1.01175892
  15578,  -29.0570583,   19.8965645,   1.01175892
  15579,    -22.34091,       15.625,          10.
  15580,   -22.931818,       15.625,          10.
  15581,   -23.522728,       15.625,          10.
  15582,   -24.113636,       15.625,          10.
  15583,   -24.704546,       15.625,          10.
  15584,   -25.295454,       15.625,          10.
  15585,   -25.886364,       15.625,          10.
  15586,   -26.477272,       15.625,          10.
  15587,   -27.068182,       15.625,          10.
  15588,    -27.65909,       15.625,          10.
  15589,   -22.136364,        16.25,          10.
  15590,   -22.772728,        16.25,          10.
  15591,    -23.40909,        16.25,          10.
  15592,   -24.045454,        16.25,          10.
  15593,   -24.681818,        16.25,          10.
  15594,   -25.318182,        16.25,          10.
  15595,   -25.954546,        16.25,          10.
  15596,    -26.59091,        16.25,          10.
  15597,   -27.227272,        16.25,          10.
  15598,   -27.863636,        16.25,          10.
  15599,   -21.931818,       16.875,          10.
  15600,   -22.613636,       16.875,          10.
  15601,   -23.295454,       16.875,          10.
  15602,   -23.977272,       16.875,          10.
  15603,    -24.65909,       16.875,          10.
  15604,    -25.34091,       16.875,          10.
  15605,   -26.022728,       16.875,          10.
  15606,   -26.704546,       16.875,          10.
  15607,   -27.386364,       16.875,          10.
  15608,   -28.068182,       16.875,          10.
  15609,   -21.727272,         17.5,          10.
  15610,   -22.454546,         17.5,          10.
  15611,   -23.181818,         17.5,          10.
  15612,    -23.90909,         17.5,          10.
  15613,   -24.636364,         17.5,          10.
  15614,   -25.363636,         17.5,          10.
  15615,    -26.09091,         17.5,          10.
  15616,   -26.818182,         17.5,          10.
  15617,   -27.545454,         17.5,          10.
  15618,   -28.272728,         17.5,          10.
  15619,   -21.522728,       18.125,          10.
  15620,   -22.295454,       18.125,          10.
  15621,   -23.068182,       18.125,          10.
  15622,    -23.84091,       18.125,          10.
  15623,   -24.613636,       18.125,          10.
  15624,   -25.386364,       18.125,          10.
  15625,    -26.15909,       18.125,          10.
  15626,   -26.931818,       18.125,          10.
  15627,   -27.704546,       18.125,          10.
  15628,   -28.477272,       18.125,          10.
  15629,   -21.318182,        18.75,          10.
  15630,   -22.136364,        18.75,          10.
  15631,   -22.954546,        18.75,          10.
  15632,   -23.772728,        18.75,          10.
  15633,    -24.59091,        18.75,          10.
  15634,    -25.40909,        18.75,          10.
  15635,   -26.227272,        18.75,          10.
  15636,   -27.045454,        18.75,          10.
  15637,   -27.863636,        18.75,          10.
  15638,   -28.681818,        18.75,          10.
  15639,   -21.113636,       19.375,          10.
  15640,   -21.977272,       19.375,          10.
  15641,    -22.84091,       19.375,          10.
  15642,   -23.704546,       19.375,          10.
  15643,   -24.568182,       19.375,          10.
  15644,   -25.431818,       19.375,          10.
  15645,   -26.295454,       19.375,          10.
  15646,    -27.15909,       19.375,          10.
  15647,   -28.022728,       19.375,          10.
  15648,   -28.886364,       19.375,          10.
  15649,   29.7689667,   19.4224148,  -9.18288708
  15650,   29.7879314,   19.4698296,  -8.36577415
  15651,   29.8068981,   19.5172443,  -7.54866171
  15652,   29.8258629,   19.5646591,  -6.73154879
  15653,   29.8448296,   19.6120739,  -5.91443586
  15654,   29.8637962,   19.6594906,  -5.09732294
  15655,   29.8827629,   19.7069054,  -4.28021002
  15656,   29.9017277,   19.7543201,  -3.46309733
  15657,   29.9206944,   19.8017349,  -2.64598465
  15658,   29.9396591,   19.8491497,  -1.82887173
  15659,   29.5306568,    18.826643,  -9.27052689
  15660,   29.5613136,   18.9032841,  -8.54105377
  15661,   29.5919704,   18.9799271,  -7.81158113
  15662,   29.6226273,   19.0565681,  -7.08210802
  15663,   29.6532841,   19.1332111,  -6.35263491
  15664,   29.6839409,   19.2098522,  -5.62316227
  15665,   29.7145977,   19.2864952,  -4.89368916
  15666,   29.7452545,   19.3631363,  -4.16421604
  15667,   29.7759113,   19.4397793,  -3.43474317
  15668,   29.8065681,   19.5164204,  -2.70527005
  15669,    29.285759,   18.2143955,  -9.34998417
  15670,    29.321516,   18.3037891,  -8.69996929
  15671,   29.3572731,   18.3931847,  -8.04995346
  15672,   29.3930321,   18.4825783,  -7.39993811
  15673,   29.4287891,   18.5719738,  -6.74992275
  15674,   29.4645462,   18.6613674,  -6.09990692
  15675,   29.5003052,   18.7507629,  -5.44989157
  15676,   29.5360641,   18.8401585,  -4.79987621
  15677,   29.5718212,   18.9295521,  -4.14986038
  15678,   29.6075783,   19.0189476,  -3.49984503
  15679,   29.0352535,   17.5881348,  -9.41821671
  15680,    29.070507,   17.6762676,  -8.83643341
  15681,   29.1057606,   17.7644024,  -8.25464916
  15682,   29.1410141,   17.8525372,  -7.67286587
  15683,   29.1762676,     17.94067,  -7.09108257
  15684,   29.2115211,   18.0288048,   -6.5092988
  15685,   29.2467747,   18.1169376,  -5.92751551
  15686,   29.2820282,   18.2050724,  -5.34573174
  15687,   29.3172836,   18.2932072,  -4.76394844
  15688,   29.3525352,     18.38134,  -4.18216467
  15689,   28.7802753,   16.9506893,  -9.47304153
  15690,   28.8105507,   17.0263767,  -8.94608307
  15691,    28.840826,    17.102066,  -8.41912365
  15692,   28.8711014,   17.1777554,  -7.89216518
  15693,   28.9013767,   17.2534428,  -7.36520672
  15694,   28.9316521,   17.3291321,  -6.83824825
  15695,   28.9619293,   17.4048214,  -6.31128931
  15696,   28.9922028,   17.4805088,  -5.78433084
  15697,     29.02248,   17.5561981,  -5.25737238
  15698,   29.0527554,   17.6318874,  -4.73041344
  15699,   28.5219879,   16.3049698,  -9.51302719
  15700,   28.5439758,   16.3599396,  -9.02605343
  15701,   28.5659637,   16.4149113,  -8.53908062
  15702,   28.5879517,   16.4698811,  -8.05210686
  15703,   28.6099396,   16.5248508,  -7.56513405
  15704,   28.6319275,   16.5798206,  -7.07816076
  15705,   28.6539173,   16.6347923,  -6.59118795
  15706,   28.6759052,   16.6897621,  -6.10421467
  15707,   28.6978931,   16.7447319,  -5.61724138
  15708,   28.7198811,   16.7997017,   -5.1302681
  15709,   28.2615299,   15.6538258,  -9.53731346
  15710,   28.2730598,   15.6826506,  -9.07462692
  15711,   28.2845898,   15.7114763,  -8.61194038
  15712,   28.2961216,   15.7403021,  -8.14925289
  15713,   28.3076515,   15.7691269,  -7.68656683
  15714,   28.3191814,   15.7979527,  -7.22387981
  15715,   28.3307114,   15.8267775,  -6.76119328
  15716,   28.3422413,   15.8556032,  -6.29850674
  15717,   28.3537712,    15.884429,   -5.8358202
  15718,   28.3653011,   15.9132538,  -5.37313318
  15719,   20.2310333,   19.4224148,  -9.18288708
  15720,   20.2120686,   19.4698296,  -8.36577415
  15721,   20.1931019,   19.5172443,  -7.54866171
  15722,   20.1741371,   19.5646591,  -6.73154879
  15723,   20.1551704,   19.6120739,  -5.91443586
  15724,   20.1362038,   19.6594906,  -5.09732294
  15725,   20.1172371,   19.7069054,  -4.28021002
  15726,   20.0982723,   19.7543201,  -3.46309733
  15727,   20.0793056,   19.8017349,  -2.64598465
  15728,   20.0603409,   19.8491497,  -1.82887173
  15729,   20.4693432,    18.826643,  -9.27052689
  15730,   20.4386864,   18.9032841,  -8.54105377
  15731,   20.4080296,   18.9799271,  -7.81158113
  15732,   20.3773727,   19.0565681,  -7.08210802
  15733,   20.3467159,   19.1332111,  -6.35263538
  15734,   20.3160591,   19.2098522,  -5.62316227
  15735,   20.2854023,   19.2864952,  -4.89368916
  15736,   20.2547455,   19.3631363,  -4.16421604
  15737,   20.2240887,   19.4397793,   -3.4347434
  15738,   20.1934319,   19.5164204,  -2.70527029
  15739,    20.714241,   18.2143955,  -9.34998417
  15740,    20.678484,   18.3037891,  -8.69996929
  15741,   20.6427269,   18.3931847,  -8.04995346
  15742,   20.6069679,   18.4825783,  -7.39993811
  15743,   20.5712109,   18.5719738,  -6.74992275
  15744,   20.5354538,   18.6613674,   -6.0999074
  15745,   20.4996948,   18.7507629,  -5.44989204
  15746,   20.4639378,   18.8401566,  -4.79987621
  15747,   20.4281788,   18.9295521,  -4.14986086
  15748,   20.3924217,   19.0189476,   -3.4998455
  15749,   20.9647465,   17.5881348,  -9.41821671
  15750,    20.929493,   17.6762676,  -8.83643341
  15751,   20.8942394,   17.7644024,  -8.25465012
  15752,   20.8589859,   17.8525352,  -7.67286634
  15753,   20.8237324,     17.94067,  -7.09108305
  15754,   20.7884789,   18.0288048,  -6.50929928
  15755,   20.7532253,   18.1169376,  -5.92751598
  15756,   20.7179718,   18.2050724,  -5.34573269
  15757,   20.6827183,   18.2932053,  -4.76394892
  15758,   20.6474648,     18.38134,  -4.18216562
  15759,   21.2197247,   16.9506893,  -9.47304153
  15760,   21.1894493,   17.0263767,  -8.94608307
  15761,    21.159174,    17.102066,   -8.4191246
  15762,   21.1288986,   17.1777554,  -7.89216566
  15763,   21.0986233,   17.2534428,   -7.3652072
  15764,   21.0683479,   17.3291321,  -6.83824873
  15765,   21.0380726,   17.4048195,  -6.31128979
  15766,   21.0077972,   17.4805088,  -5.78433132
  15767,     20.97752,   17.5561981,  -5.25737286
  15768,   20.9472466,   17.6318855,  -4.73041439
  15769,   21.4780121,   16.3049698,  -9.51302719
  15770,   21.4560242,   16.3599396,  -9.02605343
  15771,   21.4340363,   16.4149113,  -8.53908062
  15772,   21.4120483,   16.4698811,  -8.05210781
  15773,   21.3900604,   16.5248508,  -7.56513453
  15774,   21.3680725,   16.5798206,  -7.07816124
  15775,   21.3460846,   16.6347904,  -6.59118795
  15776,   21.3240967,   16.6897602,  -6.10421515
  15777,   21.3021069,   16.7447319,  -5.61724186
  15778,   21.2801189,   16.7997017,  -5.13026857
  15779,   21.7384701,   15.6538248,  -9.53731346
  15780,   21.7269402,   15.6826506,  -9.07462692
  15781,   21.7154102,   15.7114754,  -8.61194038
  15782,   21.7038803,   15.7403011,  -8.14925385
  15783,   21.6923504,   15.7691259,  -7.68656683
  15784,   21.6808205,   15.7979507,  -7.22388029
  15785,   21.6692886,   15.8267765,  -6.76119375
  15786,   21.6577587,   15.8556013,  -6.29850721
  15787,   21.6462288,   15.8844271,   -5.8358202
  15788,   21.6346989,   15.9132519,  -5.37313366
  15789,    28.886364,       19.375,         -10.
  15790,    28.681818,        18.75,         -10.
  15791,    28.477272,       18.125,         -10.
  15792,    28.272728,         17.5,         -10.
  15793,    28.068182,       16.875,         -10.
  15794,    27.863636,        16.25,         -10.
  15795,     27.65909,       15.625,         -10.
  15796,    28.022728,       19.375,         -10.
  15797,    27.863636,        18.75,         -10.
  15798,    27.704546,       18.125,         -10.
  15799,    27.545454,         17.5,         -10.
  15800,    27.386364,       16.875,         -10.
  15801,    27.227272,        16.25,         -10.
  15802,    27.068182,       15.625,         -10.
  15803,     27.15909,       19.375,         -10.
  15804,    27.045454,        18.75,         -10.
  15805,    26.931818,       18.125,         -10.
  15806,    26.818182,         17.5,         -10.
  15807,    26.704546,       16.875,         -10.
  15808,     26.59091,        16.25,         -10.
  15809,    26.477272,       15.625,         -10.
  15810,    26.295454,       19.375,         -10.
  15811,    26.227272,        18.75,         -10.
  15812,     26.15909,       18.125,         -10.
  15813,     26.09091,         17.5,         -10.
  15814,    26.022728,       16.875,         -10.
  15815,    25.954546,        16.25,         -10.
  15816,    25.886364,       15.625,         -10.
  15817,    25.431818,       19.375,         -10.
  15818,     25.40909,        18.75,         -10.
  15819,    25.386364,       18.125,         -10.
  15820,    25.363636,         17.5,         -10.
  15821,     25.34091,       16.875,         -10.
  15822,    25.318182,        16.25,         -10.
  15823,    25.295454,       15.625,         -10.
  15824,    24.568182,       19.375,         -10.
  15825,     24.59091,        18.75,         -10.
  15826,    24.613636,       18.125,         -10.
  15827,    24.636364,         17.5,         -10.
  15828,     24.65909,       16.875,         -10.
  15829,    24.681818,        16.25,         -10.
  15830,    24.704546,       15.625,         -10.
  15831,    23.704546,       19.375,         -10.
  15832,    23.772728,        18.75,         -10.
  15833,     23.84091,       18.125,         -10.
  15834,     23.90909,         17.5,         -10.
  15835,    23.977272,       16.875,         -10.
  15836,    24.045454,        16.25,         -10.
  15837,    24.113636,       15.625,         -10.
  15838,     22.84091,       19.375,         -10.
  15839,    22.954546,        18.75,         -10.
  15840,    23.068182,       18.125,         -10.
  15841,    23.181818,         17.5,         -10.
  15842,    23.295454,       16.875,         -10.
  15843,     23.40909,        16.25,         -10.
  15844,    23.522728,       15.625,         -10.
  15845,    21.977272,       19.375,         -10.
  15846,    22.136364,        18.75,         -10.
  15847,    22.295454,       18.125,         -10.
  15848,    22.454546,         17.5,         -10.
  15849,    22.613636,       16.875,         -10.
  15850,    22.772728,        16.25,         -10.
  15851,    22.931818,       15.625,         -10.
  15852,    21.113636,       19.375,         -10.
  15853,    21.318182,        18.75,         -10.
  15854,    21.522728,       18.125,         -10.
  15855,    21.727272,         17.5,         -10.
  15856,    21.931818,       16.875,         -10.
  15857,    22.136364,        16.25,         -10.
  15858,     22.34091,       15.625,         -10.
  15859,   29.0570583,   19.8965645,  -1.01175892
  15860,   28.9577293,   19.5930634,  -1.97579682
  15861,   28.7990932,   19.1083412,  -2.84982991
  15862,   28.5900097,   18.4694748,  -3.60038137
  15863,    28.340662,   17.7075748,  -4.20345545
  15864,   28.0615292,   16.8546734,  -4.64329481
  15865,   27.7628632,   15.9420795,  -4.91044664
  15866,    28.155489,   19.8965645,  -1.01175892
  15867,   28.0782337,   19.5930634,  -1.97579682
  15868,   27.9548512,   19.1083412,  -2.84982991
  15869,   27.7922306,   18.4694748,  -3.60038137
  15870,   27.5982914,   17.7075748,  -4.20345545
  15871,   27.3811893,   16.8546734,  -4.64329481
  15872,   27.1488934,   15.9420786,  -4.91044664
  15873,   27.2539215,   19.8965645,  -1.01175892
  15874,   27.1987381,   19.5930634,  -1.97579694
  15875,   27.1106071,   19.1083412,  -2.84982991
  15876,   26.9944496,   18.4694748,  -3.60038137
  15877,   26.8559227,   17.7075748,  -4.20345545
  15878,   26.7008495,   16.8546734,  -4.64329481
  15879,   26.5349236,   15.9420786,  -4.91044664
  15880,   26.3523521,   19.8965645,  -1.01175892
  15881,   26.3192425,   19.5930634,  -1.97579694
  15882,   26.2663651,   19.1083412,  -2.84982991
  15883,   26.1966705,   18.4694748,  -3.60038137
  15884,    26.113554,   17.7075748,  -4.20345545
  15885,   26.0205097,   16.8546715,  -4.64329576
  15886,   25.9209538,   15.9420786,  -4.91044664
  15887,   25.4507847,   19.8965645,  -1.01175892
  15888,   25.4397469,   19.5930634,  -1.97579694
  15889,    25.422121,   19.1083412,  -2.84982991
  15890,   25.3988895,   18.4694748,  -3.60038137
  15891,   25.3711853,   17.7075748,  -4.20345545
  15892,   25.3401699,   16.8546715,  -4.64329576
  15893,   25.3069859,   15.9420786,  -4.91044664
  15894,   24.5492153,   19.8965645,  -1.01175892
  15895,   24.5602531,   19.5930634,  -1.97579694
  15896,    24.577879,   19.1083412,  -2.84982991
  15897,   24.6011105,   18.4694748,  -3.60038161
  15898,   24.6288166,   17.7075748,  -4.20345545
  15899,   24.6598301,   16.8546715,  -4.64329576
  15900,   24.6930161,   15.9420786,  -4.91044664
  15901,   23.6476479,   19.8965645,  -1.01175892
  15902,   23.6807575,   19.5930634,  -1.97579706
  15903,   23.7336349,   19.1083412,  -2.84982991
  15904,   23.8033295,   18.4694748,  -3.60038161
  15905,    23.886446,   17.7075748,  -4.20345545
  15906,   23.9794903,   16.8546715,  -4.64329576
  15907,   24.0790462,   15.9420776,  -4.91044712
  15908,   22.7460785,   19.8965645,  -1.01175892
  15909,   22.8012619,   19.5930634,  -1.97579706
  15910,   22.8893929,   19.1083412,  -2.84982991
  15911,   23.0055504,   18.4694748,  -3.60038161
  15912,   23.1440773,   17.7075748,  -4.20345545
  15913,   23.2991505,   16.8546715,  -4.64329576
  15914,   23.4650764,   15.9420776,  -4.91044712
  15915,    21.844511,   19.8965645,  -1.01175892
  15916,   21.9217663,   19.5930634,  -1.97579706
  15917,   22.0451488,   19.1083412,  -2.84982991
  15918,   22.2077713,   18.4694748,  -3.60038161
  15919,   22.4017086,   17.7075748,  -4.20345545
  15920,   22.6188107,   16.8546715,  -4.64329576
  15921,   22.8511086,   15.9420776,  -4.91044712
  15922,   20.9429417,   19.8965645,  -1.01175892
  15923,   21.0422707,   19.5930634,  -1.97579706
  15924,   21.2009068,   19.1083412,  -2.84982991
  15925,   21.4099903,   18.4694729,  -3.60038257
  15926,   21.6593399,   17.7075748,  -4.20345545
  15927,   21.9384708,   16.8546715,  -4.64329576
  15928,   22.2371387,   15.9420776,  -4.91044712
  15929,    27.454546,          15.,  -9.54545498
  15930,    27.454546,          15.,    -9.090909
  15931,    27.454546,          15.,  -8.63636398
  15932,    27.454546,          15.,  -8.18181801
  15933,    27.454546,          15.,  -7.72727251
  15934,    27.454546,          15.,  -7.27272749
  15935,    27.454546,          15.,  -6.81818199
  15936,    27.454546,          15.,  -6.36363649
  15937,    27.454546,          15.,    -5.909091
  15938,    27.454546,          15.,   -5.4545455
  15939,     26.90909,          15.,  -9.54545498
  15940,     26.90909,          15.,    -9.090909
  15941,     26.90909,          15.,  -8.63636398
  15942,     26.90909,          15.,  -8.18181801
  15943,     26.90909,          15.,  -7.72727251
  15944,     26.90909,          15.,  -7.27272749
  15945,     26.90909,          15.,  -6.81818199
  15946,     26.90909,          15.,  -6.36363649
  15947,     26.90909,          15.,    -5.909091
  15948,     26.90909,          15.,   -5.4545455
  15949,    26.363636,          15.,  -9.54545498
  15950,    26.363636,          15.,    -9.090909
  15951,    26.363636,          15.,  -8.63636398
  15952,    26.363636,          15.,  -8.18181801
  15953,    26.363636,          15.,  -7.72727251
  15954,    26.363636,          15.,  -7.27272749
  15955,    26.363636,          15.,  -6.81818199
  15956,    26.363636,          15.,  -6.36363649
  15957,    26.363636,          15.,    -5.909091
  15958,    26.363636,          15.,   -5.4545455
  15959,    25.818182,          15.,  -9.54545498
  15960,    25.818182,          15.,    -9.090909
  15961,    25.818182,          15.,  -8.63636398
  15962,    25.818182,          15.,  -8.18181801
  15963,    25.818182,          15.,  -7.72727251
  15964,    25.818182,          15.,  -7.27272749
  15965,    25.818182,          15.,  -6.81818199
  15966,    25.818182,          15.,  -6.36363649
  15967,    25.818182,          15.,    -5.909091
  15968,    25.818182,          15.,   -5.4545455
  15969,    25.272728,          15.,  -9.54545498
  15970,    25.272728,          15.,    -9.090909
  15971,    25.272728,          15.,  -8.63636398
  15972,    25.272728,          15.,  -8.18181801
  15973,    25.272728,          15.,  -7.72727251
  15974,    25.272728,          15.,  -7.27272749
  15975,    25.272728,          15.,  -6.81818199
  15976,    25.272728,          15.,  -6.36363649
  15977,    25.272728,          15.,    -5.909091
  15978,    25.272728,          15.,   -5.4545455
  15979,    24.727272,          15.,  -9.54545498
  15980,    24.727272,          15.,    -9.090909
  15981,    24.727272,          15.,  -8.63636398
  15982,    24.727272,          15.,  -8.18181801
  15983,    24.727272,          15.,  -7.72727251
  15984,    24.727272,          15.,  -7.27272749
  15985,    24.727272,          15.,  -6.81818199
  15986,    24.727272,          15.,  -6.36363649
  15987,    24.727272,          15.,    -5.909091
  15988,    24.727272,          15.,   -5.4545455
  15989,    24.181818,          15.,  -9.54545498
  15990,    24.181818,          15.,    -9.090909
  15991,    24.181818,          15.,  -8.63636398
  15992,    24.181818,          15.,  -8.18181801
  15993,    24.181818,          15.,  -7.72727251
  15994,    24.181818,          15.,  -7.27272749
