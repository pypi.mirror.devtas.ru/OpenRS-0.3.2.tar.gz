  31995,  0.844996154,     76.35009,  -6.36363649
  31996,  0.874133945,   77.2587128,  -6.36363649
  31997,  0.903271675,   78.1673355,  -6.36363649
  31998,  0.932409465,   79.0759659,  -6.36363649
  31999,  0.670169413,   70.8983459,  -7.27272749
  32000,  0.699307203,   71.8069687,  -7.27272749
  32001,  0.728444934,   72.7155991,  -7.27272749
  32002,  0.757582724,   73.6242218,  -7.27272749
  32003,  0.786720514,   74.5328445,  -7.27272749
  32004,  0.815858364,   75.4414673,  -7.27272749
  32005,  0.844996154,     76.35009,  -7.27272749
  32006,  0.874133945,   77.2587128,  -7.27272749
  32007,  0.903271675,   78.1673355,  -7.27272749
  32008,  0.932409465,   79.0759659,  -7.27272749
  32009,  0.670169413,   70.8983459,  -8.18181801
  32010,  0.699307203,   71.8069687,  -8.18181801
  32011,  0.728444934,   72.7155991,  -8.18181801
  32012,  0.757582724,   73.6242218,  -8.18181801
  32013,  0.786720514,   74.5328445,  -8.18181801
  32014,  0.815858364,   75.4414673,  -8.18181801
  32015,  0.844996154,     76.35009,  -8.18181801
  32016,  0.874133945,   77.2587128,  -8.18181801
  32017,  0.903271675,   78.1673355,  -8.18181801
  32018,  0.932409465,   79.0759659,  -8.18181801
  32019,  0.670169413,   70.8983459,    -9.090909
  32020,  0.699307203,   71.8069687,    -9.090909
  32021,  0.728444934,   72.7155991,    -9.090909
  32022,  0.757582724,   73.6242218,    -9.090909
  32023,  0.786720514,   74.5328445,    -9.090909
  32024,  0.815858364,   75.4414673,    -9.090909
  32025,  0.844996154,     76.35009,    -9.090909
  32026,  0.874133945,   77.2587128,    -9.090909
  32027,  0.903271675,   78.1673355,    -9.090909
  32028,  0.932409465,   79.0759659,    -9.090909
  32029,           0.,   70.9090881, -0.909090936
  32030,           0.,   71.8181839, -0.909090936
  32031,           0.,    72.727272, -0.909090936
  32032,           0.,   73.6363602, -0.909090936
  32033,           0.,   74.5454559, -0.909090936
  32034,           0.,   75.4545441, -0.909090936
  32035,           0.,   76.3636398, -0.909090936
  32036,           0.,    77.272728, -0.909090936
  32037,           0.,   78.1818161, -0.909090936
  32038,           0.,   79.0909119, -0.909090936
  32039,           0.,   70.9090881,  -1.81818187
  32040,           0.,   71.8181839,  -1.81818187
  32041,           0.,    72.727272,  -1.81818187
  32042,           0.,   73.6363602,  -1.81818187
  32043,           0.,   74.5454559,  -1.81818187
  32044,           0.,   75.4545441,  -1.81818187
  32045,           0.,   76.3636398,  -1.81818187
  32046,           0.,    77.272728,  -1.81818187
  32047,           0.,   78.1818161,  -1.81818187
  32048,           0.,   79.0909119,  -1.81818187
  32049,           0.,   70.9090881,  -2.72727275
  32050,           0.,   71.8181839,  -2.72727275
  32051,           0.,    72.727272,  -2.72727275
  32052,           0.,   73.6363602,  -2.72727275
  32053,           0.,   74.5454559,  -2.72727275
  32054,           0.,   75.4545441,  -2.72727275
  32055,           0.,   76.3636398,  -2.72727275
  32056,           0.,    77.272728,  -2.72727275
  32057,           0.,   78.1818161,  -2.72727275
  32058,           0.,   79.0909119,  -2.72727275
  32059,           0.,   70.9090881,  -3.63636374
  32060,           0.,   71.8181839,  -3.63636374
  32061,           0.,    72.727272,  -3.63636374
  32062,           0.,   73.6363602,  -3.63636374
  32063,           0.,   74.5454559,  -3.63636374
  32064,           0.,   75.4545441,  -3.63636374
  32065,           0.,   76.3636398,  -3.63636374
  32066,           0.,    77.272728,  -3.63636374
  32067,           0.,   78.1818161,  -3.63636374
  32068,           0.,   79.0909119,  -3.63636374
  32069,           0.,   70.9090881,   -4.5454545
  32070,           0.,   71.8181839,   -4.5454545
  32071,           0.,    72.727272,   -4.5454545
  32072,           0.,   73.6363602,   -4.5454545
  32073,           0.,   74.5454559,   -4.5454545
  32074,           0.,   75.4545441,   -4.5454545
  32075,           0.,   76.3636398,   -4.5454545
  32076,           0.,    77.272728,   -4.5454545
  32077,           0.,   78.1818161,   -4.5454545
  32078,           0.,   79.0909119,   -4.5454545
  32079,           0.,   70.9090881,   -5.4545455
  32080,           0.,   71.8181839,   -5.4545455
  32081,           0.,    72.727272,   -5.4545455
  32082,           0.,   73.6363602,   -5.4545455
  32083,           0.,   74.5454559,   -5.4545455
  32084,           0.,   75.4545441,   -5.4545455
  32085,           0.,   76.3636398,   -5.4545455
  32086,           0.,    77.272728,   -5.4545455
  32087,           0.,   78.1818161,   -5.4545455
  32088,           0.,   79.0909119,   -5.4545455
  32089,           0.,   70.9090881,  -6.36363649
  32090,           0.,   71.8181839,  -6.36363649
  32091,           0.,    72.727272,  -6.36363649
  32092,           0.,   73.6363602,  -6.36363649
  32093,           0.,   74.5454559,  -6.36363649
  32094,           0.,   75.4545441,  -6.36363649
  32095,           0.,   76.3636398,  -6.36363649
  32096,           0.,    77.272728,  -6.36363649
  32097,           0.,   78.1818161,  -6.36363649
  32098,           0.,   79.0909119,  -6.36363649
  32099,           0.,   70.9090881,  -7.27272749
  32100,           0.,   71.8181839,  -7.27272749
  32101,           0.,    72.727272,  -7.27272749
  32102,           0.,   73.6363602,  -7.27272749
  32103,           0.,   74.5454559,  -7.27272749
  32104,           0.,   75.4545441,  -7.27272749
  32105,           0.,   76.3636398,  -7.27272749
  32106,           0.,    77.272728,  -7.27272749
  32107,           0.,   78.1818161,  -7.27272749
  32108,           0.,   79.0909119,  -7.27272749
  32109,           0.,   70.9090881,  -8.18181801
  32110,           0.,   71.8181839,  -8.18181801
  32111,           0.,    72.727272,  -8.18181801
  32112,           0.,   73.6363602,  -8.18181801
  32113,           0.,   74.5454559,  -8.18181801
  32114,           0.,   75.4545441,  -8.18181801
  32115,           0.,   76.3636398,  -8.18181801
  32116,           0.,    77.272728,  -8.18181801
  32117,           0.,   78.1818161,  -8.18181801
  32118,           0.,   79.0909119,  -8.18181801
  32119,           0.,   70.9090881,    -9.090909
  32120,           0.,   71.8181839,    -9.090909
  32121,           0.,    72.727272,    -9.090909
  32122,           0.,   73.6363602,    -9.090909
  32123,           0.,   74.5454559,    -9.090909
  32124,           0.,   75.4545441,    -9.090909
  32125,           0.,   76.3636398,    -9.090909
  32126,           0.,    77.272728,    -9.090909
  32127,           0.,   78.1818161,    -9.090909
  32128,           0.,   79.0909119,    -9.090909
  32129, -0.670169413,   70.8983459, -0.909090936
  32130, -0.699307203,   71.8069687, -0.909090936
  32131, -0.728444934,   72.7155991, -0.909090936
  32132, -0.757582724,   73.6242218, -0.909090936
  32133, -0.786720514,   74.5328445, -0.909090936
  32134, -0.815858364,   75.4414673, -0.909090936
  32135, -0.844996154,     76.35009, -0.909090936
  32136, -0.874133945,   77.2587128, -0.909090936
  32137, -0.903271675,   78.1673355, -0.909090936
  32138, -0.932409465,   79.0759659, -0.909090936
  32139, -0.670169413,   70.8983459,  -1.81818187
  32140, -0.699307203,   71.8069687,  -1.81818187
  32141, -0.728444934,   72.7155991,  -1.81818187
  32142, -0.757582724,   73.6242218,  -1.81818187
  32143, -0.786720514,   74.5328445,  -1.81818187
  32144, -0.815858364,   75.4414673,  -1.81818187
  32145, -0.844996154,     76.35009,  -1.81818187
  32146, -0.874133945,   77.2587128,  -1.81818187
  32147, -0.903271675,   78.1673355,  -1.81818187
  32148, -0.932409465,   79.0759659,  -1.81818187
  32149, -0.670169413,   70.8983459,  -2.72727275
  32150, -0.699307203,   71.8069687,  -2.72727275
  32151, -0.728444934,   72.7155991,  -2.72727275
  32152, -0.757582724,   73.6242218,  -2.72727275
  32153, -0.786720514,   74.5328445,  -2.72727275
  32154, -0.815858364,   75.4414673,  -2.72727275
  32155, -0.844996154,     76.35009,  -2.72727275
  32156, -0.874133945,   77.2587128,  -2.72727275
  32157, -0.903271675,   78.1673355,  -2.72727275
  32158, -0.932409465,   79.0759659,  -2.72727275
  32159, -0.670169413,   70.8983459,  -3.63636374
  32160, -0.699307203,   71.8069687,  -3.63636374
  32161, -0.728444934,   72.7155991,  -3.63636374
  32162, -0.757582724,   73.6242218,  -3.63636374
  32163, -0.786720514,   74.5328445,  -3.63636374
  32164, -0.815858364,   75.4414673,  -3.63636374
  32165, -0.844996154,     76.35009,  -3.63636374
  32166, -0.874133945,   77.2587128,  -3.63636374
  32167, -0.903271675,   78.1673355,  -3.63636374
  32168, -0.932409465,   79.0759659,  -3.63636374
  32169, -0.670169413,   70.8983459,   -4.5454545
  32170, -0.699307203,   71.8069687,   -4.5454545
  32171, -0.728444934,   72.7155991,   -4.5454545
  32172, -0.757582724,   73.6242218,   -4.5454545
  32173, -0.786720514,   74.5328445,   -4.5454545
  32174, -0.815858364,   75.4414673,   -4.5454545
  32175, -0.844996154,     76.35009,   -4.5454545
  32176, -0.874133945,   77.2587128,   -4.5454545
  32177, -0.903271675,   78.1673355,   -4.5454545
  32178, -0.932409465,   79.0759659,   -4.5454545
  32179, -0.670169413,   70.8983459,   -5.4545455
  32180, -0.699307203,   71.8069687,   -5.4545455
  32181, -0.728444934,   72.7155991,   -5.4545455
  32182, -0.757582724,   73.6242218,   -5.4545455
  32183, -0.786720514,   74.5328445,   -5.4545455
  32184, -0.815858364,   75.4414673,   -5.4545455
  32185, -0.844996154,     76.35009,   -5.4545455
  32186, -0.874133945,   77.2587128,   -5.4545455
  32187, -0.903271675,   78.1673355,   -5.4545455
  32188, -0.932409465,   79.0759659,   -5.4545455
  32189, -0.670169413,   70.8983459,  -6.36363649
  32190, -0.699307203,   71.8069687,  -6.36363649
  32191, -0.728444934,   72.7155991,  -6.36363649
  32192, -0.757582724,   73.6242218,  -6.36363649
  32193, -0.786720514,   74.5328445,  -6.36363649
  32194, -0.815858364,   75.4414673,  -6.36363649
  32195, -0.844996154,     76.35009,  -6.36363649
  32196, -0.874133945,   77.2587128,  -6.36363649
  32197, -0.903271675,   78.1673355,  -6.36363649
  32198, -0.932409465,   79.0759659,  -6.36363649
  32199, -0.670169413,   70.8983459,  -7.27272749
  32200, -0.699307203,   71.8069687,  -7.27272749
  32201, -0.728444934,   72.7155991,  -7.27272749
  32202, -0.757582724,   73.6242218,  -7.27272749
  32203, -0.786720514,   74.5328445,  -7.27272749
  32204, -0.815858364,   75.4414673,  -7.27272749
  32205, -0.844996154,     76.35009,  -7.27272749
  32206, -0.874133945,   77.2587128,  -7.27272749
  32207, -0.903271675,   78.1673355,  -7.27272749
  32208, -0.932409465,   79.0759659,  -7.27272749
  32209, -0.670169413,   70.8983459,  -8.18181801
  32210, -0.699307203,   71.8069687,  -8.18181801
  32211, -0.728444934,   72.7155991,  -8.18181801
  32212, -0.757582724,   73.6242218,  -8.18181801
  32213, -0.786720514,   74.5328445,  -8.18181801
  32214, -0.815858364,   75.4414673,  -8.18181801
  32215, -0.844996154,     76.35009,  -8.18181801
  32216, -0.874133945,   77.2587128,  -8.18181801
  32217, -0.903271675,   78.1673355,  -8.18181801
  32218, -0.932409465,   79.0759659,  -8.18181801
  32219, -0.670169413,   70.8983459,    -9.090909
  32220, -0.699307203,   71.8069687,    -9.090909
  32221, -0.728444934,   72.7155991,    -9.090909
  32222, -0.757582724,   73.6242218,    -9.090909
  32223, -0.786720514,   74.5328445,    -9.090909
  32224, -0.815858364,   75.4414673,    -9.090909
  32225, -0.844996154,     76.35009,    -9.090909
  32226, -0.874133945,   77.2587128,    -9.090909
  32227, -0.903271675,   78.1673355,    -9.090909
  32228, -0.932409465,   79.0759659,    -9.090909
  32229,  -1.33965003,   70.8661346, -0.909090936
  32230,  -1.39789569,   71.7733536, -0.909090936
  32231,  -1.45614135,   72.6805801, -0.909090936
  32232,  -1.51438701,   73.5877991, -0.909090936
  32233,  -1.57263267,   74.4950256, -0.909090936
  32234,  -1.63087833,   75.4022446, -0.909090936
  32235,  -1.68912399,   76.3094711, -0.909090936
  32236,  -1.74736965,   77.2166901, -0.909090936
  32237,  -1.80561531,   78.1239166, -0.909090936
  32238,  -1.86386096,   79.0311356, -0.909090936
  32239,  -1.33965003,   70.8661346,  -1.81818187
  32240,  -1.39789569,   71.7733536,  -1.81818187
  32241,  -1.45614135,   72.6805801,  -1.81818187
  32242,  -1.51438701,   73.5877991,  -1.81818187
  32243,  -1.57263267,   74.4950256,  -1.81818187
  32244,  -1.63087833,   75.4022446,  -1.81818187
  32245,  -1.68912399,   76.3094711,  -1.81818187
  32246,  -1.74736965,   77.2166901,  -1.81818187
  32247,  -1.80561531,   78.1239166,  -1.81818187
  32248,  -1.86386096,   79.0311356,  -1.81818187
  32249,  -1.33965003,   70.8661346,  -2.72727275
  32250,  -1.39789569,   71.7733536,  -2.72727275
  32251,  -1.45614135,   72.6805801,  -2.72727275
  32252,  -1.51438701,   73.5877991,  -2.72727275
  32253,  -1.57263267,   74.4950256,  -2.72727275
  32254,  -1.63087833,   75.4022446,  -2.72727275
  32255,  -1.68912399,   76.3094711,  -2.72727275
  32256,  -1.74736965,   77.2166901,  -2.72727275
  32257,  -1.80561531,   78.1239166,  -2.72727275
  32258,  -1.86386096,   79.0311356,  -2.72727275
  32259,  -1.33965003,   70.8661346,  -3.63636374
  32260,  -1.39789569,   71.7733536,  -3.63636374
  32261,  -1.45614135,   72.6805801,  -3.63636374
  32262,  -1.51438701,   73.5877991,  -3.63636374
  32263,  -1.57263267,   74.4950256,  -3.63636374
  32264,  -1.63087833,   75.4022446,  -3.63636374
  32265,  -1.68912399,   76.3094711,  -3.63636374
  32266,  -1.74736965,   77.2166901,  -3.63636374
  32267,  -1.80561531,   78.1239166,  -3.63636374
  32268,  -1.86386096,   79.0311356,  -3.63636374
  32269,  -1.33965003,   70.8661346,   -4.5454545
  32270,  -1.39789569,   71.7733536,   -4.5454545
  32271,  -1.45614135,   72.6805801,   -4.5454545
  32272,  -1.51438701,   73.5877991,   -4.5454545
  32273,  -1.57263267,   74.4950256,   -4.5454545
  32274,  -1.63087833,   75.4022446,   -4.5454545
  32275,  -1.68912399,   76.3094711,   -4.5454545
  32276,  -1.74736965,   77.2166901,   -4.5454545
  32277,  -1.80561531,   78.1239166,   -4.5454545
  32278,  -1.86386096,   79.0311356,   -4.5454545
  32279,  -1.33965003,   70.8661346,   -5.4545455
  32280,  -1.39789569,   71.7733536,   -5.4545455
  32281,  -1.45614135,   72.6805801,   -5.4545455
  32282,  -1.51438701,   73.5877991,   -5.4545455
  32283,  -1.57263267,   74.4950256,   -5.4545455
  32284,  -1.63087833,   75.4022446,   -5.4545455
  32285,  -1.68912399,   76.3094711,   -5.4545455
  32286,  -1.74736965,   77.2166901,   -5.4545455
  32287,  -1.80561531,   78.1239166,   -5.4545455
  32288,  -1.86386096,   79.0311356,   -5.4545455
  32289,  -1.33965003,   70.8661346,  -6.36363649
  32290,  -1.39789569,   71.7733536,  -6.36363649
  32291,  -1.45614135,   72.6805801,  -6.36363649
  32292,  -1.51438701,   73.5877991,  -6.36363649
  32293,  -1.57263267,   74.4950256,  -6.36363649
  32294,  -1.63087833,   75.4022446,  -6.36363649
  32295,  -1.68912399,   76.3094711,  -6.36363649
  32296,  -1.74736965,   77.2166901,  -6.36363649
  32297,  -1.80561531,   78.1239166,  -6.36363649
  32298,  -1.86386096,   79.0311356,  -6.36363649
  32299,  -1.33965003,   70.8661346,  -7.27272749
  32300,  -1.39789569,   71.7733536,  -7.27272749
  32301,  -1.45614135,   72.6805801,  -7.27272749
  32302,  -1.51438701,   73.5877991,  -7.27272749
  32303,  -1.57263267,   74.4950256,  -7.27272749
  32304,  -1.63087833,   75.4022446,  -7.27272749
  32305,  -1.68912399,   76.3094711,  -7.27272749
  32306,  -1.74736965,   77.2166901,  -7.27272749
  32307,  -1.80561531,   78.1239166,  -7.27272749
  32308,  -1.86386096,   79.0311356,  -7.27272749
  32309,  -1.33965003,   70.8661346,  -8.18181801
  32310,  -1.39789569,   71.7733536,  -8.18181801
  32311,  -1.45614135,   72.6805801,  -8.18181801
  32312,  -1.51438701,   73.5877991,  -8.18181801
  32313,  -1.57263267,   74.4950256,  -8.18181801
  32314,  -1.63087833,   75.4022446,  -8.18181801
  32315,  -1.68912399,   76.3094711,  -8.18181801
  32316,  -1.74736965,   77.2166901,  -8.18181801
  32317,  -1.80561531,   78.1239166,  -8.18181801
  32318,  -1.86386096,   79.0311356,  -8.18181801
  32319,  -1.33965003,   70.8661346,    -9.090909
  32320,  -1.39789569,   71.7733536,    -9.090909
  32321,  -1.45614135,   72.6805801,    -9.090909
  32322,  -1.51438701,   73.5877991,    -9.090909
  32323,  -1.57263267,   74.4950256,    -9.090909
  32324,  -1.63087833,   75.4022446,    -9.090909
  32325,  -1.68912399,   76.3094711,    -9.090909
  32326,  -1.74736965,   77.2166901,    -9.090909
  32327,  -1.80561531,   78.1239166,    -9.090909
  32328,  -1.86386096,   79.0311356,    -9.090909
  32329,  -2.00775385,   70.8124695, -0.909090936
  32330,  -2.09504771,   71.7173615, -0.909090936
  32331,  -2.18234134,   72.6222534, -0.909090936
  32332,  -2.26963496,   73.5271454, -0.909090936
  32333,  -2.35692859,   74.4320297, -0.909090936
  32334,  -2.44422245,   75.3369217, -0.909090936
  32335,  -2.53151608,   76.2418137, -0.909090936
  32336,   -2.6188097,   77.1467056, -0.909090936
  32337,  -2.70610356,     78.05159, -0.909090936
  32338,  -2.79339719,   78.9564819, -0.909090936
  32339,  -2.00775385,   70.8124695,  -1.81818187
  32340,  -2.09504771,   71.7173615,  -1.81818187
  32341,  -2.18234134,   72.6222534,  -1.81818187
  32342,  -2.26963496,   73.5271454,  -1.81818187
  32343,  -2.35692859,   74.4320297,  -1.81818187
  32344,  -2.44422245,   75.3369217,  -1.81818187
  32345,  -2.53151608,   76.2418137,  -1.81818187
  32346,   -2.6188097,   77.1467056,  -1.81818187
  32347,  -2.70610356,     78.05159,  -1.81818187
  32348,  -2.79339719,   78.9564819,  -1.81818187
  32349,  -2.00775385,   70.8124695,  -2.72727275
  32350,  -2.09504771,   71.7173615,  -2.72727275
  32351,  -2.18234134,   72.6222534,  -2.72727275
  32352,  -2.26963496,   73.5271454,  -2.72727275
  32353,  -2.35692859,   74.4320297,  -2.72727275
  32354,  -2.44422245,   75.3369217,  -2.72727275
  32355,  -2.53151608,   76.2418137,  -2.72727275
  32356,   -2.6188097,   77.1467056,  -2.72727275
  32357,  -2.70610356,     78.05159,  -2.72727275
  32358,  -2.79339719,   78.9564819,  -2.72727275
  32359,  -2.00775385,   70.8124695,  -3.63636374
  32360,  -2.09504771,   71.7173615,  -3.63636374
  32361,  -2.18234134,   72.6222534,  -3.63636374
  32362,  -2.26963496,   73.5271454,  -3.63636374
  32363,  -2.35692859,   74.4320297,  -3.63636374
  32364,  -2.44422245,   75.3369217,  -3.63636374
  32365,  -2.53151608,   76.2418137,  -3.63636374
  32366,   -2.6188097,   77.1467056,  -3.63636374
  32367,  -2.70610356,     78.05159,  -3.63636374
  32368,  -2.79339719,   78.9564819,  -3.63636374
  32369,  -2.00775385,   70.8124695,   -4.5454545
  32370,  -2.09504771,   71.7173615,   -4.5454545
  32371,  -2.18234134,   72.6222534,   -4.5454545
  32372,  -2.26963496,   73.5271454,   -4.5454545
  32373,  -2.35692859,   74.4320297,   -4.5454545
  32374,  -2.44422245,   75.3369217,   -4.5454545
  32375,  -2.53151608,   76.2418137,   -4.5454545
  32376,   -2.6188097,   77.1467056,   -4.5454545
  32377,  -2.70610356,     78.05159,   -4.5454545
  32378,  -2.79339719,   78.9564819,   -4.5454545
  32379,  -2.00775385,   70.8124695,   -5.4545455
  32380,  -2.09504771,   71.7173615,   -5.4545455
  32381,  -2.18234134,   72.6222534,   -5.4545455
  32382,  -2.26963496,   73.5271454,   -5.4545455
  32383,  -2.35692859,   74.4320297,   -5.4545455
  32384,  -2.44422245,   75.3369217,   -5.4545455
  32385,  -2.53151608,   76.2418137,   -5.4545455
  32386,   -2.6188097,   77.1467056,   -5.4545455
  32387,  -2.70610356,     78.05159,   -5.4545455
  32388,  -2.79339719,   78.9564819,   -5.4545455
  32389,  -2.00775385,   70.8124695,  -6.36363649
  32390,  -2.09504771,   71.7173615,  -6.36363649
  32391,  -2.18234134,   72.6222534,  -6.36363649
  32392,  -2.26963496,   73.5271454,  -6.36363649
  32393,  -2.35692859,   74.4320297,  -6.36363649
  32394,  -2.44422245,   75.3369217,  -6.36363649
  32395,  -2.53151608,   76.2418137,  -6.36363649
  32396,   -2.6188097,   77.1467056,  -6.36363649
  32397,  -2.70610356,     78.05159,  -6.36363649
  32398,  -2.79339719,   78.9564819,  -6.36363649
  32399,  -2.00775385,   70.8124695,  -7.27272749
  32400,  -2.09504771,   71.7173615,  -7.27272749
  32401,  -2.18234134,   72.6222534,  -7.27272749
  32402,  -2.26963496,   73.5271454,  -7.27272749
  32403,  -2.35692859,   74.4320297,  -7.27272749
  32404,  -2.44422245,   75.3369217,  -7.27272749
  32405,  -2.53151608,   76.2418137,  -7.27272749
  32406,   -2.6188097,   77.1467056,  -7.27272749
  32407,  -2.70610356,     78.05159,  -7.27272749
  32408,  -2.79339719,   78.9564819,  -7.27272749
  32409,  -2.00775385,   70.8124695,  -8.18181801
  32410,  -2.09504771,   71.7173615,  -8.18181801
  32411,  -2.18234134,   72.6222534,  -8.18181801
  32412,  -2.26963496,   73.5271454,  -8.18181801
  32413,  -2.35692859,   74.4320297,  -8.18181801
  32414,  -2.44422245,   75.3369217,  -8.18181801
  32415,  -2.53151608,   76.2418137,  -8.18181801
  32416,   -2.6188097,   77.1467056,  -8.18181801
  32417,  -2.70610356,     78.05159,  -8.18181801
  32418,  -2.79339719,   78.9564819,  -8.18181801
  32419,  -2.00775385,   70.8124695,    -9.090909
  32420,  -2.09504771,   71.7173615,    -9.090909
  32421,  -2.18234134,   72.6222534,    -9.090909
  32422,  -2.26963496,   73.5271454,    -9.090909
  32423,  -2.35692859,   74.4320297,    -9.090909
  32424,  -2.44422245,   75.3369217,    -9.090909
  32425,  -2.53151608,   76.2418137,    -9.090909
  32426,   -2.6188097,   77.1467056,    -9.090909
  32427,  -2.70610356,     78.05159,    -9.090909
  32428,  -2.79339719,   78.9564819,    -9.090909
  32429,  -2.67379522,   70.7374268, -0.909090936
  32430,  -2.79004717,   71.6390533, -0.909090936
  32431,  -2.90629911,   72.5406799, -0.909090936
  32432,  -3.02255106,   73.4423065, -0.909090936
  32433,  -3.13880301,   74.3439331, -0.909090936
  32434,  -3.25505495,   75.2455673, -0.909090936
  32435,   -3.3713069,   76.1471939, -0.909090936
  32436,  -3.48755884,   77.0488205, -0.909090936
  32437,  -3.60381103,   77.9504471, -0.909090936
  32438,  -3.72006297,   78.8520737, -0.909090936
  32439,  -2.67379522,   70.7374268,  -1.81818187
  32440,  -2.79004717,   71.6390533,  -1.81818187
  32441,  -2.90629911,   72.5406799,  -1.81818187
  32442,  -3.02255106,   73.4423065,  -1.81818187
  32443,  -3.13880301,   74.3439331,  -1.81818187
  32444,  -3.25505495,   75.2455673,  -1.81818187
  32445,   -3.3713069,   76.1471939,  -1.81818187
  32446,  -3.48755884,   77.0488205,  -1.81818187
  32447,  -3.60381103,   77.9504471,  -1.81818187
  32448,  -3.72006297,   78.8520737,  -1.81818187
  32449,  -2.67379522,   70.7374268,  -2.72727275
  32450,  -2.79004717,   71.6390533,  -2.72727275
  32451,  -2.90629911,   72.5406799,  -2.72727275
  32452,  -3.02255106,   73.4423065,  -2.72727275
  32453,  -3.13880301,   74.3439331,  -2.72727275
  32454,  -3.25505495,   75.2455673,  -2.72727275
  32455,   -3.3713069,   76.1471939,  -2.72727275
  32456,  -3.48755884,   77.0488205,  -2.72727275
  32457,  -3.60381103,   77.9504471,  -2.72727275
  32458,  -3.72006297,   78.8520737,  -2.72727275
  32459,  -2.67379522,   70.7374268,  -3.63636374
  32460,  -2.79004717,   71.6390533,  -3.63636374
  32461,  -2.90629911,   72.5406799,  -3.63636374
  32462,  -3.02255106,   73.4423065,  -3.63636374
  32463,  -3.13880301,   74.3439331,  -3.63636374
  32464,  -3.25505495,   75.2455673,  -3.63636374
  32465,   -3.3713069,   76.1471939,  -3.63636374
  32466,  -3.48755884,   77.0488205,  -3.63636374
  32467,  -3.60381103,   77.9504471,  -3.63636374
  32468,  -3.72006297,   78.8520737,  -3.63636374
  32469,  -2.67379522,   70.7374268,   -4.5454545
  32470,  -2.79004717,   71.6390533,   -4.5454545
  32471,  -2.90629911,   72.5406799,   -4.5454545
  32472,  -3.02255106,   73.4423065,   -4.5454545
  32473,  -3.13880301,   74.3439331,   -4.5454545
  32474,  -3.25505495,   75.2455673,   -4.5454545
  32475,   -3.3713069,   76.1471939,   -4.5454545
  32476,  -3.48755884,   77.0488205,   -4.5454545
  32477,  -3.60381103,   77.9504471,   -4.5454545
  32478,  -3.72006297,   78.8520737,   -4.5454545
  32479,  -2.67379522,   70.7374268,   -5.4545455
  32480,  -2.79004717,   71.6390533,   -5.4545455
  32481,  -2.90629911,   72.5406799,   -5.4545455
  32482,  -3.02255106,   73.4423065,   -5.4545455
  32483,  -3.13880301,   74.3439331,   -5.4545455
  32484,  -3.25505495,   75.2455673,   -5.4545455
  32485,   -3.3713069,   76.1471939,   -5.4545455
  32486,  -3.48755884,   77.0488205,   -5.4545455
  32487,  -3.60381103,   77.9504471,   -5.4545455
  32488,  -3.72006297,   78.8520737,   -5.4545455
  32489,  -2.67379522,   70.7374268,  -6.36363649
  32490,  -2.79004717,   71.6390533,  -6.36363649
  32491,  -2.90629911,   72.5406799,  -6.36363649
  32492,  -3.02255106,   73.4423065,  -6.36363649
  32493,  -3.13880301,   74.3439331,  -6.36363649
  32494,  -3.25505495,   75.2455673,  -6.36363649
  32495,   -3.3713069,   76.1471939,  -6.36363649
  32496,  -3.48755884,   77.0488205,  -6.36363649
  32497,  -3.60381103,   77.9504471,  -6.36363649
  32498,  -3.72006297,   78.8520737,  -6.36363649
  32499,  -2.67379522,   70.7374268,  -7.27272749
  32500,  -2.79004717,   71.6390533,  -7.27272749
  32501,  -2.90629911,   72.5406799,  -7.27272749
  32502,  -3.02255106,   73.4423065,  -7.27272749
  32503,  -3.13880301,   74.3439331,  -7.27272749
  32504,  -3.25505495,   75.2455673,  -7.27272749
  32505,   -3.3713069,   76.1471939,  -7.27272749
  32506,  -3.48755884,   77.0488205,  -7.27272749
  32507,  -3.60381103,   77.9504471,  -7.27272749
  32508,  -3.72006297,   78.8520737,  -7.27272749
  32509,  -2.67379522,   70.7374268,  -8.18181801
  32510,  -2.79004717,   71.6390533,  -8.18181801
  32511,  -2.90629911,   72.5406799,  -8.18181801
  32512,  -3.02255106,   73.4423065,  -8.18181801
  32513,  -3.13880301,   74.3439331,  -8.18181801
  32514,  -3.25505495,   75.2455673,  -8.18181801
  32515,   -3.3713069,   76.1471939,  -8.18181801
  32516,  -3.48755884,   77.0488205,  -8.18181801
  32517,  -3.60381103,   77.9504471,  -8.18181801
  32518,  -3.72006297,   78.8520737,  -8.18181801
  32519,  -2.67379522,   70.7374268,    -9.090909
  32520,  -2.79004717,   71.6390533,    -9.090909
  32521,  -2.90629911,   72.5406799,    -9.090909
  32522,  -3.02255106,   73.4423065,    -9.090909
  32523,  -3.13880301,   74.3439331,    -9.090909
  32524,  -3.25505495,   75.2455673,    -9.090909
  32525,   -3.3713069,   76.1471939,    -9.090909
  32526,  -3.48755884,   77.0488205,    -9.090909
  32527,  -3.60381103,   77.9504471,    -9.090909
  32528,  -3.72006297,   78.8520737,    -9.090909
  32529,  -3.33708858,   70.6410751, -0.909090936
  32530,   -3.4821794,   71.5385132, -0.909090936
  32531,  -3.62727022,   72.4359512, -0.909090936
  32532,   -3.7723608,   73.3333893, -0.909090936
  32533,  -3.91745162,   74.2308273, -0.909090936
  32534,  -4.06254244,   75.1282654, -0.909090936
  32535,  -4.20763302,   76.0257034, -0.909090936
  32536,  -4.35272408,   76.9231415, -0.909090936
  32537,  -4.49781466,   77.8205795, -0.909090936
  32538,  -4.64290571,   78.7180176, -0.909090936
  32539,  -3.33708858,   70.6410751,  -1.81818187
  32540,   -3.4821794,   71.5385132,  -1.81818187
  32541,  -3.62727022,   72.4359512,  -1.81818187
  32542,   -3.7723608,   73.3333893,  -1.81818187
  32543,  -3.91745162,   74.2308273,  -1.81818187
  32544,  -4.06254244,   75.1282654,  -1.81818187
  32545,  -4.20763302,   76.0257034,  -1.81818187
  32546,  -4.35272408,   76.9231415,  -1.81818187
  32547,  -4.49781466,   77.8205795,  -1.81818187
  32548,  -4.64290571,   78.7180176,  -1.81818187
  32549,  -3.33708858,   70.6410751,  -2.72727275
  32550,   -3.4821794,   71.5385132,  -2.72727275
  32551,  -3.62727022,   72.4359512,  -2.72727275
  32552,   -3.7723608,   73.3333893,  -2.72727275
  32553,  -3.91745162,   74.2308273,  -2.72727275
  32554,  -4.06254244,   75.1282654,  -2.72727275
  32555,  -4.20763302,   76.0257034,  -2.72727275
  32556,  -4.35272408,   76.9231415,  -2.72727275
  32557,  -4.49781466,   77.8205795,  -2.72727275
  32558,  -4.64290571,   78.7180176,  -2.72727275
  32559,  -3.33708858,   70.6410751,  -3.63636374
  32560,   -3.4821794,   71.5385132,  -3.63636374
  32561,  -3.62727022,   72.4359512,  -3.63636374
  32562,   -3.7723608,   73.3333893,  -3.63636374
  32563,  -3.91745162,   74.2308273,  -3.63636374
  32564,  -4.06254244,   75.1282654,  -3.63636374
  32565,  -4.20763302,   76.0257034,  -3.63636374
  32566,  -4.35272408,   76.9231415,  -3.63636374
  32567,  -4.49781466,   77.8205795,  -3.63636374
  32568,  -4.64290571,   78.7180176,  -3.63636374
  32569,  -3.33708858,   70.6410751,   -4.5454545
  32570,   -3.4821794,   71.5385132,   -4.5454545
  32571,  -3.62727022,   72.4359512,   -4.5454545
  32572,   -3.7723608,   73.3333893,   -4.5454545
  32573,  -3.91745162,   74.2308273,   -4.5454545
  32574,  -4.06254244,   75.1282654,   -4.5454545
  32575,  -4.20763302,   76.0257034,   -4.5454545
  32576,  -4.35272408,   76.9231415,   -4.5454545
  32577,  -4.49781466,   77.8205795,   -4.5454545
  32578,  -4.64290571,   78.7180176,   -4.5454545
  32579,  -3.33708858,   70.6410751,   -5.4545455
  32580,   -3.4821794,   71.5385132,   -5.4545455
  32581,  -3.62727022,   72.4359512,   -5.4545455
  32582,   -3.7723608,   73.3333893,   -5.4545455
  32583,  -3.91745162,   74.2308273,   -5.4545455
  32584,  -4.06254244,   75.1282654,   -5.4545455
  32585,  -4.20763302,   76.0257034,   -5.4545455
  32586,  -4.35272408,   76.9231415,   -5.4545455
  32587,  -4.49781466,   77.8205795,   -5.4545455
  32588,  -4.64290571,   78.7180176,   -5.4545455
  32589,  -3.33708858,   70.6410751,  -6.36363649
  32590,   -3.4821794,   71.5385132,  -6.36363649
  32591,  -3.62727022,   72.4359512,  -6.36363649
  32592,   -3.7723608,   73.3333893,  -6.36363649
  32593,  -3.91745162,   74.2308273,  -6.36363649
  32594,  -4.06254244,   75.1282654,  -6.36363649
  32595,  -4.20763302,   76.0257034,  -6.36363649
  32596,  -4.35272408,   76.9231415,  -6.36363649
  32597,  -4.49781466,   77.8205795,  -6.36363649
  32598,  -4.64290571,   78.7180176,  -6.36363649
  32599,  -3.33708858,   70.6410751,  -7.27272749
  32600,   -3.4821794,   71.5385132,  -7.27272749
  32601,  -3.62727022,   72.4359512,  -7.27272749
  32602,   -3.7723608,   73.3333893,  -7.27272749
  32603,  -3.91745162,   74.2308273,  -7.27272749
  32604,  -4.06254244,   75.1282654,  -7.27272749
  32605,  -4.20763302,   76.0257034,  -7.27272749
  32606,  -4.35272408,   76.9231415,  -7.27272749
  32607,  -4.49781466,   77.8205795,  -7.27272749
  32608,  -4.64290571,   78.7180176,  -7.27272749
  32609,  -3.33708858,   70.6410751,  -8.18181801
  32610,   -3.4821794,   71.5385132,  -8.18181801
  32611,  -3.62727022,   72.4359512,  -8.18181801
  32612,   -3.7723608,   73.3333893,  -8.18181801
  32613,  -3.91745162,   74.2308273,  -8.18181801
  32614,  -4.06254244,   75.1282654,  -8.18181801
  32615,  -4.20763302,   76.0257034,  -8.18181801
  32616,  -4.35272408,   76.9231415,  -8.18181801
  32617,  -4.49781466,   77.8205795,  -8.18181801
  32618,  -4.64290571,   78.7180176,  -8.18181801
  32619,  -3.33708858,   70.6410751,    -9.090909
  32620,   -3.4821794,   71.5385132,    -9.090909
  32621,  -3.62727022,   72.4359512,    -9.090909
  32622,   -3.7723608,   73.3333893,    -9.090909
  32623,  -3.91745162,   74.2308273,    -9.090909
  32624,  -4.06254244,   75.1282654,    -9.090909
  32625,  -4.20763302,   76.0257034,    -9.090909
  32626,  -4.35272408,   76.9231415,    -9.090909
  32627,  -4.49781466,   77.8205795,    -9.090909
  32628,  -4.64290571,   78.7180176,    -9.090909
  32629,  -3.99695396,   70.5235062, -0.909090936
  32630,  -4.17073441,   71.4158325, -0.909090936
  32631,  -4.34451485,   72.3081589, -0.909090936
  32632,  -4.51829529,   73.2004929, -0.909090936
  32633,  -4.69207525,   74.0928192, -0.909090936
  32634,  -4.86585617,   74.9851456, -0.909090936
  32635,  -5.03963661,   75.8774719, -0.909090936
  32636,  -5.21341705,   76.7697983, -0.909090936
  32637,  -5.38719702,   77.6621246, -0.909090936
  32638,  -5.56097794,    78.554451, -0.909090936
  32639,  -3.99695396,   70.5235062,  -1.81818187
  32640,  -4.17073441,   71.4158325,  -1.81818187
  32641,  -4.34451485,   72.3081589,  -1.81818187
  32642,  -4.51829529,   73.2004929,  -1.81818187
  32643,  -4.69207525,   74.0928192,  -1.81818187
  32644,  -4.86585617,   74.9851456,  -1.81818187
  32645,  -5.03963661,   75.8774719,  -1.81818187
  32646,  -5.21341705,   76.7697983,  -1.81818187
  32647,  -5.38719702,   77.6621246,  -1.81818187
  32648,  -5.56097794,    78.554451,  -1.81818187
  32649,  -3.99695396,   70.5235062,  -2.72727275
  32650,  -4.17073441,   71.4158325,  -2.72727275
  32651,  -4.34451485,   72.3081589,  -2.72727275
  32652,  -4.51829529,   73.2004929,  -2.72727275
  32653,  -4.69207525,   74.0928192,  -2.72727275
  32654,  -4.86585617,   74.9851456,  -2.72727275
  32655,  -5.03963661,   75.8774719,  -2.72727275
  32656,  -5.21341705,   76.7697983,  -2.72727275
  32657,  -5.38719702,   77.6621246,  -2.72727275
  32658,  -5.56097794,    78.554451,  -2.72727275
  32659,  -3.99695396,   70.5235062,  -3.63636374
  32660,  -4.17073441,   71.4158325,  -3.63636374
  32661,  -4.34451485,   72.3081589,  -3.63636374
  32662,  -4.51829529,   73.2004929,  -3.63636374
  32663,  -4.69207525,   74.0928192,  -3.63636374
  32664,  -4.86585617,   74.9851456,  -3.63636374
  32665,  -5.03963661,   75.8774719,  -3.63636374
  32666,  -5.21341705,   76.7697983,  -3.63636374
  32667,  -5.38719702,   77.6621246,  -3.63636374
  32668,  -5.56097794,    78.554451,  -3.63636374
  32669,  -3.99695396,   70.5235062,   -4.5454545
  32670,  -4.17073441,   71.4158325,   -4.5454545
  32671,  -4.34451485,   72.3081589,   -4.5454545
  32672,  -4.51829529,   73.2004929,   -4.5454545
  32673,  -4.69207525,   74.0928192,   -4.5454545
  32674,  -4.86585617,   74.9851456,   -4.5454545
  32675,  -5.03963661,   75.8774719,   -4.5454545
  32676,  -5.21341705,   76.7697983,   -4.5454545
  32677,  -5.38719702,   77.6621246,   -4.5454545
  32678,  -5.56097794,    78.554451,   -4.5454545
  32679,  -3.99695396,   70.5235062,   -5.4545455
  32680,  -4.17073441,   71.4158325,   -5.4545455
  32681,  -4.34451485,   72.3081589,   -5.4545455
  32682,  -4.51829529,   73.2004929,   -5.4545455
  32683,  -4.69207525,   74.0928192,   -5.4545455
  32684,  -4.86585617,   74.9851456,   -5.4545455
  32685,  -5.03963661,   75.8774719,   -5.4545455
  32686,  -5.21341705,   76.7697983,   -5.4545455
  32687,  -5.38719702,   77.6621246,   -5.4545455
  32688,  -5.56097794,    78.554451,   -5.4545455
  32689,  -3.99695396,   70.5235062,  -6.36363649
  32690,  -4.17073441,   71.4158325,  -6.36363649
  32691,  -4.34451485,   72.3081589,  -6.36363649
  32692,  -4.51829529,   73.2004929,  -6.36363649
  32693,  -4.69207525,   74.0928192,  -6.36363649
  32694,  -4.86585617,   74.9851456,  -6.36363649
  32695,  -5.03963661,   75.8774719,  -6.36363649
  32696,  -5.21341705,   76.7697983,  -6.36363649
  32697,  -5.38719702,   77.6621246,  -6.36363649
  32698,  -5.56097794,    78.554451,  -6.36363649
  32699,  -3.99695396,   70.5235062,  -7.27272749
  32700,  -4.17073441,   71.4158325,  -7.27272749
  32701,  -4.34451485,   72.3081589,  -7.27272749
  32702,  -4.51829529,   73.2004929,  -7.27272749
  32703,  -4.69207525,   74.0928192,  -7.27272749
  32704,  -4.86585617,   74.9851456,  -7.27272749
  32705,  -5.03963661,   75.8774719,  -7.27272749
  32706,  -5.21341705,   76.7697983,  -7.27272749
  32707,  -5.38719702,   77.6621246,  -7.27272749
  32708,  -5.56097794,    78.554451,  -7.27272749
  32709,  -3.99695396,   70.5235062,  -8.18181801
  32710,  -4.17073441,   71.4158325,  -8.18181801
  32711,  -4.34451485,   72.3081589,  -8.18181801
  32712,  -4.51829529,   73.2004929,  -8.18181801
  32713,  -4.69207525,   74.0928192,  -8.18181801
  32714,  -4.86585617,   74.9851456,  -8.18181801
  32715,  -5.03963661,   75.8774719,  -8.18181801
  32716,  -5.21341705,   76.7697983,  -8.18181801
  32717,  -5.38719702,   77.6621246,  -8.18181801
  32718,  -5.56097794,    78.554451,  -8.18181801
  32719,  -3.99695396,   70.5235062,    -9.090909
  32720,  -4.17073441,   71.4158325,    -9.090909
  32721,  -4.34451485,   72.3081589,    -9.090909
  32722,  -4.51829529,   73.2004929,    -9.090909
  32723,  -4.69207525,   74.0928192,    -9.090909
  32724,  -4.86585617,   74.9851456,    -9.090909
  32725,  -5.03963661,   75.8774719,    -9.090909
  32726,  -5.21341705,   76.7697983,    -9.090909
  32727,  -5.38719702,   77.6621246,    -9.090909
  32728,  -5.56097794,    78.554451,    -9.090909
  32729,  -4.65271044,   70.3848572, -0.909090936
  32730,   -4.8550024,   71.2711563, -0.909090936
  32731,  -5.05729342,   72.1574554, -0.909090936
  32732,  -5.25958538,   73.0437469, -0.909090936
  32733,  -5.46187687,   73.9300461, -0.909090936
  32734,  -5.66416883,   74.8163452, -0.909090936
  32735,  -5.86646032,   75.7026443, -0.909090936
  32736,  -6.06875229,   76.5889435, -0.909090936
  32737,  -6.27104378,   77.4752426, -0.909090936
  32738,  -6.47333527,   78.3615417, -0.909090936
  32739,  -4.65271044,   70.3848572,  -1.81818187
  32740,   -4.8550024,   71.2711563,  -1.81818187
  32741,  -5.05729342,   72.1574554,  -1.81818187
  32742,  -5.25958538,   73.0437469,  -1.81818187
  32743,  -5.46187687,   73.9300461,  -1.81818187
  32744,  -5.66416883,   74.8163452,  -1.81818187
  32745,  -5.86646032,   75.7026443,  -1.81818187
  32746,  -6.06875229,   76.5889435,  -1.81818187
  32747,  -6.27104378,   77.4752426,  -1.81818187
  32748,  -6.47333527,   78.3615417,  -1.81818187
  32749,  -4.65271044,   70.3848572,  -2.72727275
  32750,   -4.8550024,   71.2711563,  -2.72727275
  32751,  -5.05729342,   72.1574554,  -2.72727275
  32752,  -5.25958538,   73.0437469,  -2.72727275
  32753,  -5.46187687,   73.9300461,  -2.72727275
  32754,  -5.66416883,   74.8163452,  -2.72727275
  32755,  -5.86646032,   75.7026443,  -2.72727275
  32756,  -6.06875229,   76.5889435,  -2.72727275
  32757,  -6.27104378,   77.4752426,  -2.72727275
  32758,  -6.47333527,   78.3615417,  -2.72727275
  32759,  -4.65271044,   70.3848572,  -3.63636374
  32760,   -4.8550024,   71.2711563,  -3.63636374
  32761,  -5.05729342,   72.1574554,  -3.63636374
  32762,  -5.25958538,   73.0437469,  -3.63636374
  32763,  -5.46187687,   73.9300461,  -3.63636374
  32764,  -5.66416883,   74.8163452,  -3.63636374
  32765,  -5.86646032,   75.7026443,  -3.63636374
  32766,  -6.06875229,   76.5889435,  -3.63636374
  32767,  -6.27104378,   77.4752426,  -3.63636374
  32768,  -6.47333527,   78.3615417,  -3.63636374
  32769,  -4.65271044,   70.3848572,   -4.5454545
  32770,   -4.8550024,   71.2711563,   -4.5454545
  32771,  -5.05729342,   72.1574554,   -4.5454545
  32772,  -5.25958538,   73.0437469,   -4.5454545
  32773,  -5.46187687,   73.9300461,   -4.5454545
  32774,  -5.66416883,   74.8163452,   -4.5454545
  32775,  -5.86646032,   75.7026443,   -4.5454545
  32776,  -6.06875229,   76.5889435,   -4.5454545
  32777,  -6.27104378,   77.4752426,   -4.5454545
  32778,  -6.47333527,   78.3615417,   -4.5454545
  32779,  -4.65271044,   70.3848572,   -5.4545455
  32780,   -4.8550024,   71.2711563,   -5.4545455
  32781,  -5.05729342,   72.1574554,   -5.4545455
  32782,  -5.25958538,   73.0437469,   -5.4545455
  32783,  -5.46187687,   73.9300461,   -5.4545455
  32784,  -5.66416883,   74.8163452,   -5.4545455
  32785,  -5.86646032,   75.7026443,   -5.4545455
  32786,  -6.06875229,   76.5889435,   -5.4545455
  32787,  -6.27104378,   77.4752426,   -5.4545455
  32788,  -6.47333527,   78.3615417,   -5.4545455
  32789,  -4.65271044,   70.3848572,  -6.36363649
  32790,   -4.8550024,   71.2711563,  -6.36363649
  32791,  -5.05729342,   72.1574554,  -6.36363649
  32792,  -5.25958538,   73.0437469,  -6.36363649
  32793,  -5.46187687,   73.9300461,  -6.36363649
  32794,  -5.66416883,   74.8163452,  -6.36363649
  32795,  -5.86646032,   75.7026443,  -6.36363649
  32796,  -6.06875229,   76.5889435,  -6.36363649
  32797,  -6.27104378,   77.4752426,  -6.36363649
  32798,  -6.47333527,   78.3615417,  -6.36363649
  32799,  -4.65271044,   70.3848572,  -7.27272749
  32800,   -4.8550024,   71.2711563,  -7.27272749
  32801,  -5.05729342,   72.1574554,  -7.27272749
  32802,  -5.25958538,   73.0437469,  -7.27272749
  32803,  -5.46187687,   73.9300461,  -7.27272749
  32804,  -5.66416883,   74.8163452,  -7.27272749
  32805,  -5.86646032,   75.7026443,  -7.27272749
  32806,  -6.06875229,   76.5889435,  -7.27272749
  32807,  -6.27104378,   77.4752426,  -7.27272749
  32808,  -6.47333527,   78.3615417,  -7.27272749
  32809,  -4.65271044,   70.3848572,  -8.18181801
  32810,   -4.8550024,   71.2711563,  -8.18181801
  32811,  -5.05729342,   72.1574554,  -8.18181801
  32812,  -5.25958538,   73.0437469,  -8.18181801
  32813,  -5.46187687,   73.9300461,  -8.18181801
  32814,  -5.66416883,   74.8163452,  -8.18181801
  32815,  -5.86646032,   75.7026443,  -8.18181801
  32816,  -6.06875229,   76.5889435,  -8.18181801
  32817,  -6.27104378,   77.4752426,  -8.18181801
  32818,  -6.47333527,   78.3615417,  -8.18181801
  32819,  -4.65271044,   70.3848572,    -9.090909
  32820,   -4.8550024,   71.2711563,    -9.090909
  32821,  -5.05729342,   72.1574554,    -9.090909
  32822,  -5.25958538,   73.0437469,    -9.090909
  32823,  -5.46187687,   73.9300461,    -9.090909
  32824,  -5.66416883,   74.8163452,    -9.090909
  32825,  -5.86646032,   75.7026443,    -9.090909
  32826,  -6.06875229,   76.5889435,    -9.090909
  32827,  -6.27104378,   77.4752426,    -9.090909
  32828,  -6.47333527,   78.3615417,    -9.090909
  32829,  -5.30368757,   70.2252579, -0.909090936
  32830,  -5.53428268,   71.1046143, -0.909090936
  32831,   -5.7648778,   71.9839706, -0.909090936
  32832,  -5.99547291,   72.8633347, -0.909090936
  32833,  -6.22606802,    73.742691, -0.909090936
  32834,  -6.45666265,   74.6220474, -0.909090936
  32835,  -6.68725777,   75.5014114, -0.909090936
  32836,  -6.91785288,   76.3807678, -0.909090936
  32837,  -7.14844799,   77.2601242, -0.909090936
  32838,   -7.3790431,   78.1394882, -0.909090936
  32839,  -5.30368757,   70.2252579,  -1.81818187
  32840,  -5.53428268,   71.1046143,  -1.81818187
  32841,   -5.7648778,   71.9839706,  -1.81818187
  32842,  -5.99547291,   72.8633347,  -1.81818187
  32843,  -6.22606802,    73.742691,  -1.81818187
  32844,  -6.45666265,   74.6220474,  -1.81818187
  32845,  -6.68725777,   75.5014114,  -1.81818187
  32846,  -6.91785288,   76.3807678,  -1.81818187
  32847,  -7.14844799,   77.2601242,  -1.81818187
  32848,   -7.3790431,   78.1394882,  -1.81818187
  32849,  -5.30368757,   70.2252579,  -2.72727275
  32850,  -5.53428268,   71.1046143,  -2.72727275
  32851,   -5.7648778,   71.9839706,  -2.72727275
  32852,  -5.99547291,   72.8633347,  -2.72727275
  32853,  -6.22606802,    73.742691,  -2.72727275
  32854,  -6.45666265,   74.6220474,  -2.72727275
  32855,  -6.68725777,   75.5014114,  -2.72727275
  32856,  -6.91785288,   76.3807678,  -2.72727275
  32857,  -7.14844799,   77.2601242,  -2.72727275
  32858,   -7.3790431,   78.1394882,  -2.72727275
  32859,  -5.30368757,   70.2252579,  -3.63636374
  32860,  -5.53428268,   71.1046143,  -3.63636374
  32861,   -5.7648778,   71.9839706,  -3.63636374
  32862,  -5.99547291,   72.8633347,  -3.63636374
  32863,  -6.22606802,    73.742691,  -3.63636374
  32864,  -6.45666265,   74.6220474,  -3.63636374
  32865,  -6.68725777,   75.5014114,  -3.63636374
  32866,  -6.91785288,   76.3807678,  -3.63636374
  32867,  -7.14844799,   77.2601242,  -3.63636374
  32868,   -7.3790431,   78.1394882,  -3.63636374
  32869,  -5.30368757,   70.2252579,   -4.5454545
  32870,  -5.53428268,   71.1046143,   -4.5454545
  32871,   -5.7648778,   71.9839706,   -4.5454545
  32872,  -5.99547291,   72.8633347,   -4.5454545
  32873,  -6.22606802,    73.742691,   -4.5454545
  32874,  -6.45666265,   74.6220474,   -4.5454545
  32875,  -6.68725777,   75.5014114,   -4.5454545
  32876,  -6.91785288,   76.3807678,   -4.5454545
  32877,  -7.14844799,   77.2601242,   -4.5454545
  32878,   -7.3790431,   78.1394882,   -4.5454545
  32879,  -5.30368757,   70.2252579,   -5.4545455
  32880,  -5.53428268,   71.1046143,   -5.4545455
  32881,   -5.7648778,   71.9839706,   -5.4545455
  32882,  -5.99547291,   72.8633347,   -5.4545455
  32883,  -6.22606802,    73.742691,   -5.4545455
  32884,  -6.45666265,   74.6220474,   -5.4545455
  32885,  -6.68725777,   75.5014114,   -5.4545455
  32886,  -6.91785288,   76.3807678,   -5.4545455
  32887,  -7.14844799,   77.2601242,   -5.4545455
  32888,   -7.3790431,   78.1394882,   -5.4545455
  32889,  -5.30368757,   70.2252579,  -6.36363649
  32890,  -5.53428268,   71.1046143,  -6.36363649
  32891,   -5.7648778,   71.9839706,  -6.36363649
  32892,  -5.99547291,   72.8633347,  -6.36363649
  32893,  -6.22606802,    73.742691,  -6.36363649
  32894,  -6.45666265,   74.6220474,  -6.36363649
  32895,  -6.68725777,   75.5014114,  -6.36363649
  32896,  -6.91785288,   76.3807678,  -6.36363649
  32897,  -7.14844799,   77.2601242,  -6.36363649
  32898,   -7.3790431,   78.1394882,  -6.36363649
  32899,  -5.30368757,   70.2252579,  -7.27272749
  32900,  -5.53428268,   71.1046143,  -7.27272749
  32901,   -5.7648778,   71.9839706,  -7.27272749
  32902,  -5.99547291,   72.8633347,  -7.27272749
  32903,  -6.22606802,    73.742691,  -7.27272749
  32904,  -6.45666265,   74.6220474,  -7.27272749
  32905,  -6.68725777,   75.5014114,  -7.27272749
  32906,  -6.91785288,   76.3807678,  -7.27272749
  32907,  -7.14844799,   77.2601242,  -7.27272749
  32908,   -7.3790431,   78.1394882,  -7.27272749
  32909,  -5.30368757,   70.2252579,  -8.18181801
  32910,  -5.53428268,   71.1046143,  -8.18181801
  32911,   -5.7648778,   71.9839706,  -8.18181801
  32912,  -5.99547291,   72.8633347,  -8.18181801
  32913,  -6.22606802,    73.742691,  -8.18181801
  32914,  -6.45666265,   74.6220474,  -8.18181801
  32915,  -6.68725777,   75.5014114,  -8.18181801
  32916,  -6.91785288,   76.3807678,  -8.18181801
  32917,  -7.14844799,   77.2601242,  -8.18181801
  32918,   -7.3790431,   78.1394882,  -8.18181801
  32919,  -5.30368757,   70.2252579,    -9.090909
  32920,  -5.53428268,   71.1046143,    -9.090909
  32921,   -5.7648778,   71.9839706,    -9.090909
  32922,  -5.99547291,   72.8633347,    -9.090909
  32923,  -6.22606802,    73.742691,    -9.090909
  32924,  -6.45666265,   74.6220474,    -9.090909
  32925,  -6.68725777,   75.5014114,    -9.090909
  32926,  -6.91785288,   76.3807678,    -9.090909
  32927,  -7.14844799,   77.2601242,    -9.090909
  32928,   -7.3790431,   78.1394882,    -9.090909
  32929,   -5.9492135,   70.0448761, -0.909090936
  32930,  -6.20787525,   70.9163895, -0.909090936
  32931,  -6.46653652,   71.7879028, -0.909090936
  32932,  -6.72519779,   72.6594238, -0.909090936
  32933,  -6.98385954,   73.5309372, -0.909090936
  32934,  -7.24252129,   74.4024582, -0.909090936
  32935,  -7.50118256,   75.2739716, -0.909090936
  32936,   -7.7598443,   76.1454849, -0.909090936
  32937,  -8.01850605,   77.0170059, -0.909090936
  32938,  -8.27716732,   77.8885193, -0.909090936
  32939,   -5.9492135,   70.0448761,  -1.81818187
  32940,  -6.20787525,   70.9163895,  -1.81818187
  32941,  -6.46653652,   71.7879028,  -1.81818187
  32942,  -6.72519779,   72.6594238,  -1.81818187
  32943,  -6.98385954,   73.5309372,  -1.81818187
  32944,  -7.24252129,   74.4024582,  -1.81818187
  32945,  -7.50118256,   75.2739716,  -1.81818187
  32946,   -7.7598443,   76.1454849,  -1.81818187
  32947,  -8.01850605,   77.0170059,  -1.81818187
  32948,  -8.27716732,   77.8885193,  -1.81818187
  32949,   -5.9492135,   70.0448761,  -2.72727275
  32950,  -6.20787525,   70.9163895,  -2.72727275
  32951,  -6.46653652,   71.7879028,  -2.72727275
  32952,  -6.72519779,   72.6594238,  -2.72727275
  32953,  -6.98385954,   73.5309372,  -2.72727275
  32954,  -7.24252129,   74.4024582,  -2.72727275
  32955,  -7.50118256,   75.2739716,  -2.72727275
  32956,   -7.7598443,   76.1454849,  -2.72727275
  32957,  -8.01850605,   77.0170059,  -2.72727275
  32958,  -8.27716732,   77.8885193,  -2.72727275
  32959,   -5.9492135,   70.0448761,  -3.63636374
  32960,  -6.20787525,   70.9163895,  -3.63636374
  32961,  -6.46653652,   71.7879028,  -3.63636374
  32962,  -6.72519779,   72.6594238,  -3.63636374
  32963,  -6.98385954,   73.5309372,  -3.63636374
  32964,  -7.24252129,   74.4024582,  -3.63636374
  32965,  -7.50118256,   75.2739716,  -3.63636374
  32966,   -7.7598443,   76.1454849,  -3.63636374
  32967,  -8.01850605,   77.0170059,  -3.63636374
  32968,  -8.27716732,   77.8885193,  -3.63636374
  32969,   -5.9492135,   70.0448761,   -4.5454545
  32970,  -6.20787525,   70.9163895,   -4.5454545
  32971,  -6.46653652,   71.7879028,   -4.5454545
  32972,  -6.72519779,   72.6594238,   -4.5454545
  32973,  -6.98385954,   73.5309372,   -4.5454545
  32974,  -7.24252129,   74.4024582,   -4.5454545
  32975,  -7.50118256,   75.2739716,   -4.5454545
  32976,   -7.7598443,   76.1454849,   -4.5454545
  32977,  -8.01850605,   77.0170059,   -4.5454545
  32978,  -8.27716732,   77.8885193,   -4.5454545
  32979,   -5.9492135,   70.0448761,   -5.4545455
  32980,  -6.20787525,   70.9163895,   -5.4545455
  32981,  -6.46653652,   71.7879028,   -5.4545455
  32982,  -6.72519779,   72.6594238,   -5.4545455
  32983,  -6.98385954,   73.5309372,   -5.4545455
  32984,  -7.24252129,   74.4024582,   -5.4545455
  32985,  -7.50118256,   75.2739716,   -5.4545455
  32986,   -7.7598443,   76.1454849,   -5.4545455
  32987,  -8.01850605,   77.0170059,   -5.4545455
  32988,  -8.27716732,   77.8885193,   -5.4545455
  32989,   -5.9492135,   70.0448761,  -6.36363649
  32990,  -6.20787525,   70.9163895,  -6.36363649
  32991,  -6.46653652,   71.7879028,  -6.36363649
  32992,  -6.72519779,   72.6594238,  -6.36363649
  32993,  -6.98385954,   73.5309372,  -6.36363649
  32994,  -7.24252129,   74.4024582,  -6.36363649
  32995,  -7.50118256,   75.2739716,  -6.36363649
  32996,   -7.7598443,   76.1454849,  -6.36363649
  32997,  -8.01850605,   77.0170059,  -6.36363649
  32998,  -8.27716732,   77.8885193,  -6.36363649
  32999,   -5.9492135,   70.0448761,  -7.27272749
  33000,  -6.20787525,   70.9163895,  -7.27272749
  33001,  -6.46653652,   71.7879028,  -7.27272749
  33002,  -6.72519779,   72.6594238,  -7.27272749
  33003,  -6.98385954,   73.5309372,  -7.27272749
  33004,  -7.24252129,   74.4024582,  -7.27272749
  33005,  -7.50118256,   75.2739716,  -7.27272749
  33006,   -7.7598443,   76.1454849,  -7.27272749
  33007,  -8.01850605,   77.0170059,  -7.27272749
  33008,  -8.27716732,   77.8885193,  -7.27272749
  33009,   -5.9492135,   70.0448761,  -8.18181801
  33010,  -6.20787525,   70.9163895,  -8.18181801
  33011,  -6.46653652,   71.7879028,  -8.18181801
  33012,  -6.72519779,   72.6594238,  -8.18181801
  33013,  -6.98385954,   73.5309372,  -8.18181801
  33014,  -7.24252129,   74.4024582,  -8.18181801
  33015,  -7.50118256,   75.2739716,  -8.18181801
  33016,   -7.7598443,   76.1454849,  -8.18181801
  33017,  -8.01850605,   77.0170059,  -8.18181801
  33018,  -8.27716732,   77.8885193,  -8.18181801
  33019,   -5.9492135,   70.0448761,    -9.090909
  33020,  -6.20787525,   70.9163895,    -9.090909
  33021,  -6.46653652,   71.7879028,    -9.090909
  33022,  -6.72519779,   72.6594238,    -9.090909
  33023,  -6.98385954,   73.5309372,    -9.090909
  33024,  -7.24252129,   74.4024582,    -9.090909
  33025,  -7.50118256,   75.2739716,    -9.090909
  33026,   -7.7598443,   76.1454849,    -9.090909
  33027,  -8.01850605,   77.0170059,    -9.090909
  33028,  -8.27716732,   77.8885193,    -9.090909
  33029,  -6.58862591,    69.843895, -0.909090936
  33030,  -6.87508774,   70.7066727, -0.909090936
  33031,  -7.16155005,   71.5694504, -0.909090936
  33032,  -7.44801188,   72.4322281, -0.909090936
  33033,  -7.73447418,   73.2950058, -0.909090936
  33034,  -8.02093601,   74.1577835, -0.909090936
  33035,   -8.3073988,   75.0205612, -0.909090936
  33036,  -8.59386063,   75.8833389, -0.909090936
  33037,  -8.88032246,   76.7461166, -0.909090936
  33038,  -9.16678429,   77.6088943, -0.909090936
  33039,  -6.58862591,    69.843895,  -1.81818187
  33040,  -6.87508774,   70.7066727,  -1.81818187
  33041,  -7.16155005,   71.5694504,  -1.81818187
  33042,  -7.44801188,   72.4322281,  -1.81818187
  33043,  -7.73447418,   73.2950058,  -1.81818187
  33044,  -8.02093601,   74.1577835,  -1.81818187
  33045,   -8.3073988,   75.0205612,  -1.81818187
  33046,  -8.59386063,   75.8833389,  -1.81818187
  33047,  -8.88032246,   76.7461166,  -1.81818187
  33048,  -9.16678429,   77.6088943,  -1.81818187
  33049,  -6.58862591,    69.843895,  -2.72727275
  33050,  -6.87508774,   70.7066727,  -2.72727275
  33051,  -7.16155005,   71.5694504,  -2.72727275
  33052,  -7.44801188,   72.4322281,  -2.72727275
  33053,  -7.73447418,   73.2950058,  -2.72727275
  33054,  -8.02093601,   74.1577835,  -2.72727275
  33055,   -8.3073988,   75.0205612,  -2.72727275
  33056,  -8.59386063,   75.8833389,  -2.72727275
  33057,  -8.88032246,   76.7461166,  -2.72727275
  33058,  -9.16678429,   77.6088943,  -2.72727275
  33059,  -6.58862591,    69.843895,  -3.63636374
  33060,  -6.87508774,   70.7066727,  -3.63636374
  33061,  -7.16155005,   71.5694504,  -3.63636374
  33062,  -7.44801188,   72.4322281,  -3.63636374
  33063,  -7.73447418,   73.2950058,  -3.63636374
  33064,  -8.02093601,   74.1577835,  -3.63636374
  33065,   -8.3073988,   75.0205612,  -3.63636374
  33066,  -8.59386063,   75.8833389,  -3.63636374
  33067,  -8.88032246,   76.7461166,  -3.63636374
  33068,  -9.16678429,   77.6088943,  -3.63636374
  33069,  -6.58862591,    69.843895,   -4.5454545
  33070,  -6.87508774,   70.7066727,   -4.5454545
  33071,  -7.16155005,   71.5694504,   -4.5454545
  33072,  -7.44801188,   72.4322281,   -4.5454545
  33073,  -7.73447418,   73.2950058,   -4.5454545
  33074,  -8.02093601,   74.1577835,   -4.5454545
  33075,   -8.3073988,   75.0205612,   -4.5454545
  33076,  -8.59386063,   75.8833389,   -4.5454545
  33077,  -8.88032246,   76.7461166,   -4.5454545
  33078,  -9.16678429,   77.6088943,   -4.5454545
  33079,  -6.58862591,    69.843895,   -5.4545455
  33080,  -6.87508774,   70.7066727,   -5.4545455
  33081,  -7.16155005,   71.5694504,   -5.4545455
  33082,  -7.44801188,   72.4322281,   -5.4545455
  33083,  -7.73447418,   73.2950058,   -5.4545455
  33084,  -8.02093601,   74.1577835,   -5.4545455
  33085,   -8.3073988,   75.0205612,   -5.4545455
  33086,  -8.59386063,   75.8833389,   -5.4545455
  33087,  -8.88032246,   76.7461166,   -5.4545455
  33088,  -9.16678429,   77.6088943,   -5.4545455
  33089,  -6.58862591,    69.843895,  -6.36363649
  33090,  -6.87508774,   70.7066727,  -6.36363649
  33091,  -7.16155005,   71.5694504,  -6.36363649
  33092,  -7.44801188,   72.4322281,  -6.36363649
  33093,  -7.73447418,   73.2950058,  -6.36363649
  33094,  -8.02093601,   74.1577835,  -6.36363649
  33095,   -8.3073988,   75.0205612,  -6.36363649
  33096,  -8.59386063,   75.8833389,  -6.36363649
  33097,  -8.88032246,   76.7461166,  -6.36363649
  33098,  -9.16678429,   77.6088943,  -6.36363649
  33099,  -6.58862591,    69.843895,  -7.27272749
  33100,  -6.87508774,   70.7066727,  -7.27272749
  33101,  -7.16155005,   71.5694504,  -7.27272749
  33102,  -7.44801188,   72.4322281,  -7.27272749
  33103,  -7.73447418,   73.2950058,  -7.27272749
  33104,  -8.02093601,   74.1577835,  -7.27272749
  33105,   -8.3073988,   75.0205612,  -7.27272749
  33106,  -8.59386063,   75.8833389,  -7.27272749
  33107,  -8.88032246,   76.7461166,  -7.27272749
  33108,  -9.16678429,   77.6088943,  -7.27272749
  33109,  -6.58862591,    69.843895,  -8.18181801
  33110,  -6.87508774,   70.7066727,  -8.18181801
  33111,  -7.16155005,   71.5694504,  -8.18181801
  33112,  -7.44801188,   72.4322281,  -8.18181801
  33113,  -7.73447418,   73.2950058,  -8.18181801
  33114,  -8.02093601,   74.1577835,  -8.18181801
  33115,   -8.3073988,   75.0205612,  -8.18181801
  33116,  -8.59386063,   75.8833389,  -8.18181801
  33117,  -8.88032246,   76.7461166,  -8.18181801
  33118,  -9.16678429,   77.6088943,  -8.18181801
  33119,  -6.58862591,    69.843895,    -9.090909
  33120,  -6.87508774,   70.7066727,    -9.090909
  33121,  -7.16155005,   71.5694504,    -9.090909
  33122,  -7.44801188,   72.4322281,    -9.090909
  33123,  -7.73447418,   73.2950058,    -9.090909
  33124,  -8.02093601,   74.1577835,    -9.090909
  33125,   -8.3073988,   75.0205612,    -9.090909
  33126,  -8.59386063,   75.8833389,    -9.090909
  33127,  -8.88032246,   76.7461166,    -9.090909
  33128,  -9.16678429,   77.6088943,    -9.090909
  33129,  -7.22126818,   69.6225204, -0.909090936
  33130,  -7.53523684,   70.4756775, -0.909090936
  33131,  -7.84920549,   71.3288269, -0.909090936
  33132,  -8.16317272,   72.1819839, -0.909090936
  33133,  -8.47714138,   73.0351334, -0.909090936
  33134,  -8.79111004,   73.8882904, -0.909090936
  33135,   -9.1050787,   74.7414398, -0.909090936
  33136,  -9.41904736,   75.5945969, -0.909090936
  33137,  -9.73301506,   76.4477463, -0.909090936
  33138,  -10.0469837,   77.3009033, -0.909090936
  33139,  -7.22126818,   69.6225204,  -1.81818187
  33140,  -7.53523684,   70.4756775,  -1.81818187
  33141,  -7.84920549,   71.3288269,  -1.81818187
  33142,  -8.16317272,   72.1819839,  -1.81818187
  33143,  -8.47714138,   73.0351334,  -1.81818187
  33144,  -8.79111004,   73.8882904,  -1.81818187
  33145,   -9.1050787,   74.7414398,  -1.81818187
  33146,  -9.41904736,   75.5945969,  -1.81818187
  33147,  -9.73301506,   76.4477463,  -1.81818187
  33148,  -10.0469837,   77.3009033,  -1.81818187
  33149,  -7.22126818,   69.6225204,  -2.72727275
  33150,  -7.53523684,   70.4756775,  -2.72727275
  33151,  -7.84920549,   71.3288269,  -2.72727275
  33152,  -8.16317272,   72.1819839,  -2.72727275
  33153,  -8.47714138,   73.0351334,  -2.72727275
  33154,  -8.79111004,   73.8882904,  -2.72727275
  33155,   -9.1050787,   74.7414398,  -2.72727275
  33156,  -9.41904736,   75.5945969,  -2.72727275
  33157,  -9.73301506,   76.4477463,  -2.72727275
  33158,  -10.0469837,   77.3009033,  -2.72727275
  33159,  -7.22126818,   69.6225204,  -3.63636374
  33160,  -7.53523684,   70.4756775,  -3.63636374
  33161,  -7.84920549,   71.3288269,  -3.63636374
  33162,  -8.16317272,   72.1819839,  -3.63636374
  33163,  -8.47714138,   73.0351334,  -3.63636374
  33164,  -8.79111004,   73.8882904,  -3.63636374
  33165,   -9.1050787,   74.7414398,  -3.63636374
  33166,  -9.41904736,   75.5945969,  -3.63636374
  33167,  -9.73301506,   76.4477463,  -3.63636374
  33168,  -10.0469837,   77.3009033,  -3.63636374
  33169,  -7.22126818,   69.6225204,   -4.5454545
  33170,  -7.53523684,   70.4756775,   -4.5454545
  33171,  -7.84920549,   71.3288269,   -4.5454545
  33172,  -8.16317272,   72.1819839,   -4.5454545
  33173,  -8.47714138,   73.0351334,   -4.5454545
  33174,  -8.79111004,   73.8882904,   -4.5454545
  33175,   -9.1050787,   74.7414398,   -4.5454545
  33176,  -9.41904736,   75.5945969,   -4.5454545
  33177,  -9.73301506,   76.4477463,   -4.5454545
  33178,  -10.0469837,   77.3009033,   -4.5454545
  33179,  -7.22126818,   69.6225204,   -5.4545455
  33180,  -7.53523684,   70.4756775,   -5.4545455
  33181,  -7.84920549,   71.3288269,   -5.4545455
  33182,  -8.16317272,   72.1819839,   -5.4545455
  33183,  -8.47714138,   73.0351334,   -5.4545455
  33184,  -8.79111004,   73.8882904,   -5.4545455
  33185,   -9.1050787,   74.7414398,   -5.4545455
  33186,  -9.41904736,   75.5945969,   -5.4545455
  33187,  -9.73301506,   76.4477463,   -5.4545455
  33188,  -10.0469837,   77.3009033,   -5.4545455
  33189,  -7.22126818,   69.6225204,  -6.36363649
  33190,  -7.53523684,   70.4756775,  -6.36363649
  33191,  -7.84920549,   71.3288269,  -6.36363649
  33192,  -8.16317272,   72.1819839,  -6.36363649
  33193,  -8.47714138,   73.0351334,  -6.36363649
  33194,  -8.79111004,   73.8882904,  -6.36363649
  33195,   -9.1050787,   74.7414398,  -6.36363649
  33196,  -9.41904736,   75.5945969,  -6.36363649
  33197,  -9.73301506,   76.4477463,  -6.36363649
  33198,  -10.0469837,   77.3009033,  -6.36363649
  33199,  -7.22126818,   69.6225204,  -7.27272749
  33200,  -7.53523684,   70.4756775,  -7.27272749
  33201,  -7.84920549,   71.3288269,  -7.27272749
  33202,  -8.16317272,   72.1819839,  -7.27272749
  33203,  -8.47714138,   73.0351334,  -7.27272749
  33204,  -8.79111004,   73.8882904,  -7.27272749
  33205,   -9.1050787,   74.7414398,  -7.27272749
  33206,  -9.41904736,   75.5945969,  -7.27272749
  33207,  -9.73301506,   76.4477463,  -7.27272749
  33208,  -10.0469837,   77.3009033,  -7.27272749
  33209,  -7.22126818,   69.6225204,  -8.18181801
  33210,  -7.53523684,   70.4756775,  -8.18181801
  33211,  -7.84920549,   71.3288269,  -8.18181801
  33212,  -8.16317272,   72.1819839,  -8.18181801
  33213,  -8.47714138,   73.0351334,  -8.18181801
  33214,  -8.79111004,   73.8882904,  -8.18181801
  33215,   -9.1050787,   74.7414398,  -8.18181801
  33216,  -9.41904736,   75.5945969,  -8.18181801
  33217,  -9.73301506,   76.4477463,  -8.18181801
  33218,  -10.0469837,   77.3009033,  -8.18181801
  33219,  -7.22126818,   69.6225204,    -9.090909
  33220,  -7.53523684,   70.4756775,    -9.090909
  33221,  -7.84920549,   71.3288269,    -9.090909
  33222,  -8.16317272,   72.1819839,    -9.090909
  33223,  -8.47714138,   73.0351334,    -9.090909
  33224,  -8.79111004,   73.8882904,    -9.090909
  33225,   -9.1050787,   74.7414398,    -9.090909
  33226,  -9.41904736,   75.5945969,    -9.090909
  33227,  -9.73301506,   76.4477463,    -9.090909
  33228,  -10.0469837,   77.3009033,    -9.090909
  33229,  -7.84649086,   69.3809891, -0.909090936
  33230,  -8.18764305,   70.2236404, -0.909090936
  33231,  -8.52879429,   71.0662918, -0.909090936
  33232,  -8.86994648,   71.9089432, -0.909090936
  33233,  -9.21109867,   72.7515945, -0.909090936
  33234,  -9.55225086,   73.5942459, -0.909090936
  33235,  -9.89340305,   74.4368973, -0.909090936
  33236,  -10.2345543,   75.2795486, -0.909090936
  33237,  -10.5757065,      76.1222, -0.909090936
  33238,  -10.9168587,   76.9648514, -0.909090936
  33239,  -7.84649086,   69.3809891,  -1.81818187
  33240,  -8.18764305,   70.2236404,  -1.81818187
  33241,  -8.52879429,   71.0662918,  -1.81818187
  33242,  -8.86994648,   71.9089432,  -1.81818187
  33243,  -9.21109867,   72.7515945,  -1.81818187
  33244,  -9.55225086,   73.5942459,  -1.81818187
  33245,  -9.89340305,   74.4368973,  -1.81818187
  33246,  -10.2345543,   75.2795486,  -1.81818187
  33247,  -10.5757065,      76.1222,  -1.81818187
  33248,  -10.9168587,   76.9648514,  -1.81818187
  33249,  -7.84649086,   69.3809891,  -2.72727275
  33250,  -8.18764305,   70.2236404,  -2.72727275
  33251,  -8.52879429,   71.0662918,  -2.72727275
  33252,  -8.86994648,   71.9089432,  -2.72727275
  33253,  -9.21109867,   72.7515945,  -2.72727275
  33254,  -9.55225086,   73.5942459,  -2.72727275
  33255,  -9.89340305,   74.4368973,  -2.72727275
  33256,  -10.2345543,   75.2795486,  -2.72727275
  33257,  -10.5757065,      76.1222,  -2.72727275
  33258,  -10.9168587,   76.9648514,  -2.72727275
  33259,  -7.84649086,   69.3809891,  -3.63636374
  33260,  -8.18764305,   70.2236404,  -3.63636374
  33261,  -8.52879429,   71.0662918,  -3.63636374
  33262,  -8.86994648,   71.9089432,  -3.63636374
  33263,  -9.21109867,   72.7515945,  -3.63636374
  33264,  -9.55225086,   73.5942459,  -3.63636374
  33265,  -9.89340305,   74.4368973,  -3.63636374
  33266,  -10.2345543,   75.2795486,  -3.63636374
  33267,  -10.5757065,      76.1222,  -3.63636374
  33268,  -10.9168587,   76.9648514,  -3.63636374
  33269,  -7.84649086,   69.3809891,   -4.5454545
  33270,  -8.18764305,   70.2236404,   -4.5454545
  33271,  -8.52879429,   71.0662918,   -4.5454545
  33272,  -8.86994648,   71.9089432,   -4.5454545
  33273,  -9.21109867,   72.7515945,   -4.5454545
  33274,  -9.55225086,   73.5942459,   -4.5454545
  33275,  -9.89340305,   74.4368973,   -4.5454545
  33276,  -10.2345543,   75.2795486,   -4.5454545
  33277,  -10.5757065,      76.1222,   -4.5454545
  33278,  -10.9168587,   76.9648514,   -4.5454545
  33279,  -7.84649086,   69.3809891,   -5.4545455
  33280,  -8.18764305,   70.2236404,   -5.4545455
  33281,  -8.52879429,   71.0662918,   -5.4545455
  33282,  -8.86994648,   71.9089432,   -5.4545455
  33283,  -9.21109867,   72.7515945,   -5.4545455
  33284,  -9.55225086,   73.5942459,   -5.4545455
  33285,  -9.89340305,   74.4368973,   -5.4545455
  33286,  -10.2345543,   75.2795486,   -5.4545455
  33287,  -10.5757065,      76.1222,   -5.4545455
  33288,  -10.9168587,   76.9648514,   -5.4545455
  33289,  -7.84649086,   69.3809891,  -6.36363649
  33290,  -8.18764305,   70.2236404,  -6.36363649
  33291,  -8.52879429,   71.0662918,  -6.36363649
  33292,  -8.86994648,   71.9089432,  -6.36363649
  33293,  -9.21109867,   72.7515945,  -6.36363649
  33294,  -9.55225086,   73.5942459,  -6.36363649
  33295,  -9.89340305,   74.4368973,  -6.36363649
  33296,  -10.2345543,   75.2795486,  -6.36363649
  33297,  -10.5757065,      76.1222,  -6.36363649
  33298,  -10.9168587,   76.9648514,  -6.36363649
  33299,  -7.84649086,   69.3809891,  -7.27272749
  33300,  -8.18764305,   70.2236404,  -7.27272749
  33301,  -8.52879429,   71.0662918,  -7.27272749
  33302,  -8.86994648,   71.9089432,  -7.27272749
  33303,  -9.21109867,   72.7515945,  -7.27272749
  33304,  -9.55225086,   73.5942459,  -7.27272749
  33305,  -9.89340305,   74.4368973,  -7.27272749
  33306,  -10.2345543,   75.2795486,  -7.27272749
  33307,  -10.5757065,      76.1222,  -7.27272749
  33308,  -10.9168587,   76.9648514,  -7.27272749
  33309,  -7.84649086,   69.3809891,  -8.18181801
  33310,  -8.18764305,   70.2236404,  -8.18181801
  33311,  -8.52879429,   71.0662918,  -8.18181801
  33312,  -8.86994648,   71.9089432,  -8.18181801
  33313,  -9.21109867,   72.7515945,  -8.18181801
  33314,  -9.55225086,   73.5942459,  -8.18181801
  33315,  -9.89340305,   74.4368973,  -8.18181801
  33316,  -10.2345543,   75.2795486,  -8.18181801
  33317,  -10.5757065,      76.1222,  -8.18181801
  33318,  -10.9168587,   76.9648514,  -8.18181801
  33319,  -7.84649086,   69.3809891,    -9.090909
  33320,  -8.18764305,   70.2236404,    -9.090909
  33321,  -8.52879429,   71.0662918,    -9.090909
  33322,  -8.86994648,   71.9089432,    -9.090909
  33323,  -9.21109867,   72.7515945,    -9.090909
  33324,  -9.55225086,   73.5942459,    -9.090909
  33325,  -9.89340305,   74.4368973,    -9.090909
  33326,  -10.2345543,   75.2795486,    -9.090909
  33327,  -10.5757065,      76.1222,    -9.090909
  33328,  -10.9168587,   76.9648514,    -9.090909
  33329,   -8.4636507,   69.1195374, -0.909090936
  33330,  -8.83163548,   69.9508209, -0.909090936
  33331,  -9.19962025,   70.7821045, -0.909090936
  33332,  -9.56760502,   71.6133881, -0.909090936
  33333,  -9.93558979,   72.4446716, -0.909090936
  33334,  -10.3035755,   73.2759552, -0.909090936
  33335,  -10.6715603,   74.1072388, -0.909090936
  33336,  -11.0395451,   74.9385223, -0.909090936
  33337,  -11.4075298,   75.7698135, -0.909090936
  33338,  -11.7755146,   76.6010971, -0.909090936
  33339,   -8.4636507,   69.1195374,  -1.81818187
  33340,  -8.83163548,   69.9508209,  -1.81818187
  33341,  -9.19962025,   70.7821045,  -1.81818187
  33342,  -9.56760502,   71.6133881,  -1.81818187
  33343,  -9.93558979,   72.4446716,  -1.81818187
  33344,  -10.3035755,   73.2759552,  -1.81818187
  33345,  -10.6715603,   74.1072388,  -1.81818187
  33346,  -11.0395451,   74.9385223,  -1.81818187
  33347,  -11.4075298,   75.7698135,  -1.81818187
  33348,  -11.7755146,   76.6010971,  -1.81818187
  33349,   -8.4636507,   69.1195374,  -2.72727275
  33350,  -8.83163548,   69.9508209,  -2.72727275
  33351,  -9.19962025,   70.7821045,  -2.72727275
  33352,  -9.56760502,   71.6133881,  -2.72727275
  33353,  -9.93558979,   72.4446716,  -2.72727275
  33354,  -10.3035755,   73.2759552,  -2.72727275
  33355,  -10.6715603,   74.1072388,  -2.72727275
  33356,  -11.0395451,   74.9385223,  -2.72727275
  33357,  -11.4075298,   75.7698135,  -2.72727275
  33358,  -11.7755146,   76.6010971,  -2.72727275
  33359,   -8.4636507,   69.1195374,  -3.63636374
  33360,  -8.83163548,   69.9508209,  -3.63636374
  33361,  -9.19962025,   70.7821045,  -3.63636374
  33362,  -9.56760502,   71.6133881,  -3.63636374
  33363,  -9.93558979,   72.4446716,  -3.63636374
  33364,  -10.3035755,   73.2759552,  -3.63636374
  33365,  -10.6715603,   74.1072388,  -3.63636374
  33366,  -11.0395451,   74.9385223,  -3.63636374
  33367,  -11.4075298,   75.7698135,  -3.63636374
  33368,  -11.7755146,   76.6010971,  -3.63636374
  33369,   -8.4636507,   69.1195374,   -4.5454545
  33370,  -8.83163548,   69.9508209,   -4.5454545
  33371,  -9.19962025,   70.7821045,   -4.5454545
  33372,  -9.56760502,   71.6133881,   -4.5454545
  33373,  -9.93558979,   72.4446716,   -4.5454545
  33374,  -10.3035755,   73.2759552,   -4.5454545
  33375,  -10.6715603,   74.1072388,   -4.5454545
  33376,  -11.0395451,   74.9385223,   -4.5454545
  33377,  -11.4075298,   75.7698135,   -4.5454545
  33378,  -11.7755146,   76.6010971,   -4.5454545
  33379,   -8.4636507,   69.1195374,   -5.4545455
  33380,  -8.83163548,   69.9508209,   -5.4545455
  33381,  -9.19962025,   70.7821045,   -5.4545455
  33382,  -9.56760502,   71.6133881,   -5.4545455
  33383,  -9.93558979,   72.4446716,   -5.4545455
  33384,  -10.3035755,   73.2759552,   -5.4545455
  33385,  -10.6715603,   74.1072388,   -5.4545455
  33386,  -11.0395451,   74.9385223,   -5.4545455
  33387,  -11.4075298,   75.7698135,   -5.4545455
  33388,  -11.7755146,   76.6010971,   -5.4545455
  33389,   -8.4636507,   69.1195374,  -6.36363649
  33390,  -8.83163548,   69.9508209,  -6.36363649
  33391,  -9.19962025,   70.7821045,  -6.36363649
  33392,  -9.56760502,   71.6133881,  -6.36363649
  33393,  -9.93558979,   72.4446716,  -6.36363649
  33394,  -10.3035755,   73.2759552,  -6.36363649
  33395,  -10.6715603,   74.1072388,  -6.36363649
  33396,  -11.0395451,   74.9385223,  -6.36363649
  33397,  -11.4075298,   75.7698135,  -6.36363649
  33398,  -11.7755146,   76.6010971,  -6.36363649
  33399,   -8.4636507,   69.1195374,  -7.27272749
  33400,  -8.83163548,   69.9508209,  -7.27272749
  33401,  -9.19962025,   70.7821045,  -7.27272749
  33402,  -9.56760502,   71.6133881,  -7.27272749
  33403,  -9.93558979,   72.4446716,  -7.27272749
  33404,  -10.3035755,   73.2759552,  -7.27272749
  33405,  -10.6715603,   74.1072388,  -7.27272749
  33406,  -11.0395451,   74.9385223,  -7.27272749
  33407,  -11.4075298,   75.7698135,  -7.27272749
  33408,  -11.7755146,   76.6010971,  -7.27272749
  33409,   -8.4636507,   69.1195374,  -8.18181801
  33410,  -8.83163548,   69.9508209,  -8.18181801
  33411,  -9.19962025,   70.7821045,  -8.18181801
  33412,  -9.56760502,   71.6133881,  -8.18181801
  33413,  -9.93558979,   72.4446716,  -8.18181801
  33414,  -10.3035755,   73.2759552,  -8.18181801
  33415,  -10.6715603,   74.1072388,  -8.18181801
  33416,  -11.0395451,   74.9385223,  -8.18181801
  33417,  -11.4075298,   75.7698135,  -8.18181801
  33418,  -11.7755146,   76.6010971,  -8.18181801
  33419,   -8.4636507,   69.1195374,    -9.090909
  33420,  -8.83163548,   69.9508209,    -9.090909
  33421,  -9.19962025,   70.7821045,    -9.090909
  33422,  -9.56760502,   71.6133881,    -9.090909
  33423,  -9.93558979,   72.4446716,    -9.090909
  33424,  -10.3035755,   73.2759552,    -9.090909
  33425,  -10.6715603,   74.1072388,    -9.090909
  33426,  -11.0395451,   74.9385223,    -9.090909
  33427,  -11.4075298,   75.7698135,    -9.090909
  33428,  -11.7755146,   76.6010971,    -9.090909
  33429,  -9.07211399,   68.8384399, -0.909090936
  33430,  -9.46655369,   69.6575012, -0.909090936
  33431,  -9.86099339,   70.4765625, -0.909090936
  33432,  -10.2554331,   71.2956314, -0.909090936
  33433,  -10.6498728,   72.1146927, -0.909090936
  33434,  -11.0443125,    72.933754, -0.909090936
  33435,  -11.4387522,   73.7528152, -0.909090936
  33436,  -11.8331919,   74.5718765, -0.909090936
  33437,  -12.2276316,   75.3909378, -0.909090936
  33438,  -12.6220713,   76.2100067, -0.909090936
  33439,  -9.07211399,   68.8384399,  -1.81818187
  33440,  -9.46655369,   69.6575012,  -1.81818187
  33441,  -9.86099339,   70.4765625,  -1.81818187
  33442,  -10.2554331,   71.2956314,  -1.81818187
  33443,  -10.6498728,   72.1146927,  -1.81818187
  33444,  -11.0443125,    72.933754,  -1.81818187
  33445,  -11.4387522,   73.7528152,  -1.81818187
  33446,  -11.8331919,   74.5718765,  -1.81818187
  33447,  -12.2276316,   75.3909378,  -1.81818187
  33448,  -12.6220713,   76.2100067,  -1.81818187
  33449,  -9.07211399,   68.8384399,  -2.72727275
  33450,  -9.46655369,   69.6575012,  -2.72727275
  33451,  -9.86099339,   70.4765625,  -2.72727275
  33452,  -10.2554331,   71.2956314,  -2.72727275
  33453,  -10.6498728,   72.1146927,  -2.72727275
  33454,  -11.0443125,    72.933754,  -2.72727275
  33455,  -11.4387522,   73.7528152,  -2.72727275
  33456,  -11.8331919,   74.5718765,  -2.72727275
  33457,  -12.2276316,   75.3909378,  -2.72727275
  33458,  -12.6220713,   76.2100067,  -2.72727275
  33459,  -9.07211399,   68.8384399,  -3.63636374
  33460,  -9.46655369,   69.6575012,  -3.63636374
  33461,  -9.86099339,   70.4765625,  -3.63636374
  33462,  -10.2554331,   71.2956314,  -3.63636374
  33463,  -10.6498728,   72.1146927,  -3.63636374
  33464,  -11.0443125,    72.933754,  -3.63636374
  33465,  -11.4387522,   73.7528152,  -3.63636374
  33466,  -11.8331919,   74.5718765,  -3.63636374
  33467,  -12.2276316,   75.3909378,  -3.63636374
  33468,  -12.6220713,   76.2100067,  -3.63636374
  33469,  -9.07211399,   68.8384399,   -4.5454545
  33470,  -9.46655369,   69.6575012,   -4.5454545
  33471,  -9.86099339,   70.4765625,   -4.5454545
  33472,  -10.2554331,   71.2956314,   -4.5454545
  33473,  -10.6498728,   72.1146927,   -4.5454545
  33474,  -11.0443125,    72.933754,   -4.5454545
  33475,  -11.4387522,   73.7528152,   -4.5454545
  33476,  -11.8331919,   74.5718765,   -4.5454545
  33477,  -12.2276316,   75.3909378,   -4.5454545
  33478,  -12.6220713,   76.2100067,   -4.5454545
  33479,  -9.07211399,   68.8384399,   -5.4545455
  33480,  -9.46655369,   69.6575012,   -5.4545455
  33481,  -9.86099339,   70.4765625,   -5.4545455
  33482,  -10.2554331,   71.2956314,   -5.4545455
  33483,  -10.6498728,   72.1146927,   -5.4545455
  33484,  -11.0443125,    72.933754,   -5.4545455
  33485,  -11.4387522,   73.7528152,   -5.4545455
  33486,  -11.8331919,   74.5718765,   -5.4545455
  33487,  -12.2276316,   75.3909378,   -5.4545455
  33488,  -12.6220713,   76.2100067,   -5.4545455
  33489,  -9.07211399,   68.8384399,  -6.36363649
  33490,  -9.46655369,   69.6575012,  -6.36363649
  33491,  -9.86099339,   70.4765625,  -6.36363649
  33492,  -10.2554331,   71.2956314,  -6.36363649
  33493,  -10.6498728,   72.1146927,  -6.36363649
  33494,  -11.0443125,    72.933754,  -6.36363649
  33495,  -11.4387522,   73.7528152,  -6.36363649
  33496,  -11.8331919,   74.5718765,  -6.36363649
  33497,  -12.2276316,   75.3909378,  -6.36363649
  33498,  -12.6220713,   76.2100067,  -6.36363649
  33499,  -9.07211399,   68.8384399,  -7.27272749
  33500,  -9.46655369,   69.6575012,  -7.27272749
  33501,  -9.86099339,   70.4765625,  -7.27272749
  33502,  -10.2554331,   71.2956314,  -7.27272749
  33503,  -10.6498728,   72.1146927,  -7.27272749
  33504,  -11.0443125,    72.933754,  -7.27272749
  33505,  -11.4387522,   73.7528152,  -7.27272749
  33506,  -11.8331919,   74.5718765,  -7.27272749
  33507,  -12.2276316,   75.3909378,  -7.27272749
  33508,  -12.6220713,   76.2100067,  -7.27272749
  33509,  -9.07211399,   68.8384399,  -8.18181801
  33510,  -9.46655369,   69.6575012,  -8.18181801
  33511,  -9.86099339,   70.4765625,  -8.18181801
  33512,  -10.2554331,   71.2956314,  -8.18181801
  33513,  -10.6498728,   72.1146927,  -8.18181801
  33514,  -11.0443125,    72.933754,  -8.18181801
  33515,  -11.4387522,   73.7528152,  -8.18181801
  33516,  -11.8331919,   74.5718765,  -8.18181801
  33517,  -12.2276316,   75.3909378,  -8.18181801
  33518,  -12.6220713,   76.2100067,  -8.18181801
  33519,  -9.07211399,   68.8384399,    -9.090909
  33520,  -9.46655369,   69.6575012,    -9.090909
  33521,  -9.86099339,   70.4765625,    -9.090909
  33522,  -10.2554331,   71.2956314,    -9.090909
  33523,  -10.6498728,   72.1146927,    -9.090909
  33524,  -11.0443125,    72.933754,    -9.090909
  33525,  -11.4387522,   73.7528152,    -9.090909
  33526,  -11.8331919,   74.5718765,    -9.090909
  33527,  -12.2276316,   75.3909378,    -9.090909
  33528,  -12.6220713,   76.2100067,    -9.090909
  33529,  -9.67125511,   68.5379868, -0.909090936
  33530,  -10.0917444,   69.3439865, -0.909090936
  33531,  -10.5122337,   70.1499863, -0.909090936
  33532,   -10.932723,    70.955986, -0.909090936
  33533,  -11.3532124,   71.7619858, -0.909090936
  33534,  -11.7737026,   72.5679855, -0.909090936
  33535,  -12.1941919,   73.3739853, -0.909090936
  33536,  -12.6146812,   74.1799774, -0.909090936
  33537,  -13.0351706,   74.9859772, -0.909090936
  33538,  -13.4556599,   75.7919769, -0.909090936
  33539,  -9.67125511,   68.5379868,  -1.81818187
  33540,  -10.0917444,   69.3439865,  -1.81818187
  33541,  -10.5122337,   70.1499863,  -1.81818187
  33542,   -10.932723,    70.955986,  -1.81818187
  33543,  -11.3532124,   71.7619858,  -1.81818187
  33544,  -11.7737026,   72.5679855,  -1.81818187
  33545,  -12.1941919,   73.3739853,  -1.81818187
  33546,  -12.6146812,   74.1799774,  -1.81818187
  33547,  -13.0351706,   74.9859772,  -1.81818187
  33548,  -13.4556599,   75.7919769,  -1.81818187
  33549,  -9.67125511,   68.5379868,  -2.72727275
  33550,  -10.0917444,   69.3439865,  -2.72727275
  33551,  -10.5122337,   70.1499863,  -2.72727275
  33552,   -10.932723,    70.955986,  -2.72727275
  33553,  -11.3532124,   71.7619858,  -2.72727275
  33554,  -11.7737026,   72.5679855,  -2.72727275
  33555,  -12.1941919,   73.3739853,  -2.72727275
  33556,  -12.6146812,   74.1799774,  -2.72727275
  33557,  -13.0351706,   74.9859772,  -2.72727275
  33558,  -13.4556599,   75.7919769,  -2.72727275
  33559,  -9.67125511,   68.5379868,  -3.63636374
  33560,  -10.0917444,   69.3439865,  -3.63636374
  33561,  -10.5122337,   70.1499863,  -3.63636374
  33562,   -10.932723,    70.955986,  -3.63636374
  33563,  -11.3532124,   71.7619858,  -3.63636374
  33564,  -11.7737026,   72.5679855,  -3.63636374
  33565,  -12.1941919,   73.3739853,  -3.63636374
  33566,  -12.6146812,   74.1799774,  -3.63636374
  33567,  -13.0351706,   74.9859772,  -3.63636374
  33568,  -13.4556599,   75.7919769,  -3.63636374
  33569,  -9.67125511,   68.5379868,   -4.5454545
  33570,  -10.0917444,   69.3439865,   -4.5454545
  33571,  -10.5122337,   70.1499863,   -4.5454545
  33572,   -10.932723,    70.955986,   -4.5454545
  33573,  -11.3532124,   71.7619858,   -4.5454545
  33574,  -11.7737026,   72.5679855,   -4.5454545
  33575,  -12.1941919,   73.3739853,   -4.5454545
  33576,  -12.6146812,   74.1799774,   -4.5454545
  33577,  -13.0351706,   74.9859772,   -4.5454545
  33578,  -13.4556599,   75.7919769,   -4.5454545
  33579,  -9.67125511,   68.5379868,   -5.4545455
  33580,  -10.0917444,   69.3439865,   -5.4545455
  33581,  -10.5122337,   70.1499863,   -5.4545455
  33582,   -10.932723,    70.955986,   -5.4545455
  33583,  -11.3532124,   71.7619858,   -5.4545455
  33584,  -11.7737026,   72.5679855,   -5.4545455
  33585,  -12.1941919,   73.3739853,   -5.4545455
  33586,  -12.6146812,   74.1799774,   -5.4545455
  33587,  -13.0351706,   74.9859772,   -5.4545455
  33588,  -13.4556599,   75.7919769,   -5.4545455
  33589,  -9.67125511,   68.5379868,  -6.36363649
  33590,  -10.0917444,   69.3439865,  -6.36363649
  33591,  -10.5122337,   70.1499863,  -6.36363649
  33592,   -10.932723,    70.955986,  -6.36363649
  33593,  -11.3532124,   71.7619858,  -6.36363649
  33594,  -11.7737026,   72.5679855,  -6.36363649
  33595,  -12.1941919,   73.3739853,  -6.36363649
  33596,  -12.6146812,   74.1799774,  -6.36363649
  33597,  -13.0351706,   74.9859772,  -6.36363649
  33598,  -13.4556599,   75.7919769,  -6.36363649
  33599,  -9.67125511,   68.5379868,  -7.27272749
  33600,  -10.0917444,   69.3439865,  -7.27272749
  33601,  -10.5122337,   70.1499863,  -7.27272749
  33602,   -10.932723,    70.955986,  -7.27272749
  33603,  -11.3532124,   71.7619858,  -7.27272749
  33604,  -11.7737026,   72.5679855,  -7.27272749
  33605,  -12.1941919,   73.3739853,  -7.27272749
  33606,  -12.6146812,   74.1799774,  -7.27272749
  33607,  -13.0351706,   74.9859772,  -7.27272749
  33608,  -13.4556599,   75.7919769,  -7.27272749
  33609,  -9.67125511,   68.5379868,  -8.18181801
  33610,  -10.0917444,   69.3439865,  -8.18181801
  33611,  -10.5122337,   70.1499863,  -8.18181801
  33612,   -10.932723,    70.955986,  -8.18181801
  33613,  -11.3532124,   71.7619858,  -8.18181801
  33614,  -11.7737026,   72.5679855,  -8.18181801
  33615,  -12.1941919,   73.3739853,  -8.18181801
  33616,  -12.6146812,   74.1799774,  -8.18181801
  33617,  -13.0351706,   74.9859772,  -8.18181801
  33618,  -13.4556599,   75.7919769,  -8.18181801
  33619,  -9.67125511,   68.5379868,    -9.090909
  33620,  -10.0917444,   69.3439865,    -9.090909
  33621,  -10.5122337,   70.1499863,    -9.090909
  33622,   -10.932723,    70.955986,    -9.090909
  33623,  -11.3532124,   71.7619858,    -9.090909
  33624,  -11.7737026,   72.5679855,    -9.090909
  33625,  -12.1941919,   73.3739853,    -9.090909
  33626,  -12.6146812,   74.1799774,    -9.090909
  33627,  -13.0351706,   74.9859772,    -9.090909
  33628,  -13.4556599,   75.7919769,    -9.090909
  33629,   -10.260457,    68.218483, -0.909090936
  33630,  -10.7065639,   69.0105896, -0.909090936
  33631,  -11.1526709,   69.8026962, -0.909090936
  33632,  -11.5987778,   70.5948029, -0.909090936
  33633,  -12.0448847,   71.3869171, -0.909090936
  33634,  -12.4909916,   72.1790237, -0.909090936
  33635,  -12.9370985,   72.9711304, -0.909090936
  33636,  -13.3832054,    73.763237, -0.909090936
  33637,  -13.8293123,   74.5553436, -0.909090936
  33638,  -14.2754183,   75.3474503, -0.909090936
  33639,   -10.260457,    68.218483,  -1.81818187
  33640,  -10.7065639,   69.0105896,  -1.81818187
  33641,  -11.1526709,   69.8026962,  -1.81818187
  33642,  -11.5987778,   70.5948029,  -1.81818187
  33643,  -12.0448847,   71.3869171,  -1.81818187
  33644,  -12.4909916,   72.1790237,  -1.81818187
  33645,  -12.9370985,   72.9711304,  -1.81818187
  33646,  -13.3832054,    73.763237,  -1.81818187
  33647,  -13.8293123,   74.5553436,  -1.81818187
  33648,  -14.2754183,   75.3474503,  -1.81818187
  33649,   -10.260457,    68.218483,  -2.72727275
  33650,  -10.7065639,   69.0105896,  -2.72727275
  33651,  -11.1526709,   69.8026962,  -2.72727275
  33652,  -11.5987778,   70.5948029,  -2.72727275
  33653,  -12.0448847,   71.3869171,  -2.72727275
  33654,  -12.4909916,   72.1790237,  -2.72727275
  33655,  -12.9370985,   72.9711304,  -2.72727275
  33656,  -13.3832054,    73.763237,  -2.72727275
  33657,  -13.8293123,   74.5553436,  -2.72727275
  33658,  -14.2754183,   75.3474503,  -2.72727275
  33659,   -10.260457,    68.218483,  -3.63636374
  33660,  -10.7065639,   69.0105896,  -3.63636374
  33661,  -11.1526709,   69.8026962,  -3.63636374
  33662,  -11.5987778,   70.5948029,  -3.63636374
  33663,  -12.0448847,   71.3869171,  -3.63636374
  33664,  -12.4909916,   72.1790237,  -3.63636374
  33665,  -12.9370985,   72.9711304,  -3.63636374
  33666,  -13.3832054,    73.763237,  -3.63636374
  33667,  -13.8293123,   74.5553436,  -3.63636374
  33668,  -14.2754183,   75.3474503,  -3.63636374
  33669,   -10.260457,    68.218483,   -4.5454545
  33670,  -10.7065639,   69.0105896,   -4.5454545
  33671,  -11.1526709,   69.8026962,   -4.5454545
  33672,  -11.5987778,   70.5948029,   -4.5454545
  33673,  -12.0448847,   71.3869171,   -4.5454545
  33674,  -12.4909916,   72.1790237,   -4.5454545
  33675,  -12.9370985,   72.9711304,   -4.5454545
  33676,  -13.3832054,    73.763237,   -4.5454545
  33677,  -13.8293123,   74.5553436,   -4.5454545
  33678,  -14.2754183,   75.3474503,   -4.5454545
  33679,   -10.260457,    68.218483,   -5.4545455
  33680,  -10.7065639,   69.0105896,   -5.4545455
  33681,  -11.1526709,   69.8026962,   -5.4545455
  33682,  -11.5987778,   70.5948029,   -5.4545455
  33683,  -12.0448847,   71.3869171,   -5.4545455
  33684,  -12.4909916,   72.1790237,   -5.4545455
  33685,  -12.9370985,   72.9711304,   -5.4545455
  33686,  -13.3832054,    73.763237,   -5.4545455
  33687,  -13.8293123,   74.5553436,   -5.4545455
  33688,  -14.2754183,   75.3474503,   -5.4545455
  33689,   -10.260457,    68.218483,  -6.36363649
  33690,  -10.7065639,   69.0105896,  -6.36363649
  33691,  -11.1526709,   69.8026962,  -6.36363649
  33692,  -11.5987778,   70.5948029,  -6.36363649
  33693,  -12.0448847,   71.3869171,  -6.36363649
  33694,  -12.4909916,   72.1790237,  -6.36363649
  33695,  -12.9370985,   72.9711304,  -6.36363649
  33696,  -13.3832054,    73.763237,  -6.36363649
  33697,  -13.8293123,   74.5553436,  -6.36363649
  33698,  -14.2754183,   75.3474503,  -6.36363649
  33699,   -10.260457,    68.218483,  -7.27272749
  33700,  -10.7065639,   69.0105896,  -7.27272749
  33701,  -11.1526709,   69.8026962,  -7.27272749
  33702,  -11.5987778,   70.5948029,  -7.27272749
  33703,  -12.0448847,   71.3869171,  -7.27272749
  33704,  -12.4909916,   72.1790237,  -7.27272749
  33705,  -12.9370985,   72.9711304,  -7.27272749
  33706,  -13.3832054,    73.763237,  -7.27272749
  33707,  -13.8293123,   74.5553436,  -7.27272749
  33708,  -14.2754183,   75.3474503,  -7.27272749
  33709,   -10.260457,    68.218483,  -8.18181801
  33710,  -10.7065639,   69.0105896,  -8.18181801
  33711,  -11.1526709,   69.8026962,  -8.18181801
  33712,  -11.5987778,   70.5948029,  -8.18181801
  33713,  -12.0448847,   71.3869171,  -8.18181801
  33714,  -12.4909916,   72.1790237,  -8.18181801
  33715,  -12.9370985,   72.9711304,  -8.18181801
  33716,  -13.3832054,    73.763237,  -8.18181801
  33717,  -13.8293123,   74.5553436,  -8.18181801
  33718,  -14.2754183,   75.3474503,  -8.18181801
  33719,   -10.260457,    68.218483,    -9.090909
  33720,  -10.7065639,   69.0105896,    -9.090909
  33721,  -11.1526709,   69.8026962,    -9.090909
  33722,  -11.5987778,   70.5948029,    -9.090909
  33723,  -12.0448847,   71.3869171,    -9.090909
  33724,  -12.4909916,   72.1790237,    -9.090909
  33725,  -12.9370985,   72.9711304,    -9.090909
  33726,  -13.3832054,    73.763237,    -9.090909
  33727,  -13.8293123,   74.5553436,    -9.090909
  33728,  -14.2754183,   75.3474503,    -9.090909
  33729,   -10.839119,   67.8802567, -0.909090936
  33730,  -11.3103848,   68.6576614, -0.909090936
  33731,  -11.7816515,   69.4350662, -0.909090936
  33732,  -12.2529173,   70.2124634, -0.909090936
  33733,  -12.7241831,   70.9898682, -0.909090936
  33734,  -13.1954479,   71.7672729, -0.909090936
  33735,  -13.6667137,   72.5446701, -0.909090936
  33736,  -14.1379805,   73.3220749, -0.909090936
  33737,  -14.6092463,   74.0994797, -0.909090936
  33738,   -15.080512,   74.8768768, -0.909090936
  33739,   -10.839119,   67.8802567,  -1.81818187
  33740,  -11.3103848,   68.6576614,  -1.81818187
  33741,  -11.7816515,   69.4350662,  -1.81818187
  33742,  -12.2529173,   70.2124634,  -1.81818187
  33743,  -12.7241831,   70.9898682,  -1.81818187
  33744,  -13.1954479,   71.7672729,  -1.81818187
  33745,  -13.6667137,   72.5446701,  -1.81818187
  33746,  -14.1379805,   73.3220749,  -1.81818187
  33747,  -14.6092463,   74.0994797,  -1.81818187
  33748,   -15.080512,   74.8768768,  -1.81818187
  33749,   -10.839119,   67.8802567,  -2.72727275
  33750,  -11.3103848,   68.6576614,  -2.72727275
  33751,  -11.7816515,   69.4350662,  -2.72727275
  33752,  -12.2529173,   70.2124634,  -2.72727275
  33753,  -12.7241831,   70.9898682,  -2.72727275
  33754,  -13.1954479,   71.7672729,  -2.72727275
  33755,  -13.6667137,   72.5446701,  -2.72727275
  33756,  -14.1379805,   73.3220749,  -2.72727275
  33757,  -14.6092463,   74.0994797,  -2.72727275
  33758,   -15.080512,   74.8768768,  -2.72727275
  33759,   -10.839119,   67.8802567,  -3.63636374
  33760,  -11.3103848,   68.6576614,  -3.63636374
  33761,  -11.7816515,   69.4350662,  -3.63636374
  33762,  -12.2529173,   70.2124634,  -3.63636374
  33763,  -12.7241831,   70.9898682,  -3.63636374
  33764,  -13.1954479,   71.7672729,  -3.63636374
  33765,  -13.6667137,   72.5446701,  -3.63636374
  33766,  -14.1379805,   73.3220749,  -3.63636374
  33767,  -14.6092463,   74.0994797,  -3.63636374
  33768,   -15.080512,   74.8768768,  -3.63636374
  33769,   -10.839119,   67.8802567,   -4.5454545
  33770,  -11.3103848,   68.6576614,   -4.5454545
  33771,  -11.7816515,   69.4350662,   -4.5454545
  33772,  -12.2529173,   70.2124634,   -4.5454545
  33773,  -12.7241831,   70.9898682,   -4.5454545
  33774,  -13.1954479,   71.7672729,   -4.5454545
  33775,  -13.6667137,   72.5446701,   -4.5454545
  33776,  -14.1379805,   73.3220749,   -4.5454545
  33777,  -14.6092463,   74.0994797,   -4.5454545
  33778,   -15.080512,   74.8768768,   -4.5454545
  33779,   -10.839119,   67.8802567,   -5.4545455
  33780,  -11.3103848,   68.6576614,   -5.4545455
  33781,  -11.7816515,   69.4350662,   -5.4545455
  33782,  -12.2529173,   70.2124634,   -5.4545455
  33783,  -12.7241831,   70.9898682,   -5.4545455
  33784,  -13.1954479,   71.7672729,   -5.4545455
  33785,  -13.6667137,   72.5446701,   -5.4545455
  33786,  -14.1379805,   73.3220749,   -5.4545455
  33787,  -14.6092463,   74.0994797,   -5.4545455
  33788,   -15.080512,   74.8768768,   -5.4545455
  33789,   -10.839119,   67.8802567,  -6.36363649
  33790,  -11.3103848,   68.6576614,  -6.36363649
  33791,  -11.7816515,   69.4350662,  -6.36363649
  33792,  -12.2529173,   70.2124634,  -6.36363649
  33793,  -12.7241831,   70.9898682,  -6.36363649
  33794,  -13.1954479,   71.7672729,  -6.36363649
  33795,  -13.6667137,   72.5446701,  -6.36363649
  33796,  -14.1379805,   73.3220749,  -6.36363649
  33797,  -14.6092463,   74.0994797,  -6.36363649
  33798,   -15.080512,   74.8768768,  -6.36363649
  33799,   -10.839119,   67.8802567,  -7.27272749
  33800,  -11.3103848,   68.6576614,  -7.27272749
  33801,  -11.7816515,   69.4350662,  -7.27272749
  33802,  -12.2529173,   70.2124634,  -7.27272749
  33803,  -12.7241831,   70.9898682,  -7.27272749
  33804,  -13.1954479,   71.7672729,  -7.27272749
  33805,  -13.6667137,   72.5446701,  -7.27272749
  33806,  -14.1379805,   73.3220749,  -7.27272749
  33807,  -14.6092463,   74.0994797,  -7.27272749
  33808,   -15.080512,   74.8768768,  -7.27272749
  33809,   -10.839119,   67.8802567,  -8.18181801
  33810,  -11.3103848,   68.6576614,  -8.18181801
  33811,  -11.7816515,   69.4350662,  -8.18181801
  33812,  -12.2529173,   70.2124634,  -8.18181801
  33813,  -12.7241831,   70.9898682,  -8.18181801
  33814,  -13.1954479,   71.7672729,  -8.18181801
  33815,  -13.6667137,   72.5446701,  -8.18181801
  33816,  -14.1379805,   73.3220749,  -8.18181801
  33817,  -14.6092463,   74.0994797,  -8.18181801
  33818,   -15.080512,   74.8768768,  -8.18181801
  33819,   -10.839119,   67.8802567,    -9.090909
  33820,  -11.3103848,   68.6576614,    -9.090909
  33821,  -11.7816515,   69.4350662,    -9.090909
  33822,  -12.2529173,   70.2124634,    -9.090909
  33823,  -12.7241831,   70.9898682,    -9.090909
  33824,  -13.1954479,   71.7672729,    -9.090909
  33825,  -13.6667137,   72.5446701,    -9.090909
  33826,  -14.1379805,   73.3220749,    -9.090909
  33827,  -14.6092463,   74.0994797,    -9.090909
  33828,   -15.080512,   74.8768768,    -9.090909
  33829,  -11.4066381,   67.5236588, -0.909090936
  33830,  -11.9025784,   68.2855606, -0.909090936
  33831,  -12.3985195,   69.0474548, -0.909090936
  33832,  -12.8944607,   69.8093567, -0.909090936
  33833,  -13.3904009,   70.5712509, -0.909090936
  33834,  -13.8863411,   71.3331528, -0.909090936
  33835,  -14.3822823,    72.095047, -0.909090936
  33836,  -14.8782225,   72.8569489, -0.909090936
  33837,  -15.3741636,   73.6188431, -0.909090936
  33838,  -15.8701038,   74.3807449, -0.909090936
  33839,  -11.4066381,   67.5236588,  -1.81818187
  33840,  -11.9025784,   68.2855606,  -1.81818187
  33841,  -12.3985195,   69.0474548,  -1.81818187
  33842,  -12.8944607,   69.8093567,  -1.81818187
  33843,  -13.3904009,   70.5712509,  -1.81818187
  33844,  -13.8863411,   71.3331528,  -1.81818187
  33845,  -14.3822823,    72.095047,  -1.81818187
  33846,  -14.8782225,   72.8569489,  -1.81818187
  33847,  -15.3741636,   73.6188431,  -1.81818187
  33848,  -15.8701038,   74.3807449,  -1.81818187
  33849,  -11.4066381,   67.5236588,  -2.72727275
  33850,  -11.9025784,   68.2855606,  -2.72727275
  33851,  -12.3985195,   69.0474548,  -2.72727275
  33852,  -12.8944607,   69.8093567,  -2.72727275
  33853,  -13.3904009,   70.5712509,  -2.72727275
  33854,  -13.8863411,   71.3331528,  -2.72727275
  33855,  -14.3822823,    72.095047,  -2.72727275
  33856,  -14.8782225,   72.8569489,  -2.72727275
  33857,  -15.3741636,   73.6188431,  -2.72727275
  33858,  -15.8701038,   74.3807449,  -2.72727275
  33859,  -11.4066381,   67.5236588,  -3.63636374
  33860,  -11.9025784,   68.2855606,  -3.63636374
  33861,  -12.3985195,   69.0474548,  -3.63636374
  33862,  -12.8944607,   69.8093567,  -3.63636374
  33863,  -13.3904009,   70.5712509,  -3.63636374
  33864,  -13.8863411,   71.3331528,  -3.63636374
  33865,  -14.3822823,    72.095047,  -3.63636374
  33866,  -14.8782225,   72.8569489,  -3.63636374
  33867,  -15.3741636,   73.6188431,  -3.63636374
  33868,  -15.8701038,   74.3807449,  -3.63636374
  33869,  -11.4066381,   67.5236588,   -4.5454545
  33870,  -11.9025784,   68.2855606,   -4.5454545
  33871,  -12.3985195,   69.0474548,   -4.5454545
  33872,  -12.8944607,   69.8093567,   -4.5454545
  33873,  -13.3904009,   70.5712509,   -4.5454545
  33874,  -13.8863411,   71.3331528,   -4.5454545
  33875,  -14.3822823,    72.095047,   -4.5454545
  33876,  -14.8782225,   72.8569489,   -4.5454545
  33877,  -15.3741636,   73.6188431,   -4.5454545
  33878,  -15.8701038,   74.3807449,   -4.5454545
  33879,  -11.4066381,   67.5236588,   -5.4545455
  33880,  -11.9025784,   68.2855606,   -5.4545455
  33881,  -12.3985195,   69.0474548,   -5.4545455
  33882,  -12.8944607,   69.8093567,   -5.4545455
  33883,  -13.3904009,   70.5712509,   -5.4545455
  33884,  -13.8863411,   71.3331528,   -5.4545455
  33885,  -14.3822823,    72.095047,   -5.4545455
  33886,  -14.8782225,   72.8569489,   -5.4545455
  33887,  -15.3741636,   73.6188431,   -5.4545455
  33888,  -15.8701038,   74.3807449,   -5.4545455
  33889,  -11.4066381,   67.5236588,  -6.36363649
  33890,  -11.9025784,   68.2855606,  -6.36363649
  33891,  -12.3985195,   69.0474548,  -6.36363649
  33892,  -12.8944607,   69.8093567,  -6.36363649
  33893,  -13.3904009,   70.5712509,  -6.36363649
  33894,  -13.8863411,   71.3331528,  -6.36363649
  33895,  -14.3822823,    72.095047,  -6.36363649
  33896,  -14.8782225,   72.8569489,  -6.36363649
  33897,  -15.3741636,   73.6188431,  -6.36363649
  33898,  -15.8701038,   74.3807449,  -6.36363649
  33899,  -11.4066381,   67.5236588,  -7.27272749
  33900,  -11.9025784,   68.2855606,  -7.27272749
  33901,  -12.3985195,   69.0474548,  -7.27272749
  33902,  -12.8944607,   69.8093567,  -7.27272749
  33903,  -13.3904009,   70.5712509,  -7.27272749
  33904,  -13.8863411,   71.3331528,  -7.27272749
  33905,  -14.3822823,    72.095047,  -7.27272749
  33906,  -14.8782225,   72.8569489,  -7.27272749
  33907,  -15.3741636,   73.6188431,  -7.27272749
  33908,  -15.8701038,   74.3807449,  -7.27272749
  33909,  -11.4066381,   67.5236588,  -8.18181801
  33910,  -11.9025784,   68.2855606,  -8.18181801
  33911,  -12.3985195,   69.0474548,  -8.18181801
  33912,  -12.8944607,   69.8093567,  -8.18181801
  33913,  -13.3904009,   70.5712509,  -8.18181801
  33914,  -13.8863411,   71.3331528,  -8.18181801
  33915,  -14.3822823,    72.095047,  -8.18181801
  33916,  -14.8782225,   72.8569489,  -8.18181801
  33917,  -15.3741636,   73.6188431,  -8.18181801
  33918,  -15.8701038,   74.3807449,  -8.18181801
  33919,  -11.4066381,   67.5236588,    -9.090909
  33920,  -11.9025784,   68.2855606,    -9.090909
  33921,  -12.3985195,   69.0474548,    -9.090909
  33922,  -12.8944607,   69.8093567,    -9.090909
  33923,  -13.3904009,   70.5712509,    -9.090909
  33924,  -13.8863411,   71.3331528,    -9.090909
  33925,  -14.3822823,    72.095047,    -9.090909
  33926,  -14.8782225,   72.8569489,    -9.090909
  33927,  -15.3741636,   73.6188431,    -9.090909
  33928,  -15.8701038,   74.3807449,    -9.090909
  33929,  -11.9624405,   67.1490555, -0.909090936
  33930,  -12.4825449,   67.8946686, -0.909090936
  33931,  -13.0026512,   68.6402817, -0.909090936
  33932,  -13.5227575,   69.3858871, -0.909090936
  33933,  -14.0428638,   70.1315002, -0.909090936
  33934,  -14.5629683,   70.8771133, -0.909090936
  33935,  -15.0830746,   71.6227264, -0.909090936
  33936,  -15.6031809,   72.3683319, -0.909090936
  33937,  -16.1232853,    73.113945, -0.909090936
  33938,  -16.6433926,   73.8595581, -0.909090936
  33939,  -11.9624405,   67.1490555,  -1.81818187
  33940,  -12.4825449,   67.8946686,  -1.81818187
  33941,  -13.0026512,   68.6402817,  -1.81818187
  33942,  -13.5227575,   69.3858871,  -1.81818187
  33943,  -14.0428638,   70.1315002,  -1.81818187
  33944,  -14.5629683,   70.8771133,  -1.81818187
  33945,  -15.0830746,   71.6227264,  -1.81818187
  33946,  -15.6031809,   72.3683319,  -1.81818187
  33947,  -16.1232853,    73.113945,  -1.81818187
  33948,  -16.6433926,   73.8595581,  -1.81818187
  33949,  -11.9624405,   67.1490555,  -2.72727275
  33950,  -12.4825449,   67.8946686,  -2.72727275
  33951,  -13.0026512,   68.6402817,  -2.72727275
  33952,  -13.5227575,   69.3858871,  -2.72727275
  33953,  -14.0428638,   70.1315002,  -2.72727275
  33954,  -14.5629683,   70.8771133,  -2.72727275
  33955,  -15.0830746,   71.6227264,  -2.72727275
  33956,  -15.6031809,   72.3683319,  -2.72727275
  33957,  -16.1232853,    73.113945,  -2.72727275
  33958,  -16.6433926,   73.8595581,  -2.72727275
  33959,  -11.9624405,   67.1490555,  -3.63636374
  33960,  -12.4825449,   67.8946686,  -3.63636374
  33961,  -13.0026512,   68.6402817,  -3.63636374
  33962,  -13.5227575,   69.3858871,  -3.63636374
  33963,  -14.0428638,   70.1315002,  -3.63636374
  33964,  -14.5629683,   70.8771133,  -3.63636374
  33965,  -15.0830746,   71.6227264,  -3.63636374
  33966,  -15.6031809,   72.3683319,  -3.63636374
  33967,  -16.1232853,    73.113945,  -3.63636374
  33968,  -16.6433926,   73.8595581,  -3.63636374
  33969,  -11.9624405,   67.1490555,   -4.5454545
  33970,  -12.4825449,   67.8946686,   -4.5454545
  33971,  -13.0026512,   68.6402817,   -4.5454545
  33972,  -13.5227575,   69.3858871,   -4.5454545
  33973,  -14.0428638,   70.1315002,   -4.5454545
  33974,  -14.5629683,   70.8771133,   -4.5454545
  33975,  -15.0830746,   71.6227264,   -4.5454545
  33976,  -15.6031809,   72.3683319,   -4.5454545
  33977,  -16.1232853,    73.113945,   -4.5454545
  33978,  -16.6433926,   73.8595581,   -4.5454545
  33979,  -11.9624405,   67.1490555,   -5.4545455
  33980,  -12.4825449,   67.8946686,   -5.4545455
  33981,  -13.0026512,   68.6402817,   -5.4545455
  33982,  -13.5227575,   69.3858871,   -5.4545455
  33983,  -14.0428638,   70.1315002,   -5.4545455
  33984,  -14.5629683,   70.8771133,   -5.4545455
  33985,  -15.0830746,   71.6227264,   -5.4545455
  33986,  -15.6031809,   72.3683319,   -5.4545455
  33987,  -16.1232853,    73.113945,   -5.4545455
  33988,  -16.6433926,   73.8595581,   -5.4545455
  33989,  -11.9624405,   67.1490555,  -6.36363649
  33990,  -12.4825449,   67.8946686,  -6.36363649
  33991,  -13.0026512,   68.6402817,  -6.36363649
  33992,  -13.5227575,   69.3858871,  -6.36363649
  33993,  -14.0428638,   70.1315002,  -6.36363649
  33994,  -14.5629683,   70.8771133,  -6.36363649
