  59995,    23.636364,          2.5,   6.36363649
  59996,    22.727272,          2.5,   6.36363649
  59997,    21.818182,          2.5,   6.36363649
  59998,     20.90909,          2.5,   6.36363649
  59999,     29.09091,          2.5,   7.27272749
  60000,    28.181818,          2.5,   7.27272749
  60001,    27.272728,          2.5,   7.27272749
  60002,    26.363636,          2.5,   7.27272749
  60003,    25.454546,          2.5,   7.27272749
  60004,    24.545454,          2.5,   7.27272749
  60005,    23.636364,          2.5,   7.27272749
  60006,    22.727272,          2.5,   7.27272749
  60007,    21.818182,          2.5,   7.27272749
  60008,     20.90909,          2.5,   7.27272749
  60009,     29.09091,          2.5,   8.18181801
  60010,    28.181818,          2.5,   8.18181801
  60011,    27.272728,          2.5,   8.18181801
  60012,    26.363636,          2.5,   8.18181801
  60013,    25.454546,          2.5,   8.18181801
  60014,    24.545454,          2.5,   8.18181801
  60015,    23.636364,          2.5,   8.18181801
  60016,    22.727272,          2.5,   8.18181801
  60017,    21.818182,          2.5,   8.18181801
  60018,     20.90909,          2.5,   8.18181801
  60019,     29.09091,          2.5,     9.090909
  60020,    28.181818,          2.5,     9.090909
  60021,    27.272728,          2.5,     9.090909
  60022,    26.363636,          2.5,     9.090909
  60023,    25.454546,          2.5,     9.090909
  60024,    24.545454,          2.5,     9.090909
  60025,    23.636364,          2.5,     9.090909
  60026,    22.727272,          2.5,     9.090909
  60027,    21.818182,          2.5,     9.090909
  60028,     20.90909,          2.5,     9.090909
  60029,     29.09091,   1.66666663,  0.909090936
  60030,    28.181818,   1.66666663,  0.909090936
  60031,    27.272728,   1.66666663,  0.909090936
  60032,    26.363636,   1.66666663,  0.909090936
  60033,    25.454546,   1.66666663,  0.909090936
  60034,    24.545454,   1.66666663,  0.909090936
  60035,    23.636364,   1.66666663,  0.909090936
  60036,    22.727272,   1.66666663,  0.909090936
  60037,    21.818182,   1.66666663,  0.909090936
  60038,     20.90909,   1.66666663,  0.909090936
  60039,     29.09091,   1.66666663,   1.81818187
  60040,    28.181818,   1.66666663,   1.81818187
  60041,    27.272728,   1.66666663,   1.81818187
  60042,    26.363636,   1.66666663,   1.81818187
  60043,    25.454546,   1.66666663,   1.81818187
  60044,    24.545454,   1.66666663,   1.81818187
  60045,    23.636364,   1.66666663,   1.81818187
  60046,    22.727272,   1.66666663,   1.81818187
  60047,    21.818182,   1.66666663,   1.81818187
  60048,     20.90909,   1.66666663,   1.81818187
  60049,     29.09091,   1.66666663,   2.72727275
  60050,    28.181818,   1.66666663,   2.72727275
  60051,    27.272728,   1.66666663,   2.72727275
  60052,    26.363636,   1.66666663,   2.72727275
  60053,    25.454546,   1.66666663,   2.72727275
  60054,    24.545454,   1.66666663,   2.72727275
  60055,    23.636364,   1.66666663,   2.72727275
  60056,    22.727272,   1.66666663,   2.72727275
  60057,    21.818182,   1.66666663,   2.72727275
  60058,     20.90909,   1.66666663,   2.72727275
  60059,     29.09091,   1.66666663,   3.63636374
  60060,    28.181818,   1.66666663,   3.63636374
  60061,    27.272728,   1.66666663,   3.63636374
  60062,    26.363636,   1.66666663,   3.63636374
  60063,    25.454546,   1.66666663,   3.63636374
  60064,    24.545454,   1.66666663,   3.63636374
  60065,    23.636364,   1.66666663,   3.63636374
  60066,    22.727272,   1.66666663,   3.63636374
  60067,    21.818182,   1.66666663,   3.63636374
  60068,     20.90909,   1.66666663,   3.63636374
  60069,     29.09091,   1.66666663,    4.5454545
  60070,    28.181818,   1.66666663,    4.5454545
  60071,    27.272728,   1.66666663,    4.5454545
  60072,    26.363636,   1.66666663,    4.5454545
  60073,    25.454546,   1.66666663,    4.5454545
  60074,    24.545454,   1.66666663,    4.5454545
  60075,    23.636364,   1.66666663,    4.5454545
  60076,    22.727272,   1.66666663,    4.5454545
  60077,    21.818182,   1.66666663,    4.5454545
  60078,     20.90909,   1.66666663,    4.5454545
  60079,     29.09091,   1.66666663,    5.4545455
  60080,    28.181818,   1.66666663,    5.4545455
  60081,    27.272728,   1.66666663,    5.4545455
  60082,    26.363636,   1.66666663,    5.4545455
  60083,    25.454546,   1.66666663,    5.4545455
  60084,    24.545454,   1.66666663,    5.4545455
  60085,    23.636364,   1.66666663,    5.4545455
  60086,    22.727272,   1.66666663,    5.4545455
  60087,    21.818182,   1.66666663,    5.4545455
  60088,     20.90909,   1.66666663,    5.4545455
  60089,     29.09091,   1.66666663,   6.36363649
  60090,    28.181818,   1.66666663,   6.36363649
  60091,    27.272728,   1.66666663,   6.36363649
  60092,    26.363636,   1.66666663,   6.36363649
  60093,    25.454546,   1.66666663,   6.36363649
  60094,    24.545454,   1.66666663,   6.36363649
  60095,    23.636364,   1.66666663,   6.36363649
  60096,    22.727272,   1.66666663,   6.36363649
  60097,    21.818182,   1.66666663,   6.36363649
  60098,     20.90909,   1.66666663,   6.36363649
  60099,     29.09091,   1.66666663,   7.27272749
  60100,    28.181818,   1.66666663,   7.27272749
  60101,    27.272728,   1.66666663,   7.27272749
  60102,    26.363636,   1.66666663,   7.27272749
  60103,    25.454546,   1.66666663,   7.27272749
  60104,    24.545454,   1.66666663,   7.27272749
  60105,    23.636364,   1.66666663,   7.27272749
  60106,    22.727272,   1.66666663,   7.27272749
  60107,    21.818182,   1.66666663,   7.27272749
  60108,     20.90909,   1.66666663,   7.27272749
  60109,     29.09091,   1.66666663,   8.18181801
  60110,    28.181818,   1.66666663,   8.18181801
  60111,    27.272728,   1.66666663,   8.18181801
  60112,    26.363636,   1.66666663,   8.18181801
  60113,    25.454546,   1.66666663,   8.18181801
  60114,    24.545454,   1.66666663,   8.18181801
  60115,    23.636364,   1.66666663,   8.18181801
  60116,    22.727272,   1.66666663,   8.18181801
  60117,    21.818182,   1.66666663,   8.18181801
  60118,     20.90909,   1.66666663,   8.18181801
  60119,     29.09091,   1.66666663,     9.090909
  60120,    28.181818,   1.66666663,     9.090909
  60121,    27.272728,   1.66666663,     9.090909
  60122,    26.363636,   1.66666663,     9.090909
  60123,    25.454546,   1.66666663,     9.090909
  60124,    24.545454,   1.66666663,     9.090909
  60125,    23.636364,   1.66666663,     9.090909
  60126,    22.727272,   1.66666663,     9.090909
  60127,    21.818182,   1.66666663,     9.090909
  60128,     20.90909,   1.66666663,     9.090909
  60129,     29.09091,  0.833333313,  0.909090936
  60130,    28.181818,  0.833333313,  0.909090936
  60131,    27.272728,  0.833333313,  0.909090936
  60132,    26.363636,  0.833333313,  0.909090936
  60133,    25.454546,  0.833333313,  0.909090936
  60134,    24.545454,  0.833333313,  0.909090936
  60135,    23.636364,  0.833333313,  0.909090936
  60136,    22.727272,  0.833333313,  0.909090936
  60137,    21.818182,  0.833333313,  0.909090936
  60138,     20.90909,  0.833333313,  0.909090936
  60139,     29.09091,  0.833333313,   1.81818187
  60140,    28.181818,  0.833333313,   1.81818187
  60141,    27.272728,  0.833333313,   1.81818187
  60142,    26.363636,  0.833333313,   1.81818187
  60143,    25.454546,  0.833333313,   1.81818187
  60144,    24.545454,  0.833333313,   1.81818187
  60145,    23.636364,  0.833333313,   1.81818187
  60146,    22.727272,  0.833333313,   1.81818187
  60147,    21.818182,  0.833333313,   1.81818187
  60148,     20.90909,  0.833333313,   1.81818187
  60149,     29.09091,  0.833333313,   2.72727275
  60150,    28.181818,  0.833333313,   2.72727275
  60151,    27.272728,  0.833333313,   2.72727275
  60152,    26.363636,  0.833333313,   2.72727275
  60153,    25.454546,  0.833333313,   2.72727275
  60154,    24.545454,  0.833333313,   2.72727275
  60155,    23.636364,  0.833333313,   2.72727275
  60156,    22.727272,  0.833333313,   2.72727275
  60157,    21.818182,  0.833333313,   2.72727275
  60158,     20.90909,  0.833333313,   2.72727275
  60159,     29.09091,  0.833333313,   3.63636374
  60160,    28.181818,  0.833333313,   3.63636374
  60161,    27.272728,  0.833333313,   3.63636374
  60162,    26.363636,  0.833333313,   3.63636374
  60163,    25.454546,  0.833333313,   3.63636374
  60164,    24.545454,  0.833333313,   3.63636374
  60165,    23.636364,  0.833333313,   3.63636374
  60166,    22.727272,  0.833333313,   3.63636374
  60167,    21.818182,  0.833333313,   3.63636374
  60168,     20.90909,  0.833333313,   3.63636374
  60169,     29.09091,  0.833333313,    4.5454545
  60170,    28.181818,  0.833333313,    4.5454545
  60171,    27.272728,  0.833333313,    4.5454545
  60172,    26.363636,  0.833333313,    4.5454545
  60173,    25.454546,  0.833333313,    4.5454545
  60174,    24.545454,  0.833333313,    4.5454545
  60175,    23.636364,  0.833333313,    4.5454545
  60176,    22.727272,  0.833333313,    4.5454545
  60177,    21.818182,  0.833333313,    4.5454545
  60178,     20.90909,  0.833333313,    4.5454545
  60179,     29.09091,  0.833333313,    5.4545455
  60180,    28.181818,  0.833333313,    5.4545455
  60181,    27.272728,  0.833333313,    5.4545455
  60182,    26.363636,  0.833333313,    5.4545455
  60183,    25.454546,  0.833333313,    5.4545455
  60184,    24.545454,  0.833333313,    5.4545455
  60185,    23.636364,  0.833333313,    5.4545455
  60186,    22.727272,  0.833333313,    5.4545455
  60187,    21.818182,  0.833333313,    5.4545455
  60188,     20.90909,  0.833333313,    5.4545455
  60189,     29.09091,  0.833333313,   6.36363649
  60190,    28.181818,  0.833333313,   6.36363649
  60191,    27.272728,  0.833333313,   6.36363649
  60192,    26.363636,  0.833333313,   6.36363649
  60193,    25.454546,  0.833333313,   6.36363649
  60194,    24.545454,  0.833333313,   6.36363649
  60195,    23.636364,  0.833333313,   6.36363649
  60196,    22.727272,  0.833333313,   6.36363649
  60197,    21.818182,  0.833333313,   6.36363649
  60198,     20.90909,  0.833333313,   6.36363649
  60199,     29.09091,  0.833333313,   7.27272749
  60200,    28.181818,  0.833333313,   7.27272749
  60201,    27.272728,  0.833333313,   7.27272749
  60202,    26.363636,  0.833333313,   7.27272749
  60203,    25.454546,  0.833333313,   7.27272749
  60204,    24.545454,  0.833333313,   7.27272749
  60205,    23.636364,  0.833333313,   7.27272749
  60206,    22.727272,  0.833333313,   7.27272749
  60207,    21.818182,  0.833333313,   7.27272749
  60208,     20.90909,  0.833333313,   7.27272749
  60209,     29.09091,  0.833333313,   8.18181801
  60210,    28.181818,  0.833333313,   8.18181801
  60211,    27.272728,  0.833333313,   8.18181801
  60212,    26.363636,  0.833333313,   8.18181801
  60213,    25.454546,  0.833333313,   8.18181801
  60214,    24.545454,  0.833333313,   8.18181801
  60215,    23.636364,  0.833333313,   8.18181801
  60216,    22.727272,  0.833333313,   8.18181801
  60217,    21.818182,  0.833333313,   8.18181801
  60218,     20.90909,  0.833333313,   8.18181801
  60219,     29.09091,  0.833333313,     9.090909
  60220,    28.181818,  0.833333313,     9.090909
  60221,    27.272728,  0.833333313,     9.090909
  60222,    26.363636,  0.833333313,     9.090909
  60223,    25.454546,  0.833333313,     9.090909
  60224,    24.545454,  0.833333313,     9.090909
  60225,    23.636364,  0.833333313,     9.090909
  60226,    22.727272,  0.833333313,     9.090909
  60227,    21.818182,  0.833333313,     9.090909
  60228,     20.90909,  0.833333313,     9.090909
  60229,   22.3314762,   14.3461742,   9.53731346
  60230,   22.3220425,   14.3173494,   9.07462692
  60231,   22.3126087,   14.2885237,   8.61194038
  60232,    22.303175,   14.2596989,   8.14925385
  60233,   22.2937393,   14.2308731,   7.68656683
  60234,   22.2843075,   14.2020483,   7.22388029
  60235,   22.2748737,   14.1732225,   6.76119328
  60236,     22.26544,   14.1443977,   6.29850674
  60237,   22.2560062,    14.115572,    5.8358202
  60238,   22.2465725,   14.0867462,   5.37313366
  60239,   22.1183739,   13.6950293,   9.51302719
  60240,   22.1003838,   13.6400595,   9.02605343
  60241,   22.0823936,   13.5850887,   8.53908062
  60242,   22.0644035,   13.5301189,   8.05210686
  60243,   22.0464115,   13.4751482,   7.56513405
  60244,   22.0284214,   13.4201784,   7.07816076
  60245,   22.0104313,   13.3652077,   6.59118748
  60246,   21.9924412,   13.3102379,   6.10421467
  60247,   21.9744511,   13.2552671,   5.61724138
  60248,    21.956461,   13.2002974,    5.1302681
  60249,   21.9070473,   13.0493116,   9.47304153
  60250,   21.8822765,   12.9736223,   8.94608307
  60251,   21.8575058,    12.897934,   8.41912365
  60252,   21.8327351,   12.8222446,   7.89216518
  60253,   21.8079643,   12.7465563,   7.36520672
  60254,   21.7831936,   12.6708679,   6.83824825
  60255,   21.7584209,   12.5951796,   6.31128979
  60256,   21.7336502,   12.5194912,   5.78433084
  60257,   21.7088795,   12.4438019,   5.25737238
  60258,   21.6841087,   12.3681135,   4.73041391
  60259,   21.6984291,   12.4118662,   9.41821671
  60260,   21.6695843,   12.3237314,   8.83643246
  60261,   21.6407413,   12.2355976,   8.25464916
  60262,   21.6118965,   12.1474638,   7.67286587
  60263,   21.5830536,    12.059329,    7.0910821
  60264,   21.5542107,   11.9711952,    6.5092988
  60265,   21.5253658,   11.8830614,   5.92751503
  60266,   21.4965229,   11.7949276,   5.34573174
  60267,   21.4676781,   11.7067928,   4.76394796
  60268,   21.4388332,    11.618659,   4.18216467
  60269,   21.4934731,   11.7856054,   9.34998417
  60270,   21.4642143,   11.6962109,   8.69996929
  60271,   21.4349594,   11.6068163,   8.04995346
  60272,   21.4057026,   11.5174208,   7.39993811
  60273,   21.3764458,   11.4280262,   6.74992228
  60274,   21.3471889,   11.3386316,   6.09990692
  60275,   21.3179321,   11.2492371,   5.44989157
  60276,   21.2886772,   11.1598425,   4.79987574
  60277,   21.2594204,   11.0704479,   4.14986038
  60278,   21.2301636,   10.9810534,   3.49984479
  60279,   21.2930984,    11.173358,   9.27052689
  60280,   21.2680168,   11.0967159,   8.54105377
  60281,   21.2429333,   11.0200739,   7.81158113
  60282,   21.2178497,   10.9434319,   7.08210802
  60283,   21.1927681,   10.8667889,   6.35263491
  60284,   21.1676846,   10.7901468,   5.62316179
  60285,   21.1426029,   10.7135048,   4.89368916
  60286,   21.1175194,   10.6368628,   4.16421604
  60287,   21.0924358,   10.5602207,   3.43474269
  60288,   21.0673542,   10.4835787,   2.70526981
  60289,   21.0981178,   10.5775852,   9.18288708
  60290,   21.0826015,   10.5301704,   8.36577415
  60291,   21.0670834,   10.4827547,   7.54866171
  60292,   21.0515652,   10.4353399,   6.73154879
  60293,   21.0360489,   10.3879251,   5.91443586
  60294,   21.0205288,   10.3405104,   5.09732294
  60295,   21.0050125,   10.2930956,   4.28021002
  60296,   20.9894943,   10.2456808,    3.4630971
  60297,   20.9739761,   10.1982651,   2.64598441
  60298,   20.9584599,   10.1508503,   1.82887149
  60299,   22.9244804,   14.3461742,   9.53731346
  60300,   22.9171429,   14.3173494,   9.07462692
  60301,   22.9098053,   14.2885237,   8.61194038
  60302,   22.9024696,   14.2596989,   8.14925385
  60303,   22.8951302,   14.2308731,   7.68656683
  60304,   22.8877926,   14.2020483,   7.22388029
  60305,    22.880455,   14.1732225,   6.76119328
  60306,   22.8731194,   14.1443977,   6.29850674
  60307,   22.8657818,    14.115572,    5.8358202
  60308,   22.8584442,   14.0867462,   5.37313366
  60309,   22.7587357,   13.6950293,   9.51302719
  60310,   22.7447433,   13.6400595,   9.02605343
  60311,    22.730751,   13.5850887,   8.53908062
  60312,   22.7167587,   13.5301189,   8.05210686
  60313,   22.7027645,   13.4751482,   7.56513405
  60314,   22.6887722,   13.4201794,   7.07816124
  60315,   22.6747799,   13.3652086,   6.59118795
  60316,   22.6607876,   13.3102388,   6.10421515
  60317,   22.6467953,   13.2552681,   5.61724186
  60318,    22.632803,   13.2002983,   5.13026857
  60319,   22.5943699,   13.0493116,   9.47304153
  60320,   22.5751038,   12.9736223,   8.94608307
  60321,   22.5558376,    12.897934,   8.41912365
  60322,   22.5365715,   12.8222446,   7.89216518
  60323,   22.5173054,   12.7465563,   7.36520672
  60324,   22.4980392,   12.6708679,   6.83824825
  60325,   22.4787731,   12.5951796,   6.31128979
  60326,    22.459507,   12.5194912,   5.78433084
  60327,   22.4402409,   12.4438019,   5.25737238
  60328,   22.4209747,   12.3681135,   4.73041391
  60329,   22.4321117,   12.4118662,   9.41821671
  60330,   22.4096775,   12.3237314,   8.83643246
  60331,   22.3872433,   12.2355976,   8.25464916
  60332,    22.364809,   12.1474638,   7.67286587
  60333,   22.3423748,    12.059329,    7.0910821
  60334,   22.3199406,   11.9711952,    6.5092988
  60335,   22.2975063,   11.8830614,   5.92751503
  60336,   22.2750721,   11.7949276,   5.34573174
  60337,   22.2526379,   11.7067928,   4.76394796
  60338,   22.2302036,    11.618659,   4.18216467
  60339,   22.2726994,   11.7856054,   9.34998417
  60340,   22.2499447,   11.6962109,   8.69996929
  60341,     22.22719,   11.6068163,   8.04995346
  60342,   22.2044334,   11.5174208,   7.39993811
  60343,   22.1816788,   11.4280262,   6.74992228
  60344,   22.1589241,   11.3386316,   6.09990692
  60345,   22.1361694,   11.2492371,   5.44989157
  60346,   22.1134148,   11.1598425,   4.79987574
  60347,   22.0906582,   11.0704479,   4.14986038
  60348,   22.0679054,   10.9810534,   3.49984479
  60349,   22.1168556,    11.173358,   9.27052689
  60350,   22.0973454,   11.0967159,   8.54105377
  60351,    22.077837,   11.0200739,   7.81158113
  60352,   22.0583286,   10.9434319,   7.08210802
  60353,   22.0388203,   10.8667889,   6.35263491
  60354,     22.01931,   10.7901468,   5.62316179
  60355,   21.9998016,   10.7135048,   4.89368868
  60356,   21.9802933,   10.6368628,   4.16421556
  60357,   21.9607849,   10.5602207,   3.43474245
  60358,   21.9412746,   10.4835787,   2.70526958
  60359,   21.9652023,   10.5775852,   9.18288708
  60360,   21.9531345,   10.5301704,   8.36577415
  60361,   21.9410648,   10.4827547,   7.54866171
  60362,   21.9289951,   10.4353399,   6.73154879
  60363,   21.9169254,   10.3879251,   5.91443586
  60364,   21.9048576,   10.3405104,   5.09732294
  60365,   21.8927879,   10.2930956,   4.28021002
  60366,   21.8807182,   10.2456808,    3.4630971
  60367,   21.8686485,   10.1982651,   2.64598441
  60368,   21.8565807,   10.1508503,   1.82887137
  60369,   23.5174866,   14.3461742,   9.53731346
  60370,   23.5122452,   14.3173494,   9.07462692
  60371,   23.5070057,   14.2885237,   8.61194038
  60372,   23.5017643,   14.2596989,   8.14925385
  60373,    23.496521,   14.2308731,   7.68656683
  60374,   23.4912815,   14.2020483,   7.22388029
  60375,   23.4860401,   14.1732225,   6.76119328
  60376,   23.4807987,   14.1443977,   6.29850674
  60377,   23.4755592,    14.115572,    5.8358202
  60378,   23.4703178,   14.0867462,   5.37313366
  60379,   23.3990955,   13.6950293,   9.51302719
  60380,    23.389101,   13.6400595,   9.02605343
  60381,   23.3791065,   13.5850887,   8.53908062
  60382,    23.369112,   13.5301189,   8.05210686
  60383,   23.3591156,   13.4751482,   7.56513405
  60384,    23.349123,   13.4201794,   7.07816124
  60385,   23.3391285,   13.3652086,   6.59118795
  60386,    23.329134,   13.3102388,   6.10421515
  60387,   23.3191395,   13.2552681,   5.61724186
  60388,    23.309145,   13.2002983,   5.13026857
  60389,   23.2816925,   13.0493116,   9.47304153
  60390,    23.267931,   12.9736223,   8.94608307
  60391,   23.2541695,    12.897934,   8.41912365
  60392,   23.2404079,   12.8222456,   7.89216518
  60393,   23.2266464,   12.7465563,   7.36520672
  60394,   23.2128849,   12.6708679,   6.83824825
  60395,   23.1991234,   12.5951796,   6.31128979
  60396,   23.1853619,   12.5194912,   5.78433084
  60397,   23.1716003,   12.4438019,   5.25737238
  60398,   23.1578388,   12.3681135,   4.73041391
  60399,   23.1657944,   12.4118662,   9.41821671
  60400,   23.1497688,   12.3237314,   8.83643246
  60401,   23.1337452,   12.2355976,   8.25464916
  60402,   23.1177216,   12.1474638,   7.67286587
  60403,    23.101696,    12.059329,    7.0910821
  60404,   23.0856724,   11.9711952,    6.5092988
  60405,   23.0696487,   11.8830614,   5.92751503
  60406,   23.0536232,   11.7949276,   5.34573174
  60407,   23.0375977,   11.7067928,   4.76394796
  60408,    23.021574,    11.618659,   4.18216467
  60409,   23.0519295,   11.7856054,   9.34998417
  60410,    23.035675,   11.6962109,   8.69996929
  60411,   23.0194225,   11.6068163,   8.04995346
  60412,   23.0031681,   11.5174208,   7.39993811
  60413,   22.9869137,   11.4280262,   6.74992228
  60414,   22.9706612,   11.3386316,   6.09990692
  60415,   22.9544067,   11.2492371,   5.44989109
  60416,   22.9381542,   11.1598425,   4.79987574
  60417,   22.9218998,   11.0704479,   4.14986038
  60418,   22.9056473,   10.9810534,   3.49984479
  60419,   22.9406109,    11.173358,   9.27052689
  60420,   22.9266758,   11.0967159,   8.54105377
  60421,   22.9127407,   11.0200739,   7.81158113
  60422,   22.8988056,   10.9434319,   7.08210802
  60423,   22.8848705,   10.8667889,   6.35263491
  60424,   22.8709373,   10.7901468,   5.62316132
  60425,   22.8570023,   10.7135048,   4.89368868
  60426,   22.8430672,   10.6368628,   4.16421556
  60427,   22.8291321,   10.5602207,   3.43474245
  60428,    22.815197,   10.4835787,   2.70526958
  60429,   22.8322887,   10.5775852,   9.18288708
  60430,   22.8236675,   10.5301704,   8.36577415
  60431,   22.8150463,   10.4827547,   7.54866123
  60432,   22.8064251,   10.4353399,   6.73154831
  60433,   22.7978058,   10.3879251,   5.91443539
  60434,   22.7891827,   10.3405104,   5.09732246
  60435,   22.7805634,   10.2930956,   4.28020954
  60436,   22.7719421,   10.2456808,   3.46309686
  60437,   22.7633209,   10.1982651,   2.64598417
  60438,   22.7546997,   10.1508503,   1.82887125
  60439,   24.1104908,   14.3461742,   9.53731346
  60440,   24.1073475,   14.3173494,   9.07462692
  60441,   24.1042023,   14.2885237,   8.61194038
  60442,    24.101059,   14.2596989,   8.14925385
  60443,   24.0979118,   14.2308731,   7.68656683
  60444,   24.0947685,   14.2020493,   7.22388029
  60445,   24.0916233,   14.1732235,   6.76119375
  60446,     24.08848,   14.1443987,   6.29850721
  60447,   24.0853348,   14.1155729,   5.83582067
  60448,   24.0821915,   14.0867472,   5.37313414
  60449,   24.0394573,   13.6950293,   9.51302719
  60450,   24.0334606,   13.6400595,   9.02605343
  60451,   24.0274639,   13.5850887,   8.53908062
  60452,   24.0214672,   13.5301189,   8.05210686
  60453,   24.0154686,   13.4751482,   7.56513405
  60454,   24.0094738,   13.4201794,   7.07816124
  60455,   24.0034771,   13.3652086,   6.59118795
  60456,   23.9974804,   13.3102388,   6.10421515
  60457,   23.9914837,   13.2552681,   5.61724186
  60458,    23.985487,   13.2002983,   5.13026857
  60459,   23.9690151,   13.0493116,   9.47304153
  60460,   23.9607582,   12.9736223,   8.94608307
  60461,   23.9525013,    12.897934,   8.41912365
  60462,   23.9442444,   12.8222456,   7.89216518
  60463,   23.9359875,   12.7465563,   7.36520672
  60464,   23.9277306,   12.6708679,   6.83824825
  60465,   23.9194736,   12.5951796,   6.31128979
  60466,   23.9112167,   12.5194902,   5.78433084
  60467,   23.9029598,   12.4438019,   5.25737238
  60468,   23.8947029,   12.3681135,   4.73041391
  60469,   23.8994751,   12.4118662,   9.41821671
  60470,   23.8898602,   12.3237314,   8.83643246
  60471,   23.8802471,   12.2355976,   8.25464916
  60472,   23.8706322,   12.1474638,   7.67286587
  60473,   23.8610172,    12.059329,    7.0910821
  60474,   23.8514023,   11.9711952,    6.5092988
  60475,   23.8417873,   11.8830614,   5.92751503
  60476,   23.8321743,   11.7949276,   5.34573174
  60477,   23.8225574,   11.7067928,   4.76394796
  60478,   23.8129425,    11.618659,   4.18216467
  60479,   23.8311577,   11.7856054,   9.34998417
  60480,   23.8214054,   11.6962109,   8.69996929
  60481,   23.8116531,   11.6068163,   8.04995346
  60482,   23.8019009,   11.5174208,   7.39993811
  60483,   23.7921486,   11.4280262,   6.74992228
  60484,   23.7823963,   11.3386316,   6.09990692
  60485,    23.772644,   11.2492371,   5.44989109
  60486,   23.7628918,   11.1598425,   4.79987574
  60487,   23.7531395,   11.0704479,   4.14986038
  60488,   23.7433872,   10.9810534,   3.49984479
  60489,   23.7643661,    11.173358,   9.27052689
  60490,   23.7560062,   11.0967159,   8.54105377
  60491,   23.7476444,   11.0200739,   7.81158113
  60492,   23.7392845,   10.9434319,   7.08210754
  60493,   23.7309227,   10.8667889,   6.35263443
  60494,   23.7225628,   10.7901468,   5.62316132
  60495,    23.714201,   10.7135048,   4.89368868
  60496,   23.7058411,   10.6368628,   4.16421556
  60497,   23.6974792,   10.5602207,   3.43474245
  60498,   23.6891193,   10.4835787,   2.70526934
  60499,   23.6993732,   10.5775852,   9.18288708
  60500,   23.6942005,   10.5301704,   8.36577415
  60501,   23.6890278,   10.4827547,   7.54866123
  60502,   23.6838551,   10.4353399,   6.73154831
  60503,   23.6786842,   10.3879251,   5.91443539
  60504,   23.6735096,   10.3405104,   5.09732246
  60505,   23.6683388,   10.2930956,   4.28020954
  60506,    23.663166,   10.2456808,   3.46309686
  60507,   23.6579933,   10.1982651,   2.64598393
  60508,   23.6528206,   10.1508503,   1.82887101
  60509,   24.7034969,   14.3461742,   9.53731346
  60510,   24.7024498,   14.3173494,   9.07462692
  60511,   24.7014008,   14.2885237,   8.61194038
  60512,   24.7003517,   14.2596989,   8.14925385
  60513,   24.6993027,   14.2308731,   7.68656683
  60514,   24.6982555,   14.2020493,   7.22388029
  60515,   24.6972084,   14.1732235,   6.76119375
  60516,   24.6961594,   14.1443987,   6.29850721
  60517,   24.6951103,   14.1155729,    5.8358202
  60518,   24.6940632,   14.0867472,   5.37313366
  60519,   24.6798191,   13.6950293,   9.51302719
  60520,   24.6778202,   13.6400595,   9.02605343
  60521,   24.6758213,   13.5850887,   8.53908062
  60522,   24.6738224,   13.5301189,   8.05210686
  60523,   24.6718216,   13.4751482,   7.56513405
  60524,   24.6698246,   13.4201794,   7.07816124
  60525,   24.6678257,   13.3652086,   6.59118795
  60526,   24.6658268,   13.3102388,   6.10421515
  60527,   24.6638279,   13.2552681,   5.61724186
  60528,    24.661829,   13.2002983,   5.13026857
  60529,   24.6563377,   13.0493116,   9.47304153
  60530,   24.6535854,   12.9736223,   8.94608307
  60531,   24.6508331,    12.897934,   8.41912365
  60532,   24.6480808,   12.8222456,   7.89216518
  60533,   24.6453285,   12.7465563,   7.36520672
  60534,   24.6425762,   12.6708679,   6.83824825
  60535,   24.6398239,   12.5951796,   6.31128979
  60536,   24.6370716,   12.5194902,   5.78433084
  60537,   24.6343193,   12.4438019,   5.25737238
  60538,    24.631567,   12.3681135,   4.73041391
  60539,   24.6331596,   12.4118662,   9.41821671
  60540,   24.6299534,   12.3237314,   8.83643246
  60541,    24.626749,   12.2355976,   8.25464916
  60542,   24.6235447,   12.1474638,   7.67286587
  60543,   24.6203403,    12.059329,    7.0910821
  60544,   24.6171341,   11.9711952,    6.5092988
  60545,   24.6139297,   11.8830614,   5.92751503
  60546,   24.6107254,   11.7949276,   5.34573174
  60547,   24.6075191,   11.7067928,   4.76394796
  60548,   24.6043148,    11.618659,   4.18216467
  60549,   24.6103859,   11.7856054,   9.34998417
  60550,   24.6071339,   11.6962109,   8.69996929
  60551,   24.6038837,   11.6068163,   8.04995346
  60552,   24.6006336,   11.5174208,   7.39993811
  60553,   24.5973835,   11.4280262,   6.74992228
  60554,   24.5941315,   11.3386316,   6.09990692
  60555,   24.5908813,   11.2492371,   5.44989109
  60556,   24.5876312,   11.1598425,   4.79987574
  60557,   24.5843811,   11.0704479,   4.14986038
  60558,   24.5811291,   10.9810534,   3.49984479
  60559,   24.5881233,    11.173358,   9.27052689
  60560,   24.5853367,   11.0967159,   8.54105377
  60561,   24.5825481,   11.0200739,   7.81158066
  60562,   24.5797615,   10.9434319,   7.08210754
  60563,   24.5769749,   10.8667889,   6.35263443
  60564,   24.5741882,   10.7901468,   5.62316132
  60565,   24.5714016,   10.7135048,   4.89368868
  60566,    24.568615,   10.6368628,   4.16421556
  60567,   24.5658264,   10.5602207,   3.43474221
  60568,   24.5630398,   10.4835787,   2.70526934
  60569,   24.5664577,   10.5775852,   9.18288708
  60570,   24.5647335,   10.5301704,   8.36577415
  60571,   24.5630093,   10.4827547,   7.54866123
  60572,    24.561285,   10.4353399,   6.73154831
  60573,   24.5595608,   10.3879251,   5.91443539
  60574,   24.5578365,   10.3405104,   5.09732246
  60575,   24.5561123,   10.2930956,   4.28020954
  60576,    24.554388,   10.2456808,   3.46309662
  60577,   24.5526638,   10.1982651,    2.6459837
  60578,   24.5509396,   10.1508503,   1.82887089
  60579,   25.2965031,   14.3461752,   9.53731346
  60580,   25.2975502,   14.3173494,   9.07462692
  60581,   25.2985992,   14.2885246,   8.61194038
  60582,   25.2996464,   14.2596989,   8.14925385
  60583,   25.3006935,   14.2308741,   7.68656683
  60584,   25.3017426,   14.2020483,   7.22388029
  60585,   25.3027916,   14.1732225,   6.76119375
  60586,   25.3038387,   14.1443977,   6.29850721
  60587,   25.3048878,    14.115572,    5.8358202
  60588,   25.3059349,   14.0867472,   5.37313366
  60589,   25.3201809,   13.6950302,   9.51302719
  60590,   25.3221798,   13.6400595,   9.02605343
  60591,   25.3241787,   13.5850897,   8.53908062
  60592,   25.3261776,   13.5301199,   8.05210781
  60593,   25.3281765,   13.4751492,   7.56513453
  60594,   25.3301735,   13.4201784,   7.07816076
  60595,   25.3321724,   13.3652086,   6.59118748
  60596,   25.3341732,   13.3102379,   6.10421467
  60597,   25.3361721,   13.2552681,   5.61724138
  60598,    25.338171,   13.2002974,    5.1302681
  60599,   25.3436623,   13.0493116,   9.47304153
  60600,   25.3464146,   12.9736223,   8.94608307
  60601,   25.3491669,    12.897934,    8.4191246
  60602,   25.3519192,   12.8222456,   7.89216566
  60603,   25.3546715,   12.7465563,   7.36520672
  60604,   25.3574238,   12.6708679,   6.83824778
  60605,   25.3601742,   12.5951796,   6.31128931
  60606,   25.3629284,   12.5194902,   5.78433037
  60607,   25.3656807,   12.4438019,    5.2573719
  60608,    25.368433,   12.3681135,   4.73041344
  60609,   25.3668404,   12.4118662,   9.41821671
  60610,   25.3700466,   12.3237324,   8.83643341
  60611,    25.373251,   12.2355976,   8.25464916
  60612,   25.3764553,   12.1474638,   7.67286587
  60613,   25.3796597,     12.05933,    7.0910821
  60614,   25.3828659,   11.9711962,    6.5092988
  60615,   25.3860703,   11.8830614,   5.92751503
  60616,   25.3892746,   11.7949276,   5.34573174
  60617,   25.3924789,   11.7067938,   4.76394796
  60618,   25.3956833,     11.61866,   4.18216467
  60619,   25.3896141,   11.7856054,   9.34998417
  60620,   25.3928661,   11.6962109,   8.69996929
  60621,   25.3961163,   11.6068163,   8.04995346
  60622,   25.3993664,   11.5174208,   7.39993811
  60623,   25.4026165,   11.4280262,   6.74992228
  60624,   25.4058685,   11.3386316,   6.09990692
  60625,   25.4091187,   11.2492371,   5.44989109
  60626,   25.4123688,   11.1598425,   4.79987574
  60627,   25.4156189,   11.0704479,   4.14986038
  60628,   25.4188709,   10.9810524,   3.49984479
  60629,   25.4118767,    11.173358,   9.27052689
  60630,   25.4146652,   11.0967159,   8.54105377
  60631,   25.4174519,   11.0200739,   7.81158066
  60632,   25.4202385,   10.9434319,   7.08210754
  60633,   25.4230251,   10.8667889,   6.35263443
  60634,   25.4258137,   10.7901468,   5.62316132
  60635,   25.4286003,   10.7135048,   4.89368868
  60636,   25.4313869,   10.6368628,   4.16421556
  60637,   25.4341736,   10.5602207,   3.43474221
  60638,   25.4369621,   10.4835787,    2.7052691
  60639,   25.4335423,   10.5775852,   9.18288708
  60640,   25.4352665,   10.5301704,   8.36577415
  60641,   25.4369907,   10.4827547,   7.54866123
  60642,    25.438715,   10.4353399,   6.73154831
  60643,   25.4404392,   10.3879251,   5.91443539
  60644,   25.4421635,   10.3405104,   5.09732246
  60645,   25.4438896,   10.2930946,   4.28020954
  60646,    25.445612,   10.2456799,   3.46309662
  60647,   25.4473362,   10.1982651,    2.6459837
  60648,   25.4490604,   10.1508503,   1.82887065
  60649,   25.8895092,   14.3461752,   9.53731346
  60650,   25.8926525,   14.3173494,   9.07462692
  60651,   25.8957977,   14.2885246,   8.61194038
  60652,    25.898941,   14.2596989,   8.14925385
  60653,   25.9020863,   14.2308741,   7.68656683
  60654,   25.9052296,   14.2020483,   7.22388029
  60655,   25.9083767,   14.1732225,   6.76119375
  60656,     25.91152,   14.1443977,   6.29850721
  60657,   25.9146652,    14.115572,    5.8358202
  60658,   25.9178085,   14.0867472,   5.37313366
  60659,   25.9605427,   13.6950302,   9.51302719
  60660,   25.9665394,   13.6400595,   9.02605343
  60661,   25.9725361,   13.5850897,   8.53908062
  60662,   25.9785328,   13.5301199,   8.05210781
  60663,   25.9845295,   13.4751492,   7.56513453
  60664,   25.9905243,   13.4201784,   7.07816076
  60665,    25.996521,   13.3652086,   6.59118748
  60666,   26.0025196,   13.3102379,   6.10421467
  60667,   26.0085163,   13.2552681,   5.61724138
  60668,    26.014513,   13.2002974,    5.1302681
  60669,   26.0309849,   13.0493116,   9.47304153
  60670,   26.0392418,   12.9736223,   8.94608307
  60671,   26.0474987,    12.897934,    8.4191246
  60672,   26.0557556,   12.8222456,   7.89216566
  60673,   26.0640125,   12.7465563,   7.36520672
  60674,   26.0722694,   12.6708679,   6.83824778
  60675,   26.0805244,   12.5951796,   6.31128931
  60676,   26.0887833,   12.5194902,   5.78433037
  60677,   26.0970402,   12.4438019,    5.2573719
  60678,   26.1052971,   12.3681135,   4.73041344
  60679,   26.1005249,   12.4118662,   9.41821671
  60680,   26.1101398,   12.3237324,   8.83643341
  60681,   26.1197529,   12.2355976,   8.25464916
  60682,   26.1293678,   12.1474638,   7.67286587
  60683,   26.1389828,     12.05933,   7.09108257
  60684,   26.1485977,   11.9711962,    6.5092988
  60685,   26.1582127,   11.8830614,   5.92751551
  60686,   26.1678257,   11.7949276,   5.34573221
  60687,   26.1774406,   11.7067938,   4.76394844
  60688,   26.1870556,     11.61866,   4.18216467
  60689,   26.1688423,   11.7856054,   9.34998417
  60690,   26.1785946,   11.6962109,   8.69996929
  60691,   26.1883469,   11.6068163,   8.04995346
  60692,   26.1980991,   11.5174208,   7.39993811
  60693,   26.2078514,   11.4280262,   6.74992228
  60694,   26.2176037,   11.3386316,   6.09990692
  60695,    26.227356,   11.2492371,   5.44989109
  60696,   26.2371082,   11.1598425,   4.79987574
  60697,   26.2468605,   11.0704479,   4.14986038
  60698,   26.2566128,   10.9810524,   3.49984479
  60699,   26.2356339,    11.173358,   9.27052689
  60700,   26.2439938,   11.0967159,   8.54105377
  60701,   26.2523556,   11.0200739,   7.81158066
  60702,   26.2607155,   10.9434319,   7.08210754
  60703,   26.2690773,   10.8667889,   6.35263443
  60704,   26.2774372,   10.7901468,   5.62316132
  60705,    26.285799,   10.7135048,   4.89368868
  60706,   26.2941589,   10.6368628,   4.16421556
  60707,   26.3025208,   10.5602207,   3.43474221
  60708,   26.3108807,   10.4835787,    2.7052691
  60709,   26.3006268,   10.5775852,   9.18288708
  60710,   26.3057995,   10.5301704,   8.36577415
  60711,   26.3109722,   10.4827547,   7.54866123
  60712,   26.3161449,   10.4353399,   6.73154831
  60713,   26.3213158,   10.3879251,   5.91443539
  60714,   26.3264904,   10.3405104,   5.09732246
  60715,   26.3316631,   10.2930946,   4.28020954
  60716,    26.336834,   10.2456799,   3.46309638
  60717,   26.3420067,   10.1982651,   2.64598346
  60718,   26.3471794,   10.1508503,   1.82887053
  60719,   26.4825134,   14.3461752,   9.53731346
  60720,   26.4877548,   14.3173494,   9.07462692
  60721,   26.4929943,   14.2885246,   8.61194038
  60722,   26.4982357,   14.2596989,   8.14925385
  60723,   26.5034771,   14.2308741,   7.68656683
  60724,   26.5087166,   14.2020483,   7.22388029
  60725,   26.5139599,   14.1732225,   6.76119375
  60726,   26.5192013,   14.1443977,   6.29850721
  60727,   26.5244408,    14.115572,    5.8358202
  60728,   26.5296822,   14.0867472,   5.37313366
  60729,   26.6009045,   13.6950302,   9.51302719
  60730,    26.610899,   13.6400595,   9.02605343
  60731,   26.6208935,   13.5850897,   8.53908062
  60732,    26.630888,   13.5301199,   8.05210781
  60733,   26.6408825,   13.4751492,   7.56513453
  60734,   26.6508751,   13.4201794,   7.07816124
  60735,   26.6608696,   13.3652096,   6.59118795
  60736,    26.670866,   13.3102388,   6.10421515
  60737,   26.6808605,   13.2552691,   5.61724186
  60738,    26.690855,   13.2002983,   5.13026857
  60739,   26.7183075,   13.0493116,   9.47304153
  60740,    26.732069,   12.9736223,   8.94608307
  60741,   26.7458305,    12.897934,    8.4191246
  60742,   26.7595921,   12.8222456,   7.89216566
  60743,   26.7733536,   12.7465563,   7.36520672
  60744,   26.7871151,   12.6708679,   6.83824778
  60745,   26.8008747,   12.5951796,   6.31128931
  60746,   26.8146381,   12.5194902,   5.78433037
  60747,   26.8283997,   12.4438019,    5.2573719
  60748,   26.8421612,   12.3681135,   4.73041344
  60749,   26.8342056,   12.4118662,   9.41821671
  60750,   26.8502312,   12.3237324,   8.83643341
  60751,   26.8662548,   12.2355976,   8.25464916
  60752,   26.8822784,   12.1474638,   7.67286587
  60753,    26.898304,     12.05933,   7.09108257
  60754,   26.9143276,   11.9711962,    6.5092988
  60755,   26.9303513,   11.8830614,   5.92751551
  60756,   26.9463768,   11.7949276,   5.34573221
  60757,   26.9624004,   11.7067938,   4.76394844
  60758,   26.9784241,     11.61866,   4.18216467
  60759,   26.9480705,   11.7856054,   9.34998417
  60760,    26.964325,   11.6962109,   8.69996929
  60761,   26.9805775,   11.6068163,   8.04995346
  60762,   26.9968319,   11.5174208,   7.39993811
  60763,   27.0130863,   11.4280262,   6.74992228
  60764,   27.0293388,   11.3386316,   6.09990692
  60765,   27.0455933,   11.2492371,   5.44989109
  60766,   27.0618458,   11.1598425,   4.79987574
  60767,   27.0781002,   11.0704479,   4.14986038
  60768,   27.0943527,   10.9810524,   3.49984479
  60769,   27.0593891,    11.173358,   9.27052689
  60770,   27.0733242,   11.0967159,   8.54105377
  60771,   27.0872593,   11.0200739,   7.81158066
  60772,   27.1011944,   10.9434319,   7.08210754
  60773,   27.1151295,   10.8667889,   6.35263443
  60774,   27.1290627,   10.7901468,   5.62316132
  60775,   27.1429977,   10.7135048,   4.89368868
  60776,   27.1569328,   10.6368628,   4.16421509
  60777,   27.1708679,   10.5602207,   3.43474197
  60778,    27.184803,   10.4835787,    2.7052691
  60779,   27.1677113,   10.5775852,   9.18288708
  60780,   27.1763325,   10.5301704,   8.36577415
  60781,   27.1849537,   10.4827547,   7.54866123
  60782,   27.1935749,   10.4353399,   6.73154831
  60783,   27.2021942,   10.3879251,   5.91443539
  60784,   27.2108173,   10.3405104,   5.09732246
  60785,   27.2194386,   10.2930946,   4.28020954
  60786,   27.2280579,   10.2456799,   3.46309638
  60787,   27.2366791,   10.1982651,   2.64598346
  60788,   27.2453003,   10.1508503,   1.82887042
  60789,   27.0755196,   14.3461752,   9.53731346
  60790,   27.0828571,   14.3173494,   9.07462692
  60791,   27.0901928,   14.2885246,   8.61194038
  60792,   27.0975304,   14.2596989,   8.14925385
  60793,   27.1048679,   14.2308741,   7.68656683
  60794,   27.1122036,   14.2020483,   7.22388029
  60795,   27.1195431,   14.1732225,   6.76119375
  60796,   27.1268806,   14.1443977,   6.29850721
  60797,   27.1342163,    14.115572,    5.8358202
  60798,   27.1415539,   14.0867472,   5.37313366
  60799,   27.2412643,   13.6950302,   9.51302719
  60800,   27.2552567,   13.6400595,   9.02605343
  60801,    27.269249,   13.5850897,   8.53908062
  60802,   27.2832413,   13.5301199,   8.05210781
  60803,   27.2972336,   13.4751492,   7.56513453
  60804,   27.3112259,   13.4201794,   7.07816124
  60805,   27.3252182,   13.3652096,   6.59118795
  60806,   27.3392124,   13.3102388,   6.10421515
  60807,   27.3532047,   13.2552691,   5.61724186
  60808,    27.367197,   13.2002983,   5.13026857
  60809,   27.4056301,   13.0493116,   9.47304153
  60810,   27.4248962,   12.9736223,   8.94608307
  60811,   27.4441624,    12.897934,    8.4191246
  60812,   27.4634285,   12.8222456,   7.89216566
  60813,   27.4826946,   12.7465563,   7.36520672
  60814,   27.5019608,   12.6708679,   6.83824778
  60815,    27.521225,   12.5951796,   6.31128931
  60816,    27.540493,   12.5194902,   5.78433037
  60817,   27.5597591,   12.4438019,    5.2573719
  60818,   27.5790253,   12.3681135,   4.73041344
  60819,   27.5678883,   12.4118662,   9.41821671
  60820,   27.5903225,   12.3237324,   8.83643341
  60821,   27.6127567,   12.2355976,   8.25464916
  60822,    27.635191,   12.1474638,   7.67286587
  60823,   27.6576252,     12.05933,   7.09108257
  60824,   27.6800594,   11.9711962,    6.5092988
  60825,   27.7024937,   11.8830614,   5.92751551
  60826,   27.7249279,   11.7949276,   5.34573221
  60827,   27.7473602,   11.7067938,   4.76394844
  60828,   27.7697945,     11.61866,   4.18216467
  60829,   27.7273006,   11.7856054,   9.34998417
  60830,   27.7500553,   11.6962109,   8.69996929
  60831,     27.77281,   11.6068163,   8.04995346
  60832,   27.7955666,   11.5174208,   7.39993811
  60833,   27.8183212,   11.4280262,   6.74992228
  60834,   27.8410759,   11.3386316,   6.09990692
  60835,   27.8638306,   11.2492371,   5.44989109
  60836,   27.8865852,   11.1598425,   4.79987574
  60837,   27.9093418,   11.0704479,   4.14986038
  60838,   27.9320946,   10.9810524,   3.49984479
  60839,   27.8831444,    11.173358,   9.27052689
  60840,   27.9026546,   11.0967159,   8.54105377
  60841,    27.922163,   11.0200739,   7.81158066
  60842,   27.9416714,   10.9434319,   7.08210754
  60843,   27.9611797,   10.8667889,   6.35263443
  60844,     27.98069,   10.7901468,   5.62316132
  60845,   28.0001984,   10.7135048,    4.8936882
  60846,   28.0197067,   10.6368628,   4.16421509
  60847,   28.0392151,   10.5602207,   3.43474197
  60848,   28.0587254,   10.4835787,   2.70526886
  60849,   28.0347977,   10.5775852,   9.18288708
  60850,   28.0468655,   10.5301704,   8.36577415
  60851,   28.0589352,   10.4827547,   7.54866076
  60852,   28.0710049,   10.4353399,   6.73154783
  60853,   28.0830746,   10.3879251,   5.91443491
  60854,   28.0951424,   10.3405104,   5.09732199
  60855,    28.107214,   10.2930946,   4.28020906
  60856,   28.1192818,   10.2456799,   3.46309614
  60857,   28.1313515,   10.1982651,   2.64598322
  60858,   28.1434193,   10.1508503,    1.8288703
  60859,   27.6685238,   14.3461752,   9.53731346
  60860,   27.6779575,   14.3173494,   9.07462692
  60861,   27.6873913,   14.2885246,   8.61194038
  60862,    27.696825,   14.2596989,   8.14925385
  60863,   27.7062588,   14.2308741,   7.68656683
  60864,   27.7156906,   14.2020483,   7.22388029
  60865,   27.7251263,   14.1732225,   6.76119375
  60866,     27.73456,   14.1443977,   6.29850721
  60867,   27.7439938,    14.115572,    5.8358202
  60868,   27.7534275,   14.0867472,   5.37313366
  60869,   27.8816261,   13.6950302,   9.51302719
  60870,   27.8996162,   13.6400595,   9.02605343
  60871,   27.9176064,   13.5850897,   8.53908062
  60872,   27.9355965,   13.5301199,   8.05210781
  60873,   27.9535866,   13.4751492,   7.56513453
  60874,   27.9715767,   13.4201794,   7.07816124
  60875,   27.9895668,   13.3652096,   6.59118795
  60876,   28.0075588,   13.3102388,   6.10421515
  60877,   28.0255489,   13.2552691,   5.61724186
  60878,    28.043539,   13.2002983,   5.13026857
  60879,   28.0929527,   13.0493116,   9.47304153
  60880,   28.1177235,   12.9736223,   8.94608307
  60881,   28.1424942,    12.897934,    8.4191246
  60882,   28.1672649,   12.8222456,   7.89216566
  60883,   28.1920357,   12.7465563,   7.36520672
  60884,   28.2168064,   12.6708679,   6.83824778
  60885,   28.2415752,   12.5951796,   6.31128931
  60886,   28.2663479,   12.5194902,   5.78433037
  60887,   28.2911186,   12.4438019,    5.2573719
  60888,   28.3158894,   12.3681135,   4.73041344
  60889,   28.3015709,   12.4118662,   9.41821671
  60890,   28.3304157,   12.3237324,   8.83643341
  60891,   28.3592587,   12.2355976,   8.25464916
  60892,   28.3881035,   12.1474638,   7.67286587
  60893,   28.4169464,     12.05933,   7.09108257
  60894,   28.4457893,   11.9711962,    6.5092988
  60895,   28.4746342,   11.8830614,   5.92751551
  60896,   28.5034771,   11.7949276,   5.34573221
  60897,     28.53232,   11.7067938,   4.76394844
  60898,   28.5611649,     11.61866,   4.18216467
  60899,   28.5065269,   11.7856054,   9.34998417
  60900,   28.5357857,   11.6962109,   8.69996929
  60901,   28.5650406,   11.6068163,   8.04995346
  60902,   28.5942974,   11.5174208,   7.39993811
  60903,   28.6235542,   11.4280262,   6.74992228
  60904,   28.6528111,   11.3386316,   6.09990692
  60905,   28.6820679,   11.2492371,   5.44989109
  60906,   28.7113228,   11.1598425,   4.79987574
  60907,   28.7405796,   11.0704479,   4.14986038
  60908,   28.7698364,   10.9810524,   3.49984479
  60909,   28.7069016,    11.173358,   9.27052689
  60910,   28.7319832,   11.0967159,   8.54105377
  60911,   28.7570667,   11.0200739,   7.81158066
  60912,   28.7821503,   10.9434319,   7.08210754
  60913,   28.8072319,   10.8667889,   6.35263443
  60914,   28.8323154,   10.7901468,   5.62316132
  60915,   28.8573971,   10.7135048,    4.8936882
  60916,   28.8824806,   10.6368628,   4.16421509
  60917,   28.9075642,   10.5602207,   3.43474174
  60918,   28.9326458,   10.4835787,   2.70526886
  60919,   28.9018822,   10.5775852,   9.18288708
  60920,   28.9173985,   10.5301704,   8.36577415
  60921,   28.9329166,   10.4827547,   7.54866076
  60922,   28.9484348,   10.4353399,   6.73154783
  60923,   28.9639511,   10.3879251,   5.91443491
  60924,   28.9794712,   10.3405104,   5.09732199
  60925,   28.9949894,   10.2930946,   4.28020906
  60926,   29.0105057,   10.2456799,   3.46309614
  60927,   29.0260239,   10.1982651,   2.64598298
  60928,   29.0415401,   10.1508503,   1.82887018
  60929,     20.90909,   9.16666698,    -9.090909
  60930,    21.818182,   9.16666698,    -9.090909
  60931,    22.727272,   9.16666698,    -9.090909
  60932,    23.636364,   9.16666698,    -9.090909
  60933,    24.545454,   9.16666698,    -9.090909
  60934,    25.454546,   9.16666698,    -9.090909
  60935,    26.363636,   9.16666698,    -9.090909
  60936,    27.272728,   9.16666698,    -9.090909
  60937,    28.181818,   9.16666698,    -9.090909
  60938,     29.09091,   9.16666698,    -9.090909
  60939,     20.90909,   8.33333302,    -9.090909
  60940,    21.818182,   8.33333302,    -9.090909
  60941,    22.727272,   8.33333302,    -9.090909
  60942,    23.636364,   8.33333302,    -9.090909
  60943,    24.545454,   8.33333302,    -9.090909
  60944,    25.454546,   8.33333302,    -9.090909
  60945,    26.363636,   8.33333302,    -9.090909
  60946,    27.272728,   8.33333302,    -9.090909
  60947,    28.181818,   8.33333302,    -9.090909
  60948,     29.09091,   8.33333302,    -9.090909
  60949,     20.90909,          7.5,    -9.090909
  60950,    21.818182,          7.5,    -9.090909
  60951,    22.727272,          7.5,    -9.090909
  60952,    23.636364,          7.5,    -9.090909
  60953,    24.545454,          7.5,    -9.090909
  60954,    25.454546,          7.5,    -9.090909
  60955,    26.363636,          7.5,    -9.090909
  60956,    27.272728,          7.5,    -9.090909
  60957,    28.181818,          7.5,    -9.090909
  60958,     29.09091,          7.5,    -9.090909
  60959,     20.90909,   6.66666651,    -9.090909
  60960,    21.818182,   6.66666651,    -9.090909
  60961,    22.727272,   6.66666651,    -9.090909
  60962,    23.636364,   6.66666651,    -9.090909
  60963,    24.545454,   6.66666651,    -9.090909
  60964,    25.454546,   6.66666651,    -9.090909
  60965,    26.363636,   6.66666651,    -9.090909
  60966,    27.272728,   6.66666651,    -9.090909
  60967,    28.181818,   6.66666651,    -9.090909
  60968,     29.09091,   6.66666651,    -9.090909
  60969,     20.90909,   5.83333349,    -9.090909
  60970,    21.818182,   5.83333349,    -9.090909
  60971,    22.727272,   5.83333349,    -9.090909
  60972,    23.636364,   5.83333349,    -9.090909
  60973,    24.545454,   5.83333349,    -9.090909
  60974,    25.454546,   5.83333349,    -9.090909
  60975,    26.363636,   5.83333349,    -9.090909
  60976,    27.272728,   5.83333349,    -9.090909
  60977,    28.181818,   5.83333349,    -9.090909
  60978,     29.09091,   5.83333349,    -9.090909
  60979,     20.90909,           5.,    -9.090909
  60980,    21.818182,           5.,    -9.090909
  60981,    22.727272,           5.,    -9.090909
  60982,    23.636364,           5.,    -9.090909
  60983,    24.545454,           5.,    -9.090909
  60984,    25.454546,           5.,    -9.090909
  60985,    26.363636,           5.,    -9.090909
  60986,    27.272728,           5.,    -9.090909
  60987,    28.181818,           5.,    -9.090909
  60988,     29.09091,           5.,    -9.090909
  60989,     20.90909,   4.16666651,    -9.090909
  60990,    21.818182,   4.16666651,    -9.090909
  60991,    22.727272,   4.16666651,    -9.090909
  60992,    23.636364,   4.16666651,    -9.090909
  60993,    24.545454,   4.16666651,    -9.090909
  60994,    25.454546,   4.16666651,    -9.090909
  60995,    26.363636,   4.16666651,    -9.090909
  60996,    27.272728,   4.16666651,    -9.090909
  60997,    28.181818,   4.16666651,    -9.090909
  60998,     29.09091,   4.16666651,    -9.090909
  60999,     20.90909,   3.33333325,    -9.090909
  61000,    21.818182,   3.33333325,    -9.090909
  61001,    22.727272,   3.33333325,    -9.090909
  61002,    23.636364,   3.33333325,    -9.090909
  61003,    24.545454,   3.33333325,    -9.090909
  61004,    25.454546,   3.33333325,    -9.090909
  61005,    26.363636,   3.33333325,    -9.090909
  61006,    27.272728,   3.33333325,    -9.090909
  61007,    28.181818,   3.33333325,    -9.090909
  61008,     29.09091,   3.33333325,    -9.090909
  61009,     20.90909,          2.5,    -9.090909
  61010,    21.818182,          2.5,    -9.090909
  61011,    22.727272,          2.5,    -9.090909
  61012,    23.636364,          2.5,    -9.090909
  61013,    24.545454,          2.5,    -9.090909
  61014,    25.454546,          2.5,    -9.090909
  61015,    26.363636,          2.5,    -9.090909
  61016,    27.272728,          2.5,    -9.090909
  61017,    28.181818,          2.5,    -9.090909
  61018,     29.09091,          2.5,    -9.090909
  61019,     20.90909,   1.66666663,    -9.090909
  61020,    21.818182,   1.66666663,    -9.090909
  61021,    22.727272,   1.66666663,    -9.090909
  61022,    23.636364,   1.66666663,    -9.090909
  61023,    24.545454,   1.66666663,    -9.090909
  61024,    25.454546,   1.66666663,    -9.090909
  61025,    26.363636,   1.66666663,    -9.090909
  61026,    27.272728,   1.66666663,    -9.090909
  61027,    28.181818,   1.66666663,    -9.090909
  61028,     29.09091,   1.66666663,    -9.090909
  61029,     20.90909,  0.833333313,    -9.090909
  61030,    21.818182,  0.833333313,    -9.090909
  61031,    22.727272,  0.833333313,    -9.090909
  61032,    23.636364,  0.833333313,    -9.090909
  61033,    24.545454,  0.833333313,    -9.090909
  61034,    25.454546,  0.833333313,    -9.090909
  61035,    26.363636,  0.833333313,    -9.090909
  61036,    27.272728,  0.833333313,    -9.090909
  61037,    28.181818,  0.833333313,    -9.090909
  61038,     29.09091,  0.833333313,    -9.090909
  61039,     20.90909,   9.16666698,  -8.18181801
  61040,    21.818182,   9.16666698,  -8.18181801
  61041,    22.727272,   9.16666698,  -8.18181801
  61042,    23.636364,   9.16666698,  -8.18181801
  61043,    24.545454,   9.16666698,  -8.18181801
  61044,    25.454546,   9.16666698,  -8.18181801
  61045,    26.363636,   9.16666698,  -8.18181801
  61046,    27.272728,   9.16666698,  -8.18181801
  61047,    28.181818,   9.16666698,  -8.18181801
  61048,     29.09091,   9.16666698,  -8.18181801
  61049,     20.90909,   8.33333302,  -8.18181801
  61050,    21.818182,   8.33333302,  -8.18181801
  61051,    22.727272,   8.33333302,  -8.18181801
  61052,    23.636364,   8.33333302,  -8.18181801
  61053,    24.545454,   8.33333302,  -8.18181801
  61054,    25.454546,   8.33333302,  -8.18181801
  61055,    26.363636,   8.33333302,  -8.18181801
  61056,    27.272728,   8.33333302,  -8.18181801
  61057,    28.181818,   8.33333302,  -8.18181801
  61058,     29.09091,   8.33333302,  -8.18181801
  61059,     20.90909,          7.5,  -8.18181801
  61060,    21.818182,          7.5,  -8.18181801
  61061,    22.727272,          7.5,  -8.18181801
  61062,    23.636364,          7.5,  -8.18181801
  61063,    24.545454,          7.5,  -8.18181801
  61064,    25.454546,          7.5,  -8.18181801
  61065,    26.363636,          7.5,  -8.18181801
  61066,    27.272728,          7.5,  -8.18181801
  61067,    28.181818,          7.5,  -8.18181801
  61068,     29.09091,          7.5,  -8.18181801
  61069,     20.90909,   6.66666651,  -8.18181801
  61070,    21.818182,   6.66666651,  -8.18181801
  61071,    22.727272,   6.66666651,  -8.18181801
  61072,    23.636364,   6.66666651,  -8.18181801
  61073,    24.545454,   6.66666651,  -8.18181801
  61074,    25.454546,   6.66666651,  -8.18181801
  61075,    26.363636,   6.66666651,  -8.18181801
  61076,    27.272728,   6.66666651,  -8.18181801
  61077,    28.181818,   6.66666651,  -8.18181801
  61078,     29.09091,   6.66666651,  -8.18181801
  61079,     20.90909,   5.83333349,  -8.18181801
  61080,    21.818182,   5.83333349,  -8.18181801
  61081,    22.727272,   5.83333349,  -8.18181801
  61082,    23.636364,   5.83333349,  -8.18181801
  61083,    24.545454,   5.83333349,  -8.18181801
  61084,    25.454546,   5.83333349,  -8.18181801
  61085,    26.363636,   5.83333349,  -8.18181801
  61086,    27.272728,   5.83333349,  -8.18181801
  61087,    28.181818,   5.83333349,  -8.18181801
  61088,     29.09091,   5.83333349,  -8.18181801
  61089,     20.90909,           5.,  -8.18181801
  61090,    21.818182,           5.,  -8.18181801
  61091,    22.727272,           5.,  -8.18181801
  61092,    23.636364,           5.,  -8.18181801
  61093,    24.545454,           5.,  -8.18181801
  61094,    25.454546,           5.,  -8.18181801
  61095,    26.363636,           5.,  -8.18181801
  61096,    27.272728,           5.,  -8.18181801
  61097,    28.181818,           5.,  -8.18181801
  61098,     29.09091,           5.,  -8.18181801
  61099,     20.90909,   4.16666651,  -8.18181801
  61100,    21.818182,   4.16666651,  -8.18181801
  61101,    22.727272,   4.16666651,  -8.18181801
  61102,    23.636364,   4.16666651,  -8.18181801
  61103,    24.545454,   4.16666651,  -8.18181801
  61104,    25.454546,   4.16666651,  -8.18181801
  61105,    26.363636,   4.16666651,  -8.18181801
  61106,    27.272728,   4.16666651,  -8.18181801
  61107,    28.181818,   4.16666651,  -8.18181801
  61108,     29.09091,   4.16666651,  -8.18181801
  61109,     20.90909,   3.33333325,  -8.18181801
  61110,    21.818182,   3.33333325,  -8.18181801
  61111,    22.727272,   3.33333325,  -8.18181801
  61112,    23.636364,   3.33333325,  -8.18181801
  61113,    24.545454,   3.33333325,  -8.18181801
  61114,    25.454546,   3.33333325,  -8.18181801
  61115,    26.363636,   3.33333325,  -8.18181801
  61116,    27.272728,   3.33333325,  -8.18181801
  61117,    28.181818,   3.33333325,  -8.18181801
  61118,     29.09091,   3.33333325,  -8.18181801
  61119,     20.90909,          2.5,  -8.18181801
  61120,    21.818182,          2.5,  -8.18181801
  61121,    22.727272,          2.5,  -8.18181801
  61122,    23.636364,          2.5,  -8.18181801
  61123,    24.545454,          2.5,  -8.18181801
  61124,    25.454546,          2.5,  -8.18181801
  61125,    26.363636,          2.5,  -8.18181801
  61126,    27.272728,          2.5,  -8.18181801
  61127,    28.181818,          2.5,  -8.18181801
  61128,     29.09091,          2.5,  -8.18181801
  61129,     20.90909,   1.66666663,  -8.18181801
  61130,    21.818182,   1.66666663,  -8.18181801
  61131,    22.727272,   1.66666663,  -8.18181801
  61132,    23.636364,   1.66666663,  -8.18181801
  61133,    24.545454,   1.66666663,  -8.18181801
  61134,    25.454546,   1.66666663,  -8.18181801
  61135,    26.363636,   1.66666663,  -8.18181801
  61136,    27.272728,   1.66666663,  -8.18181801
  61137,    28.181818,   1.66666663,  -8.18181801
  61138,     29.09091,   1.66666663,  -8.18181801
  61139,     20.90909,  0.833333313,  -8.18181801
  61140,    21.818182,  0.833333313,  -8.18181801
  61141,    22.727272,  0.833333313,  -8.18181801
  61142,    23.636364,  0.833333313,  -8.18181801
  61143,    24.545454,  0.833333313,  -8.18181801
  61144,    25.454546,  0.833333313,  -8.18181801
  61145,    26.363636,  0.833333313,  -8.18181801
  61146,    27.272728,  0.833333313,  -8.18181801
  61147,    28.181818,  0.833333313,  -8.18181801
  61148,     29.09091,  0.833333313,  -8.18181801
  61149,     20.90909,   9.16666698,  -7.27272749
  61150,    21.818182,   9.16666698,  -7.27272749
  61151,    22.727272,   9.16666698,  -7.27272749
  61152,    23.636364,   9.16666698,  -7.27272749
  61153,    24.545454,   9.16666698,  -7.27272749
  61154,    25.454546,   9.16666698,  -7.27272749
  61155,    26.363636,   9.16666698,  -7.27272749
  61156,    27.272728,   9.16666698,  -7.27272749
  61157,    28.181818,   9.16666698,  -7.27272749
  61158,     29.09091,   9.16666698,  -7.27272749
  61159,     20.90909,   8.33333302,  -7.27272749
  61160,    21.818182,   8.33333302,  -7.27272749
  61161,    22.727272,   8.33333302,  -7.27272749
  61162,    23.636364,   8.33333302,  -7.27272749
  61163,    24.545454,   8.33333302,  -7.27272749
  61164,    25.454546,   8.33333302,  -7.27272749
  61165,    26.363636,   8.33333302,  -7.27272749
  61166,    27.272728,   8.33333302,  -7.27272749
  61167,    28.181818,   8.33333302,  -7.27272749
  61168,     29.09091,   8.33333302,  -7.27272749
  61169,     20.90909,          7.5,  -7.27272749
  61170,    21.818182,          7.5,  -7.27272749
  61171,    22.727272,          7.5,  -7.27272749
  61172,    23.636364,          7.5,  -7.27272749
  61173,    24.545454,          7.5,  -7.27272749
  61174,    25.454546,          7.5,  -7.27272749
  61175,    26.363636,          7.5,  -7.27272749
  61176,    27.272728,          7.5,  -7.27272749
  61177,    28.181818,          7.5,  -7.27272749
  61178,     29.09091,          7.5,  -7.27272749
  61179,     20.90909,   6.66666651,  -7.27272749
  61180,    21.818182,   6.66666651,  -7.27272749
  61181,    22.727272,   6.66666651,  -7.27272749
  61182,    23.636364,   6.66666651,  -7.27272749
  61183,    24.545454,   6.66666651,  -7.27272749
  61184,    25.454546,   6.66666651,  -7.27272749
  61185,    26.363636,   6.66666651,  -7.27272749
  61186,    27.272728,   6.66666651,  -7.27272749
  61187,    28.181818,   6.66666651,  -7.27272749
  61188,     29.09091,   6.66666651,  -7.27272749
  61189,     20.90909,   5.83333349,  -7.27272749
  61190,    21.818182,   5.83333349,  -7.27272749
  61191,    22.727272,   5.83333349,  -7.27272749
  61192,    23.636364,   5.83333349,  -7.27272749
  61193,    24.545454,   5.83333349,  -7.27272749
  61194,    25.454546,   5.83333349,  -7.27272749
  61195,    26.363636,   5.83333349,  -7.27272749
  61196,    27.272728,   5.83333349,  -7.27272749
  61197,    28.181818,   5.83333349,  -7.27272749
  61198,     29.09091,   5.83333349,  -7.27272749
  61199,     20.90909,           5.,  -7.27272749
  61200,    21.818182,           5.,  -7.27272749
  61201,    22.727272,           5.,  -7.27272749
  61202,    23.636364,           5.,  -7.27272749
  61203,    24.545454,           5.,  -7.27272749
  61204,    25.454546,           5.,  -7.27272749
  61205,    26.363636,           5.,  -7.27272749
  61206,    27.272728,           5.,  -7.27272749
  61207,    28.181818,           5.,  -7.27272749
  61208,     29.09091,           5.,  -7.27272749
  61209,     20.90909,   4.16666651,  -7.27272749
  61210,    21.818182,   4.16666651,  -7.27272749
  61211,    22.727272,   4.16666651,  -7.27272749
  61212,    23.636364,   4.16666651,  -7.27272749
  61213,    24.545454,   4.16666651,  -7.27272749
  61214,    25.454546,   4.16666651,  -7.27272749
  61215,    26.363636,   4.16666651,  -7.27272749
  61216,    27.272728,   4.16666651,  -7.27272749
  61217,    28.181818,   4.16666651,  -7.27272749
  61218,     29.09091,   4.16666651,  -7.27272749
  61219,     20.90909,   3.33333325,  -7.27272749
  61220,    21.818182,   3.33333325,  -7.27272749
  61221,    22.727272,   3.33333325,  -7.27272749
  61222,    23.636364,   3.33333325,  -7.27272749
  61223,    24.545454,   3.33333325,  -7.27272749
  61224,    25.454546,   3.33333325,  -7.27272749
  61225,    26.363636,   3.33333325,  -7.27272749
  61226,    27.272728,   3.33333325,  -7.27272749
  61227,    28.181818,   3.33333325,  -7.27272749
  61228,     29.09091,   3.33333325,  -7.27272749
  61229,     20.90909,          2.5,  -7.27272749
  61230,    21.818182,          2.5,  -7.27272749
  61231,    22.727272,          2.5,  -7.27272749
  61232,    23.636364,          2.5,  -7.27272749
  61233,    24.545454,          2.5,  -7.27272749
  61234,    25.454546,          2.5,  -7.27272749
  61235,    26.363636,          2.5,  -7.27272749
  61236,    27.272728,          2.5,  -7.27272749
  61237,    28.181818,          2.5,  -7.27272749
  61238,     29.09091,          2.5,  -7.27272749
  61239,     20.90909,   1.66666663,  -7.27272749
  61240,    21.818182,   1.66666663,  -7.27272749
  61241,    22.727272,   1.66666663,  -7.27272749
  61242,    23.636364,   1.66666663,  -7.27272749
  61243,    24.545454,   1.66666663,  -7.27272749
  61244,    25.454546,   1.66666663,  -7.27272749
  61245,    26.363636,   1.66666663,  -7.27272749
  61246,    27.272728,   1.66666663,  -7.27272749
  61247,    28.181818,   1.66666663,  -7.27272749
  61248,     29.09091,   1.66666663,  -7.27272749
  61249,     20.90909,  0.833333313,  -7.27272749
  61250,    21.818182,  0.833333313,  -7.27272749
  61251,    22.727272,  0.833333313,  -7.27272749
  61252,    23.636364,  0.833333313,  -7.27272749
  61253,    24.545454,  0.833333313,  -7.27272749
  61254,    25.454546,  0.833333313,  -7.27272749
  61255,    26.363636,  0.833333313,  -7.27272749
  61256,    27.272728,  0.833333313,  -7.27272749
  61257,    28.181818,  0.833333313,  -7.27272749
  61258,     29.09091,  0.833333313,  -7.27272749
  61259,     20.90909,   9.16666698,  -6.36363649
  61260,    21.818182,   9.16666698,  -6.36363649
  61261,    22.727272,   9.16666698,  -6.36363649
  61262,    23.636364,   9.16666698,  -6.36363649
  61263,    24.545454,   9.16666698,  -6.36363649
  61264,    25.454546,   9.16666698,  -6.36363649
  61265,    26.363636,   9.16666698,  -6.36363649
  61266,    27.272728,   9.16666698,  -6.36363649
  61267,    28.181818,   9.16666698,  -6.36363649
  61268,     29.09091,   9.16666698,  -6.36363649
  61269,     20.90909,   8.33333302,  -6.36363649
  61270,    21.818182,   8.33333302,  -6.36363649
  61271,    22.727272,   8.33333302,  -6.36363649
  61272,    23.636364,   8.33333302,  -6.36363649
  61273,    24.545454,   8.33333302,  -6.36363649
  61274,    25.454546,   8.33333302,  -6.36363649
  61275,    26.363636,   8.33333302,  -6.36363649
  61276,    27.272728,   8.33333302,  -6.36363649
  61277,    28.181818,   8.33333302,  -6.36363649
  61278,     29.09091,   8.33333302,  -6.36363649
  61279,     20.90909,          7.5,  -6.36363649
  61280,    21.818182,          7.5,  -6.36363649
  61281,    22.727272,          7.5,  -6.36363649
  61282,    23.636364,          7.5,  -6.36363649
  61283,    24.545454,          7.5,  -6.36363649
  61284,    25.454546,          7.5,  -6.36363649
  61285,    26.363636,          7.5,  -6.36363649
  61286,    27.272728,          7.5,  -6.36363649
  61287,    28.181818,          7.5,  -6.36363649
  61288,     29.09091,          7.5,  -6.36363649
  61289,     20.90909,   6.66666651,  -6.36363649
  61290,    21.818182,   6.66666651,  -6.36363649
  61291,    22.727272,   6.66666651,  -6.36363649
  61292,    23.636364,   6.66666651,  -6.36363649
  61293,    24.545454,   6.66666651,  -6.36363649
  61294,    25.454546,   6.66666651,  -6.36363649
  61295,    26.363636,   6.66666651,  -6.36363649
  61296,    27.272728,   6.66666651,  -6.36363649
  61297,    28.181818,   6.66666651,  -6.36363649
  61298,     29.09091,   6.66666651,  -6.36363649
  61299,     20.90909,   5.83333349,  -6.36363649
  61300,    21.818182,   5.83333349,  -6.36363649
  61301,    22.727272,   5.83333349,  -6.36363649
  61302,    23.636364,   5.83333349,  -6.36363649
  61303,    24.545454,   5.83333349,  -6.36363649
  61304,    25.454546,   5.83333349,  -6.36363649
  61305,    26.363636,   5.83333349,  -6.36363649
  61306,    27.272728,   5.83333349,  -6.36363649
  61307,    28.181818,   5.83333349,  -6.36363649
  61308,     29.09091,   5.83333349,  -6.36363649
  61309,     20.90909,           5.,  -6.36363649
  61310,    21.818182,           5.,  -6.36363649
  61311,    22.727272,           5.,  -6.36363649
  61312,    23.636364,           5.,  -6.36363649
  61313,    24.545454,           5.,  -6.36363649
  61314,    25.454546,           5.,  -6.36363649
  61315,    26.363636,           5.,  -6.36363649
  61316,    27.272728,           5.,  -6.36363649
  61317,    28.181818,           5.,  -6.36363649
  61318,     29.09091,           5.,  -6.36363649
  61319,     20.90909,   4.16666651,  -6.36363649
  61320,    21.818182,   4.16666651,  -6.36363649
  61321,    22.727272,   4.16666651,  -6.36363649
  61322,    23.636364,   4.16666651,  -6.36363649
  61323,    24.545454,   4.16666651,  -6.36363649
  61324,    25.454546,   4.16666651,  -6.36363649
  61325,    26.363636,   4.16666651,  -6.36363649
  61326,    27.272728,   4.16666651,  -6.36363649
  61327,    28.181818,   4.16666651,  -6.36363649
  61328,     29.09091,   4.16666651,  -6.36363649
  61329,     20.90909,   3.33333325,  -6.36363649
  61330,    21.818182,   3.33333325,  -6.36363649
  61331,    22.727272,   3.33333325,  -6.36363649
  61332,    23.636364,   3.33333325,  -6.36363649
  61333,    24.545454,   3.33333325,  -6.36363649
  61334,    25.454546,   3.33333325,  -6.36363649
  61335,    26.363636,   3.33333325,  -6.36363649
  61336,    27.272728,   3.33333325,  -6.36363649
  61337,    28.181818,   3.33333325,  -6.36363649
  61338,     29.09091,   3.33333325,  -6.36363649
  61339,     20.90909,          2.5,  -6.36363649
  61340,    21.818182,          2.5,  -6.36363649
  61341,    22.727272,          2.5,  -6.36363649
  61342,    23.636364,          2.5,  -6.36363649
  61343,    24.545454,          2.5,  -6.36363649
  61344,    25.454546,          2.5,  -6.36363649
  61345,    26.363636,          2.5,  -6.36363649
  61346,    27.272728,          2.5,  -6.36363649
  61347,    28.181818,          2.5,  -6.36363649
  61348,     29.09091,          2.5,  -6.36363649
  61349,     20.90909,   1.66666663,  -6.36363649
  61350,    21.818182,   1.66666663,  -6.36363649
  61351,    22.727272,   1.66666663,  -6.36363649
  61352,    23.636364,   1.66666663,  -6.36363649
  61353,    24.545454,   1.66666663,  -6.36363649
  61354,    25.454546,   1.66666663,  -6.36363649
  61355,    26.363636,   1.66666663,  -6.36363649
  61356,    27.272728,   1.66666663,  -6.36363649
  61357,    28.181818,   1.66666663,  -6.36363649
  61358,     29.09091,   1.66666663,  -6.36363649
  61359,     20.90909,  0.833333313,  -6.36363649
  61360,    21.818182,  0.833333313,  -6.36363649
  61361,    22.727272,  0.833333313,  -6.36363649
  61362,    23.636364,  0.833333313,  -6.36363649
  61363,    24.545454,  0.833333313,  -6.36363649
  61364,    25.454546,  0.833333313,  -6.36363649
  61365,    26.363636,  0.833333313,  -6.36363649
  61366,    27.272728,  0.833333313,  -6.36363649
  61367,    28.181818,  0.833333313,  -6.36363649
  61368,     29.09091,  0.833333313,  -6.36363649
  61369,     20.90909,   9.16666698,   -5.4545455
  61370,    21.818182,   9.16666698,   -5.4545455
  61371,    22.727272,   9.16666698,   -5.4545455
  61372,    23.636364,   9.16666698,   -5.4545455
  61373,    24.545454,   9.16666698,   -5.4545455
  61374,    25.454546,   9.16666698,   -5.4545455
  61375,    26.363636,   9.16666698,   -5.4545455
  61376,    27.272728,   9.16666698,   -5.4545455
  61377,    28.181818,   9.16666698,   -5.4545455
  61378,     29.09091,   9.16666698,   -5.4545455
  61379,     20.90909,   8.33333302,   -5.4545455
  61380,    21.818182,   8.33333302,   -5.4545455
  61381,    22.727272,   8.33333302,   -5.4545455
  61382,    23.636364,   8.33333302,   -5.4545455
  61383,    24.545454,   8.33333302,   -5.4545455
  61384,    25.454546,   8.33333302,   -5.4545455
  61385,    26.363636,   8.33333302,   -5.4545455
  61386,    27.272728,   8.33333302,   -5.4545455
  61387,    28.181818,   8.33333302,   -5.4545455
  61388,     29.09091,   8.33333302,   -5.4545455
  61389,     20.90909,          7.5,   -5.4545455
  61390,    21.818182,          7.5,   -5.4545455
  61391,    22.727272,          7.5,   -5.4545455
  61392,    23.636364,          7.5,   -5.4545455
  61393,    24.545454,          7.5,   -5.4545455
  61394,    25.454546,          7.5,   -5.4545455
  61395,    26.363636,          7.5,   -5.4545455
  61396,    27.272728,          7.5,   -5.4545455
  61397,    28.181818,          7.5,   -5.4545455
  61398,     29.09091,          7.5,   -5.4545455
  61399,     20.90909,   6.66666651,   -5.4545455
  61400,    21.818182,   6.66666651,   -5.4545455
  61401,    22.727272,   6.66666651,   -5.4545455
  61402,    23.636364,   6.66666651,   -5.4545455
  61403,    24.545454,   6.66666651,   -5.4545455
  61404,    25.454546,   6.66666651,   -5.4545455
  61405,    26.363636,   6.66666651,   -5.4545455
  61406,    27.272728,   6.66666651,   -5.4545455
  61407,    28.181818,   6.66666651,   -5.4545455
  61408,     29.09091,   6.66666651,   -5.4545455
  61409,     20.90909,   5.83333349,   -5.4545455
  61410,    21.818182,   5.83333349,   -5.4545455
  61411,    22.727272,   5.83333349,   -5.4545455
  61412,    23.636364,   5.83333349,   -5.4545455
  61413,    24.545454,   5.83333349,   -5.4545455
  61414,    25.454546,   5.83333349,   -5.4545455
  61415,    26.363636,   5.83333349,   -5.4545455
  61416,    27.272728,   5.83333349,   -5.4545455
  61417,    28.181818,   5.83333349,   -5.4545455
  61418,     29.09091,   5.83333349,   -5.4545455
  61419,     20.90909,           5.,   -5.4545455
  61420,    21.818182,           5.,   -5.4545455
  61421,    22.727272,           5.,   -5.4545455
  61422,    23.636364,           5.,   -5.4545455
  61423,    24.545454,           5.,   -5.4545455
  61424,    25.454546,           5.,   -5.4545455
  61425,    26.363636,           5.,   -5.4545455
  61426,    27.272728,           5.,   -5.4545455
  61427,    28.181818,           5.,   -5.4545455
  61428,     29.09091,           5.,   -5.4545455
  61429,     20.90909,   4.16666651,   -5.4545455
  61430,    21.818182,   4.16666651,   -5.4545455
  61431,    22.727272,   4.16666651,   -5.4545455
  61432,    23.636364,   4.16666651,   -5.4545455
  61433,    24.545454,   4.16666651,   -5.4545455
  61434,    25.454546,   4.16666651,   -5.4545455
  61435,    26.363636,   4.16666651,   -5.4545455
  61436,    27.272728,   4.16666651,   -5.4545455
  61437,    28.181818,   4.16666651,   -5.4545455
  61438,     29.09091,   4.16666651,   -5.4545455
  61439,     20.90909,   3.33333325,   -5.4545455
  61440,    21.818182,   3.33333325,   -5.4545455
  61441,    22.727272,   3.33333325,   -5.4545455
  61442,    23.636364,   3.33333325,   -5.4545455
  61443,    24.545454,   3.33333325,   -5.4545455
  61444,    25.454546,   3.33333325,   -5.4545455
  61445,    26.363636,   3.33333325,   -5.4545455
  61446,    27.272728,   3.33333325,   -5.4545455
  61447,    28.181818,   3.33333325,   -5.4545455
  61448,     29.09091,   3.33333325,   -5.4545455
  61449,     20.90909,          2.5,   -5.4545455
  61450,    21.818182,          2.5,   -5.4545455
  61451,    22.727272,          2.5,   -5.4545455
  61452,    23.636364,          2.5,   -5.4545455
  61453,    24.545454,          2.5,   -5.4545455
  61454,    25.454546,          2.5,   -5.4545455
  61455,    26.363636,          2.5,   -5.4545455
  61456,    27.272728,          2.5,   -5.4545455
  61457,    28.181818,          2.5,   -5.4545455
  61458,     29.09091,          2.5,   -5.4545455
  61459,     20.90909,   1.66666663,   -5.4545455
  61460,    21.818182,   1.66666663,   -5.4545455
  61461,    22.727272,   1.66666663,   -5.4545455
  61462,    23.636364,   1.66666663,   -5.4545455
  61463,    24.545454,   1.66666663,   -5.4545455
  61464,    25.454546,   1.66666663,   -5.4545455
  61465,    26.363636,   1.66666663,   -5.4545455
  61466,    27.272728,   1.66666663,   -5.4545455
  61467,    28.181818,   1.66666663,   -5.4545455
  61468,     29.09091,   1.66666663,   -5.4545455
  61469,     20.90909,  0.833333313,   -5.4545455
  61470,    21.818182,  0.833333313,   -5.4545455
  61471,    22.727272,  0.833333313,   -5.4545455
  61472,    23.636364,  0.833333313,   -5.4545455
  61473,    24.545454,  0.833333313,   -5.4545455
  61474,    25.454546,  0.833333313,   -5.4545455
  61475,    26.363636,  0.833333313,   -5.4545455
  61476,    27.272728,  0.833333313,   -5.4545455
  61477,    28.181818,  0.833333313,   -5.4545455
  61478,     29.09091,  0.833333313,   -5.4545455
  61479,     20.90909,   9.16666698,   -4.5454545
  61480,    21.818182,   9.16666698,   -4.5454545
  61481,    22.727272,   9.16666698,   -4.5454545
  61482,    23.636364,   9.16666698,   -4.5454545
  61483,    24.545454,   9.16666698,   -4.5454545
  61484,    25.454546,   9.16666698,   -4.5454545
  61485,    26.363636,   9.16666698,   -4.5454545
  61486,    27.272728,   9.16666698,   -4.5454545
  61487,    28.181818,   9.16666698,   -4.5454545
  61488,     29.09091,   9.16666698,   -4.5454545
  61489,     20.90909,   8.33333302,   -4.5454545
  61490,    21.818182,   8.33333302,   -4.5454545
  61491,    22.727272,   8.33333302,   -4.5454545
  61492,    23.636364,   8.33333302,   -4.5454545
  61493,    24.545454,   8.33333302,   -4.5454545
  61494,    25.454546,   8.33333302,   -4.5454545
  61495,    26.363636,   8.33333302,   -4.5454545
  61496,    27.272728,   8.33333302,   -4.5454545
  61497,    28.181818,   8.33333302,   -4.5454545
  61498,     29.09091,   8.33333302,   -4.5454545
  61499,     20.90909,          7.5,   -4.5454545
  61500,    21.818182,          7.5,   -4.5454545
  61501,    22.727272,          7.5,   -4.5454545
  61502,    23.636364,          7.5,   -4.5454545
  61503,    24.545454,          7.5,   -4.5454545
  61504,    25.454546,          7.5,   -4.5454545
  61505,    26.363636,          7.5,   -4.5454545
  61506,    27.272728,          7.5,   -4.5454545
  61507,    28.181818,          7.5,   -4.5454545
  61508,     29.09091,          7.5,   -4.5454545
  61509,     20.90909,   6.66666651,   -4.5454545
  61510,    21.818182,   6.66666651,   -4.5454545
  61511,    22.727272,   6.66666651,   -4.5454545
  61512,    23.636364,   6.66666651,   -4.5454545
  61513,    24.545454,   6.66666651,   -4.5454545
  61514,    25.454546,   6.66666651,   -4.5454545
  61515,    26.363636,   6.66666651,   -4.5454545
  61516,    27.272728,   6.66666651,   -4.5454545
  61517,    28.181818,   6.66666651,   -4.5454545
  61518,     29.09091,   6.66666651,   -4.5454545
  61519,     20.90909,   5.83333349,   -4.5454545
  61520,    21.818182,   5.83333349,   -4.5454545
  61521,    22.727272,   5.83333349,   -4.5454545
  61522,    23.636364,   5.83333349,   -4.5454545
  61523,    24.545454,   5.83333349,   -4.5454545
  61524,    25.454546,   5.83333349,   -4.5454545
  61525,    26.363636,   5.83333349,   -4.5454545
  61526,    27.272728,   5.83333349,   -4.5454545
  61527,    28.181818,   5.83333349,   -4.5454545
  61528,     29.09091,   5.83333349,   -4.5454545
  61529,     20.90909,           5.,   -4.5454545
  61530,    21.818182,           5.,   -4.5454545
  61531,    22.727272,           5.,   -4.5454545
  61532,    23.636364,           5.,   -4.5454545
  61533,    24.545454,           5.,   -4.5454545
  61534,    25.454546,           5.,   -4.5454545
  61535,    26.363636,           5.,   -4.5454545
  61536,    27.272728,           5.,   -4.5454545
  61537,    28.181818,           5.,   -4.5454545
  61538,     29.09091,           5.,   -4.5454545
  61539,     20.90909,   4.16666651,   -4.5454545
  61540,    21.818182,   4.16666651,   -4.5454545
  61541,    22.727272,   4.16666651,   -4.5454545
  61542,    23.636364,   4.16666651,   -4.5454545
  61543,    24.545454,   4.16666651,   -4.5454545
  61544,    25.454546,   4.16666651,   -4.5454545
  61545,    26.363636,   4.16666651,   -4.5454545
  61546,    27.272728,   4.16666651,   -4.5454545
  61547,    28.181818,   4.16666651,   -4.5454545
  61548,     29.09091,   4.16666651,   -4.5454545
  61549,     20.90909,   3.33333325,   -4.5454545
  61550,    21.818182,   3.33333325,   -4.5454545
  61551,    22.727272,   3.33333325,   -4.5454545
  61552,    23.636364,   3.33333325,   -4.5454545
  61553,    24.545454,   3.33333325,   -4.5454545
  61554,    25.454546,   3.33333325,   -4.5454545
  61555,    26.363636,   3.33333325,   -4.5454545
  61556,    27.272728,   3.33333325,   -4.5454545
  61557,    28.181818,   3.33333325,   -4.5454545
  61558,     29.09091,   3.33333325,   -4.5454545
  61559,     20.90909,          2.5,   -4.5454545
  61560,    21.818182,          2.5,   -4.5454545
  61561,    22.727272,          2.5,   -4.5454545
  61562,    23.636364,          2.5,   -4.5454545
  61563,    24.545454,          2.5,   -4.5454545
  61564,    25.454546,          2.5,   -4.5454545
  61565,    26.363636,          2.5,   -4.5454545
  61566,    27.272728,          2.5,   -4.5454545
  61567,    28.181818,          2.5,   -4.5454545
  61568,     29.09091,          2.5,   -4.5454545
  61569,     20.90909,   1.66666663,   -4.5454545
  61570,    21.818182,   1.66666663,   -4.5454545
  61571,    22.727272,   1.66666663,   -4.5454545
  61572,    23.636364,   1.66666663,   -4.5454545
  61573,    24.545454,   1.66666663,   -4.5454545
  61574,    25.454546,   1.66666663,   -4.5454545
  61575,    26.363636,   1.66666663,   -4.5454545
  61576,    27.272728,   1.66666663,   -4.5454545
  61577,    28.181818,   1.66666663,   -4.5454545
  61578,     29.09091,   1.66666663,   -4.5454545
  61579,     20.90909,  0.833333313,   -4.5454545
  61580,    21.818182,  0.833333313,   -4.5454545
  61581,    22.727272,  0.833333313,   -4.5454545
  61582,    23.636364,  0.833333313,   -4.5454545
  61583,    24.545454,  0.833333313,   -4.5454545
  61584,    25.454546,  0.833333313,   -4.5454545
  61585,    26.363636,  0.833333313,   -4.5454545
  61586,    27.272728,  0.833333313,   -4.5454545
  61587,    28.181818,  0.833333313,   -4.5454545
  61588,     29.09091,  0.833333313,   -4.5454545
  61589,     20.90909,   9.16666698,  -3.63636374
  61590,    21.818182,   9.16666698,  -3.63636374
  61591,    22.727272,   9.16666698,  -3.63636374
  61592,    23.636364,   9.16666698,  -3.63636374
  61593,    24.545454,   9.16666698,  -3.63636374
  61594,    25.454546,   9.16666698,  -3.63636374
  61595,    26.363636,   9.16666698,  -3.63636374
  61596,    27.272728,   9.16666698,  -3.63636374
  61597,    28.181818,   9.16666698,  -3.63636374
  61598,     29.09091,   9.16666698,  -3.63636374
  61599,     20.90909,   8.33333302,  -3.63636374
  61600,    21.818182,   8.33333302,  -3.63636374
  61601,    22.727272,   8.33333302,  -3.63636374
  61602,    23.636364,   8.33333302,  -3.63636374
  61603,    24.545454,   8.33333302,  -3.63636374
  61604,    25.454546,   8.33333302,  -3.63636374
  61605,    26.363636,   8.33333302,  -3.63636374
  61606,    27.272728,   8.33333302,  -3.63636374
  61607,    28.181818,   8.33333302,  -3.63636374
  61608,     29.09091,   8.33333302,  -3.63636374
  61609,     20.90909,          7.5,  -3.63636374
  61610,    21.818182,          7.5,  -3.63636374
  61611,    22.727272,          7.5,  -3.63636374
  61612,    23.636364,          7.5,  -3.63636374
  61613,    24.545454,          7.5,  -3.63636374
  61614,    25.454546,          7.5,  -3.63636374
  61615,    26.363636,          7.5,  -3.63636374
  61616,    27.272728,          7.5,  -3.63636374
  61617,    28.181818,          7.5,  -3.63636374
  61618,     29.09091,          7.5,  -3.63636374
  61619,     20.90909,   6.66666651,  -3.63636374
  61620,    21.818182,   6.66666651,  -3.63636374
  61621,    22.727272,   6.66666651,  -3.63636374
  61622,    23.636364,   6.66666651,  -3.63636374
  61623,    24.545454,   6.66666651,  -3.63636374
  61624,    25.454546,   6.66666651,  -3.63636374
  61625,    26.363636,   6.66666651,  -3.63636374
  61626,    27.272728,   6.66666651,  -3.63636374
  61627,    28.181818,   6.66666651,  -3.63636374
  61628,     29.09091,   6.66666651,  -3.63636374
  61629,     20.90909,   5.83333349,  -3.63636374
  61630,    21.818182,   5.83333349,  -3.63636374
  61631,    22.727272,   5.83333349,  -3.63636374
  61632,    23.636364,   5.83333349,  -3.63636374
  61633,    24.545454,   5.83333349,  -3.63636374
  61634,    25.454546,   5.83333349,  -3.63636374
  61635,    26.363636,   5.83333349,  -3.63636374
  61636,    27.272728,   5.83333349,  -3.63636374
  61637,    28.181818,   5.83333349,  -3.63636374
  61638,     29.09091,   5.83333349,  -3.63636374
  61639,     20.90909,           5.,  -3.63636374
  61640,    21.818182,           5.,  -3.63636374
  61641,    22.727272,           5.,  -3.63636374
  61642,    23.636364,           5.,  -3.63636374
  61643,    24.545454,           5.,  -3.63636374
  61644,    25.454546,           5.,  -3.63636374
  61645,    26.363636,           5.,  -3.63636374
  61646,    27.272728,           5.,  -3.63636374
  61647,    28.181818,           5.,  -3.63636374
  61648,     29.09091,           5.,  -3.63636374
  61649,     20.90909,   4.16666651,  -3.63636374
  61650,    21.818182,   4.16666651,  -3.63636374
  61651,    22.727272,   4.16666651,  -3.63636374
  61652,    23.636364,   4.16666651,  -3.63636374
  61653,    24.545454,   4.16666651,  -3.63636374
  61654,    25.454546,   4.16666651,  -3.63636374
  61655,    26.363636,   4.16666651,  -3.63636374
  61656,    27.272728,   4.16666651,  -3.63636374
  61657,    28.181818,   4.16666651,  -3.63636374
  61658,     29.09091,   4.16666651,  -3.63636374
  61659,     20.90909,   3.33333325,  -3.63636374
  61660,    21.818182,   3.33333325,  -3.63636374
  61661,    22.727272,   3.33333325,  -3.63636374
  61662,    23.636364,   3.33333325,  -3.63636374
  61663,    24.545454,   3.33333325,  -3.63636374
  61664,    25.454546,   3.33333325,  -3.63636374
  61665,    26.363636,   3.33333325,  -3.63636374
  61666,    27.272728,   3.33333325,  -3.63636374
  61667,    28.181818,   3.33333325,  -3.63636374
  61668,     29.09091,   3.33333325,  -3.63636374
  61669,     20.90909,          2.5,  -3.63636374
  61670,    21.818182,          2.5,  -3.63636374
  61671,    22.727272,          2.5,  -3.63636374
  61672,    23.636364,          2.5,  -3.63636374
  61673,    24.545454,          2.5,  -3.63636374
  61674,    25.454546,          2.5,  -3.63636374
  61675,    26.363636,          2.5,  -3.63636374
  61676,    27.272728,          2.5,  -3.63636374
  61677,    28.181818,          2.5,  -3.63636374
  61678,     29.09091,          2.5,  -3.63636374
  61679,     20.90909,   1.66666663,  -3.63636374
  61680,    21.818182,   1.66666663,  -3.63636374
  61681,    22.727272,   1.66666663,  -3.63636374
  61682,    23.636364,   1.66666663,  -3.63636374
  61683,    24.545454,   1.66666663,  -3.63636374
  61684,    25.454546,   1.66666663,  -3.63636374
  61685,    26.363636,   1.66666663,  -3.63636374
  61686,    27.272728,   1.66666663,  -3.63636374
  61687,    28.181818,   1.66666663,  -3.63636374
  61688,     29.09091,   1.66666663,  -3.63636374
  61689,     20.90909,  0.833333313,  -3.63636374
  61690,    21.818182,  0.833333313,  -3.63636374
  61691,    22.727272,  0.833333313,  -3.63636374
  61692,    23.636364,  0.833333313,  -3.63636374
  61693,    24.545454,  0.833333313,  -3.63636374
  61694,    25.454546,  0.833333313,  -3.63636374
  61695,    26.363636,  0.833333313,  -3.63636374
  61696,    27.272728,  0.833333313,  -3.63636374
  61697,    28.181818,  0.833333313,  -3.63636374
  61698,     29.09091,  0.833333313,  -3.63636374
  61699,     20.90909,   9.16666698,  -2.72727275
  61700,    21.818182,   9.16666698,  -2.72727275
  61701,    22.727272,   9.16666698,  -2.72727275
  61702,    23.636364,   9.16666698,  -2.72727275
  61703,    24.545454,   9.16666698,  -2.72727275
  61704,    25.454546,   9.16666698,  -2.72727275
  61705,    26.363636,   9.16666698,  -2.72727275
  61706,    27.272728,   9.16666698,  -2.72727275
  61707,    28.181818,   9.16666698,  -2.72727275
  61708,     29.09091,   9.16666698,  -2.72727275
  61709,     20.90909,   8.33333302,  -2.72727275
  61710,    21.818182,   8.33333302,  -2.72727275
  61711,    22.727272,   8.33333302,  -2.72727275
  61712,    23.636364,   8.33333302,  -2.72727275
  61713,    24.545454,   8.33333302,  -2.72727275
  61714,    25.454546,   8.33333302,  -2.72727275
  61715,    26.363636,   8.33333302,  -2.72727275
  61716,    27.272728,   8.33333302,  -2.72727275
  61717,    28.181818,   8.33333302,  -2.72727275
  61718,     29.09091,   8.33333302,  -2.72727275
  61719,     20.90909,          7.5,  -2.72727275
  61720,    21.818182,          7.5,  -2.72727275
  61721,    22.727272,          7.5,  -2.72727275
  61722,    23.636364,          7.5,  -2.72727275
  61723,    24.545454,          7.5,  -2.72727275
  61724,    25.454546,          7.5,  -2.72727275
  61725,    26.363636,          7.5,  -2.72727275
  61726,    27.272728,          7.5,  -2.72727275
  61727,    28.181818,          7.5,  -2.72727275
  61728,     29.09091,          7.5,  -2.72727275
  61729,     20.90909,   6.66666651,  -2.72727275
  61730,    21.818182,   6.66666651,  -2.72727275
  61731,    22.727272,   6.66666651,  -2.72727275
  61732,    23.636364,   6.66666651,  -2.72727275
  61733,    24.545454,   6.66666651,  -2.72727275
  61734,    25.454546,   6.66666651,  -2.72727275
  61735,    26.363636,   6.66666651,  -2.72727275
  61736,    27.272728,   6.66666651,  -2.72727275
  61737,    28.181818,   6.66666651,  -2.72727275
  61738,     29.09091,   6.66666651,  -2.72727275
  61739,     20.90909,   5.83333349,  -2.72727275
  61740,    21.818182,   5.83333349,  -2.72727275
  61741,    22.727272,   5.83333349,  -2.72727275
  61742,    23.636364,   5.83333349,  -2.72727275
  61743,    24.545454,   5.83333349,  -2.72727275
  61744,    25.454546,   5.83333349,  -2.72727275
  61745,    26.363636,   5.83333349,  -2.72727275
  61746,    27.272728,   5.83333349,  -2.72727275
  61747,    28.181818,   5.83333349,  -2.72727275
  61748,     29.09091,   5.83333349,  -2.72727275
  61749,     20.90909,           5.,  -2.72727275
  61750,    21.818182,           5.,  -2.72727275
  61751,    22.727272,           5.,  -2.72727275
  61752,    23.636364,           5.,  -2.72727275
  61753,    24.545454,           5.,  -2.72727275
  61754,    25.454546,           5.,  -2.72727275
  61755,    26.363636,           5.,  -2.72727275
  61756,    27.272728,           5.,  -2.72727275
  61757,    28.181818,           5.,  -2.72727275
  61758,     29.09091,           5.,  -2.72727275
  61759,     20.90909,   4.16666651,  -2.72727275
  61760,    21.818182,   4.16666651,  -2.72727275
  61761,    22.727272,   4.16666651,  -2.72727275
  61762,    23.636364,   4.16666651,  -2.72727275
  61763,    24.545454,   4.16666651,  -2.72727275
  61764,    25.454546,   4.16666651,  -2.72727275
  61765,    26.363636,   4.16666651,  -2.72727275
  61766,    27.272728,   4.16666651,  -2.72727275
  61767,    28.181818,   4.16666651,  -2.72727275
  61768,     29.09091,   4.16666651,  -2.72727275
  61769,     20.90909,   3.33333325,  -2.72727275
  61770,    21.818182,   3.33333325,  -2.72727275
  61771,    22.727272,   3.33333325,  -2.72727275
  61772,    23.636364,   3.33333325,  -2.72727275
  61773,    24.545454,   3.33333325,  -2.72727275
  61774,    25.454546,   3.33333325,  -2.72727275
  61775,    26.363636,   3.33333325,  -2.72727275
  61776,    27.272728,   3.33333325,  -2.72727275
  61777,    28.181818,   3.33333325,  -2.72727275
  61778,     29.09091,   3.33333325,  -2.72727275
  61779,     20.90909,          2.5,  -2.72727275
  61780,    21.818182,          2.5,  -2.72727275
  61781,    22.727272,          2.5,  -2.72727275
  61782,    23.636364,          2.5,  -2.72727275
  61783,    24.545454,          2.5,  -2.72727275
  61784,    25.454546,          2.5,  -2.72727275
  61785,    26.363636,          2.5,  -2.72727275
  61786,    27.272728,          2.5,  -2.72727275
  61787,    28.181818,          2.5,  -2.72727275
  61788,     29.09091,          2.5,  -2.72727275
  61789,     20.90909,   1.66666663,  -2.72727275
  61790,    21.818182,   1.66666663,  -2.72727275
  61791,    22.727272,   1.66666663,  -2.72727275
  61792,    23.636364,   1.66666663,  -2.72727275
  61793,    24.545454,   1.66666663,  -2.72727275
  61794,    25.454546,   1.66666663,  -2.72727275
  61795,    26.363636,   1.66666663,  -2.72727275
  61796,    27.272728,   1.66666663,  -2.72727275
  61797,    28.181818,   1.66666663,  -2.72727275
  61798,     29.09091,   1.66666663,  -2.72727275
  61799,     20.90909,  0.833333313,  -2.72727275
  61800,    21.818182,  0.833333313,  -2.72727275
  61801,    22.727272,  0.833333313,  -2.72727275
  61802,    23.636364,  0.833333313,  -2.72727275
  61803,    24.545454,  0.833333313,  -2.72727275
  61804,    25.454546,  0.833333313,  -2.72727275
  61805,    26.363636,  0.833333313,  -2.72727275
  61806,    27.272728,  0.833333313,  -2.72727275
  61807,    28.181818,  0.833333313,  -2.72727275
  61808,     29.09091,  0.833333313,  -2.72727275
  61809,     20.90909,   9.16666698,  -1.81818187
  61810,    21.818182,   9.16666698,  -1.81818187
  61811,    22.727272,   9.16666698,  -1.81818187
  61812,    23.636364,   9.16666698,  -1.81818187
  61813,    24.545454,   9.16666698,  -1.81818187
  61814,    25.454546,   9.16666698,  -1.81818187
  61815,    26.363636,   9.16666698,  -1.81818187
  61816,    27.272728,   9.16666698,  -1.81818187
  61817,    28.181818,   9.16666698,  -1.81818187
  61818,     29.09091,   9.16666698,  -1.81818187
  61819,     20.90909,   8.33333302,  -1.81818187
  61820,    21.818182,   8.33333302,  -1.81818187
  61821,    22.727272,   8.33333302,  -1.81818187
  61822,    23.636364,   8.33333302,  -1.81818187
  61823,    24.545454,   8.33333302,  -1.81818187
  61824,    25.454546,   8.33333302,  -1.81818187
  61825,    26.363636,   8.33333302,  -1.81818187
  61826,    27.272728,   8.33333302,  -1.81818187
  61827,    28.181818,   8.33333302,  -1.81818187
  61828,     29.09091,   8.33333302,  -1.81818187
  61829,     20.90909,          7.5,  -1.81818187
  61830,    21.818182,          7.5,  -1.81818187
  61831,    22.727272,          7.5,  -1.81818187
  61832,    23.636364,          7.5,  -1.81818187
  61833,    24.545454,          7.5,  -1.81818187
  61834,    25.454546,          7.5,  -1.81818187
  61835,    26.363636,          7.5,  -1.81818187
  61836,    27.272728,          7.5,  -1.81818187
  61837,    28.181818,          7.5,  -1.81818187
  61838,     29.09091,          7.5,  -1.81818187
  61839,     20.90909,   6.66666651,  -1.81818187
  61840,    21.818182,   6.66666651,  -1.81818187
  61841,    22.727272,   6.66666651,  -1.81818187
  61842,    23.636364,   6.66666651,  -1.81818187
  61843,    24.545454,   6.66666651,  -1.81818187
  61844,    25.454546,   6.66666651,  -1.81818187
  61845,    26.363636,   6.66666651,  -1.81818187
  61846,    27.272728,   6.66666651,  -1.81818187
  61847,    28.181818,   6.66666651,  -1.81818187
  61848,     29.09091,   6.66666651,  -1.81818187
  61849,     20.90909,   5.83333349,  -1.81818187
  61850,    21.818182,   5.83333349,  -1.81818187
  61851,    22.727272,   5.83333349,  -1.81818187
  61852,    23.636364,   5.83333349,  -1.81818187
  61853,    24.545454,   5.83333349,  -1.81818187
  61854,    25.454546,   5.83333349,  -1.81818187
  61855,    26.363636,   5.83333349,  -1.81818187
  61856,    27.272728,   5.83333349,  -1.81818187
  61857,    28.181818,   5.83333349,  -1.81818187
  61858,     29.09091,   5.83333349,  -1.81818187
  61859,     20.90909,           5.,  -1.81818187
  61860,    21.818182,           5.,  -1.81818187
  61861,    22.727272,           5.,  -1.81818187
  61862,    23.636364,           5.,  -1.81818187
  61863,    24.545454,           5.,  -1.81818187
  61864,    25.454546,           5.,  -1.81818187
  61865,    26.363636,           5.,  -1.81818187
  61866,    27.272728,           5.,  -1.81818187
  61867,    28.181818,           5.,  -1.81818187
  61868,     29.09091,           5.,  -1.81818187
  61869,     20.90909,   4.16666651,  -1.81818187
  61870,    21.818182,   4.16666651,  -1.81818187
  61871,    22.727272,   4.16666651,  -1.81818187
  61872,    23.636364,   4.16666651,  -1.81818187
  61873,    24.545454,   4.16666651,  -1.81818187
  61874,    25.454546,   4.16666651,  -1.81818187
  61875,    26.363636,   4.16666651,  -1.81818187
  61876,    27.272728,   4.16666651,  -1.81818187
  61877,    28.181818,   4.16666651,  -1.81818187
  61878,     29.09091,   4.16666651,  -1.81818187
  61879,     20.90909,   3.33333325,  -1.81818187
  61880,    21.818182,   3.33333325,  -1.81818187
  61881,    22.727272,   3.33333325,  -1.81818187
  61882,    23.636364,   3.33333325,  -1.81818187
  61883,    24.545454,   3.33333325,  -1.81818187
  61884,    25.454546,   3.33333325,  -1.81818187
  61885,    26.363636,   3.33333325,  -1.81818187
  61886,    27.272728,   3.33333325,  -1.81818187
  61887,    28.181818,   3.33333325,  -1.81818187
  61888,     29.09091,   3.33333325,  -1.81818187
  61889,     20.90909,          2.5,  -1.81818187
  61890,    21.818182,          2.5,  -1.81818187
  61891,    22.727272,          2.5,  -1.81818187
  61892,    23.636364,          2.5,  -1.81818187
  61893,    24.545454,          2.5,  -1.81818187
  61894,    25.454546,          2.5,  -1.81818187
  61895,    26.363636,          2.5,  -1.81818187
  61896,    27.272728,          2.5,  -1.81818187
  61897,    28.181818,          2.5,  -1.81818187
  61898,     29.09091,          2.5,  -1.81818187
  61899,     20.90909,   1.66666663,  -1.81818187
  61900,    21.818182,   1.66666663,  -1.81818187
  61901,    22.727272,   1.66666663,  -1.81818187
  61902,    23.636364,   1.66666663,  -1.81818187
  61903,    24.545454,   1.66666663,  -1.81818187
  61904,    25.454546,   1.66666663,  -1.81818187
  61905,    26.363636,   1.66666663,  -1.81818187
  61906,    27.272728,   1.66666663,  -1.81818187
  61907,    28.181818,   1.66666663,  -1.81818187
  61908,     29.09091,   1.66666663,  -1.81818187
  61909,     20.90909,  0.833333313,  -1.81818187
  61910,    21.818182,  0.833333313,  -1.81818187
  61911,    22.727272,  0.833333313,  -1.81818187
  61912,    23.636364,  0.833333313,  -1.81818187
  61913,    24.545454,  0.833333313,  -1.81818187
  61914,    25.454546,  0.833333313,  -1.81818187
  61915,    26.363636,  0.833333313,  -1.81818187
  61916,    27.272728,  0.833333313,  -1.81818187
  61917,    28.181818,  0.833333313,  -1.81818187
  61918,     29.09091,  0.833333313,  -1.81818187
  61919,     20.90909,   9.16666698, -0.909090936
  61920,    21.818182,   9.16666698, -0.909090936
  61921,    22.727272,   9.16666698, -0.909090936
  61922,    23.636364,   9.16666698, -0.909090936
  61923,    24.545454,   9.16666698, -0.909090936
  61924,    25.454546,   9.16666698, -0.909090936
  61925,    26.363636,   9.16666698, -0.909090936
  61926,    27.272728,   9.16666698, -0.909090936
  61927,    28.181818,   9.16666698, -0.909090936
  61928,     29.09091,   9.16666698, -0.909090936
  61929,     20.90909,   8.33333302, -0.909090936
  61930,    21.818182,   8.33333302, -0.909090936
  61931,    22.727272,   8.33333302, -0.909090936
  61932,    23.636364,   8.33333302, -0.909090936
  61933,    24.545454,   8.33333302, -0.909090936
  61934,    25.454546,   8.33333302, -0.909090936
  61935,    26.363636,   8.33333302, -0.909090936
  61936,    27.272728,   8.33333302, -0.909090936
  61937,    28.181818,   8.33333302, -0.909090936
  61938,     29.09091,   8.33333302, -0.909090936
  61939,     20.90909,          7.5, -0.909090936
  61940,    21.818182,          7.5, -0.909090936
  61941,    22.727272,          7.5, -0.909090936
  61942,    23.636364,          7.5, -0.909090936
  61943,    24.545454,          7.5, -0.909090936
  61944,    25.454546,          7.5, -0.909090936
  61945,    26.363636,          7.5, -0.909090936
  61946,    27.272728,          7.5, -0.909090936
  61947,    28.181818,          7.5, -0.909090936
  61948,     29.09091,          7.5, -0.909090936
  61949,     20.90909,   6.66666651, -0.909090936
  61950,    21.818182,   6.66666651, -0.909090936
  61951,    22.727272,   6.66666651, -0.909090936
  61952,    23.636364,   6.66666651, -0.909090936
  61953,    24.545454,   6.66666651, -0.909090936
  61954,    25.454546,   6.66666651, -0.909090936
  61955,    26.363636,   6.66666651, -0.909090936
  61956,    27.272728,   6.66666651, -0.909090936
  61957,    28.181818,   6.66666651, -0.909090936
  61958,     29.09091,   6.66666651, -0.909090936
  61959,     20.90909,   5.83333349, -0.909090936
  61960,    21.818182,   5.83333349, -0.909090936
  61961,    22.727272,   5.83333349, -0.909090936
  61962,    23.636364,   5.83333349, -0.909090936
  61963,    24.545454,   5.83333349, -0.909090936
  61964,    25.454546,   5.83333349, -0.909090936
  61965,    26.363636,   5.83333349, -0.909090936
  61966,    27.272728,   5.83333349, -0.909090936
  61967,    28.181818,   5.83333349, -0.909090936
  61968,     29.09091,   5.83333349, -0.909090936
  61969,     20.90909,           5., -0.909090936
  61970,    21.818182,           5., -0.909090936
  61971,    22.727272,           5., -0.909090936
  61972,    23.636364,           5., -0.909090936
  61973,    24.545454,           5., -0.909090936
  61974,    25.454546,           5., -0.909090936
  61975,    26.363636,           5., -0.909090936
  61976,    27.272728,           5., -0.909090936
  61977,    28.181818,           5., -0.909090936
  61978,     29.09091,           5., -0.909090936
  61979,     20.90909,   4.16666651, -0.909090936
  61980,    21.818182,   4.16666651, -0.909090936
  61981,    22.727272,   4.16666651, -0.909090936
  61982,    23.636364,   4.16666651, -0.909090936
  61983,    24.545454,   4.16666651, -0.909090936
  61984,    25.454546,   4.16666651, -0.909090936
  61985,    26.363636,   4.16666651, -0.909090936
  61986,    27.272728,   4.16666651, -0.909090936
  61987,    28.181818,   4.16666651, -0.909090936
  61988,     29.09091,   4.16666651, -0.909090936
  61989,     20.90909,   3.33333325, -0.909090936
  61990,    21.818182,   3.33333325, -0.909090936
  61991,    22.727272,   3.33333325, -0.909090936
  61992,    23.636364,   3.33333325, -0.909090936
  61993,    24.545454,   3.33333325, -0.909090936
  61994,    25.454546,   3.33333325, -0.909090936
