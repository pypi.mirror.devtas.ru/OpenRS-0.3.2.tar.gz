  19995,   26.7603302,   33.0382767, -0.909090936
  19996,   27.5702477,   33.0382767, -0.909090936
  19997,   28.3801651,   33.0382767, -0.909090936
  19998,   29.1900826,   33.0382767, -0.909090936
  19999,   20.9917355,   33.8373222, -0.909090936
  20000,   21.9834709,   33.8373222, -0.909090936
  20001,   22.9752064,   33.8373222, -0.909090936
  20002,   23.9669418,   33.8373222, -0.909090936
  20003,   24.9586773,   33.8373222, -0.909090936
  20004,   25.9504128,   33.8373222, -0.909090936
  20005,   26.7603302,   33.8373222, -0.909090936
  20006,   27.5702477,   33.8373222, -0.909090936
  20007,   28.3801651,   33.8373222, -0.909090936
  20008,   29.1900826,   33.8373222, -0.909090936
  20009,   20.9917355,    34.636364, -0.909090936
  20010,   21.9834709,    34.636364, -0.909090936
  20011,   22.9752064,    34.636364, -0.909090936
  20012,   23.9669418,    34.636364, -0.909090936
  20013,   24.9586773,    34.636364, -0.909090936
  20014,   25.9504128,    34.636364, -0.909090936
  20015,   26.7603302,    34.636364, -0.909090936
  20016,   27.5702477,    34.636364, -0.909090936
  20017,   28.3801651,    34.636364, -0.909090936
  20018,   29.1900826,    34.636364, -0.909090936
  20019,   20.9917355,   35.4354057, -0.909090936
  20020,   21.9834709,   35.4354057, -0.909090936
  20021,   22.9752064,   35.4354057, -0.909090936
  20022,   23.9669418,   35.4354057, -0.909090936
  20023,   24.9586773,   35.4354057, -0.909090936
  20024,   25.9504128,   35.4354057, -0.909090936
  20025,   26.7603302,   35.4354057, -0.909090936
  20026,   27.5702477,   35.4354057, -0.909090936
  20027,   28.3801651,   35.4354057, -0.909090936
  20028,   29.1900826,   35.4354057, -0.909090936
  20029,   20.9917355,   36.2344513, -0.909090936
  20030,   21.9834709,   36.2344513, -0.909090936
  20031,   22.9752064,   36.2344513, -0.909090936
  20032,   23.9669418,   36.2344513, -0.909090936
  20033,   24.9586773,   36.2344513, -0.909090936
  20034,   25.9504128,   36.2344513, -0.909090936
  20035,   26.7603302,   36.2344513, -0.909090936
  20036,   27.5702477,   36.2344513, -0.909090936
  20037,   28.3801651,   36.2344513, -0.909090936
  20038,   29.1900826,   36.2344513, -0.909090936
  20039,   20.9917355,    37.033493, -0.909090936
  20040,   21.9834709,    37.033493, -0.909090936
  20041,   22.9752064,    37.033493, -0.909090936
  20042,   23.9669418,    37.033493, -0.909090936
  20043,   24.9586773,    37.033493, -0.909090936
  20044,   25.9504128,    37.033493, -0.909090936
  20045,   26.7603302,    37.033493, -0.909090936
  20046,   27.5702477,    37.033493, -0.909090936
  20047,   28.3801651,    37.033493, -0.909090936
  20048,   29.1900826,    37.033493, -0.909090936
  20049,   20.9917355,   37.8325348, -0.909090936
  20050,   21.9834709,   37.8325348, -0.909090936
  20051,   22.9752064,   37.8325348, -0.909090936
  20052,   23.9669418,   37.8325348, -0.909090936
  20053,   24.9586773,   37.8325348, -0.909090936
  20054,   25.9504128,   37.8325348, -0.909090936
  20055,   26.7603302,   37.8325348, -0.909090936
  20056,   27.5702477,   37.8325348, -0.909090936
  20057,   28.3801651,   37.8325348, -0.909090936
  20058,   29.1900826,   37.8325348, -0.909090936
  20059,   20.9917355,   38.6315804, -0.909090936
  20060,   21.9834709,   38.6315804, -0.909090936
  20061,   22.9752064,   38.6315804, -0.909090936
  20062,   23.9669418,   38.6315804, -0.909090936
  20063,   24.9586773,   38.6315804, -0.909090936
  20064,   25.9504128,   38.6315804, -0.909090936
  20065,   26.7603302,   38.6315804, -0.909090936
  20066,   27.5702477,   38.6315804, -0.909090936
  20067,   28.3801651,   38.6315804, -0.909090936
  20068,   29.1900826,   38.6315804, -0.909090936
  20069,   20.9917355,   39.4306221, -0.909090936
  20070,   21.9834709,   39.4306221, -0.909090936
  20071,   22.9752064,   39.4306221, -0.909090936
  20072,   23.9669418,   39.4306221, -0.909090936
  20073,   24.9586773,   39.4306221, -0.909090936
  20074,   25.9504128,   39.4306221, -0.909090936
  20075,   26.7603302,   39.4306221, -0.909090936
  20076,   27.5702477,   39.4306221, -0.909090936
  20077,   28.3801651,   39.4306221, -0.909090936
  20078,   29.1900826,   39.4306221, -0.909090936
  20079,   20.9917355,   40.2296638, -0.909090936
  20080,   21.9834709,   40.2296638, -0.909090936
  20081,   22.9752064,   40.2296638, -0.909090936
  20082,   23.9669418,   40.2296638, -0.909090936
  20083,   24.9586773,   40.2296638, -0.909090936
  20084,   25.9504128,   40.2296638, -0.909090936
  20085,   26.7603302,   40.2296638, -0.909090936
  20086,   27.5702477,   40.2296638, -0.909090936
  20087,   28.3801651,   40.2296638, -0.909090936
  20088,   29.1900826,   40.2296638, -0.909090936
  20089,   20.9917355,   41.0287094, -0.909090936
  20090,   21.9834709,   41.0287094, -0.909090936
  20091,   22.9752064,   41.0287094, -0.909090936
  20092,   23.9669418,   41.0287094, -0.909090936
  20093,   24.9586773,   41.0287094, -0.909090936
  20094,   25.9504128,   41.0287094, -0.909090936
  20095,   26.7603302,   41.0287094, -0.909090936
  20096,   27.5702477,   41.0287094, -0.909090936
  20097,   28.3801651,   41.0287094, -0.909090936
  20098,   29.1900826,   41.0287094, -0.909090936
  20099,   20.9917355,   41.8277512, -0.909090936
  20100,   21.9834709,   41.8277512, -0.909090936
  20101,   22.9752064,   41.8277512, -0.909090936
  20102,   23.9669418,   41.8277512, -0.909090936
  20103,   24.9586773,   41.8277512, -0.909090936
  20104,   25.9504128,   41.8277512, -0.909090936
  20105,   26.7603302,   41.8277512, -0.909090936
  20106,   27.5702477,   41.8277512, -0.909090936
  20107,   28.3801651,   41.8277512, -0.909090936
  20108,   29.1900826,   41.8277512, -0.909090936
  20109,   20.9917355,   42.6267929, -0.909090936
  20110,   21.9834709,   42.6267929, -0.909090936
  20111,   22.9752064,   42.6267929, -0.909090936
  20112,   23.9669418,   42.6267929, -0.909090936
  20113,   24.9586773,   42.6267929, -0.909090936
  20114,   25.9504128,   42.6267929, -0.909090936
  20115,   26.7603302,   42.6267929, -0.909090936
  20116,   27.5702477,   42.6267929, -0.909090936
  20117,   28.3801651,   42.6267929, -0.909090936
  20118,   29.1900826,   42.6267929, -0.909090936
  20119,   20.9917355,   43.4258385, -0.909090936
  20120,   21.9834709,   43.4258385, -0.909090936
  20121,   22.9752064,   43.4258385, -0.909090936
  20122,   23.9669418,   43.4258385, -0.909090936
  20123,   24.9586773,   43.4258385, -0.909090936
  20124,   25.9504128,   43.4258385, -0.909090936
  20125,   26.7603302,   43.4258385, -0.909090936
  20126,   27.5702477,   43.4258385, -0.909090936
  20127,   28.3801651,   43.4258385, -0.909090936
  20128,   29.1900826,   43.4258385, -0.909090936
  20129,   20.9917355,   44.2248802, -0.909090936
  20130,   21.9834709,   44.2248802, -0.909090936
  20131,   22.9752064,   44.2248802, -0.909090936
  20132,   23.9669418,   44.2248802, -0.909090936
  20133,   24.9586773,   44.2248802, -0.909090936
  20134,   25.9504128,   44.2248802, -0.909090936
  20135,   26.7603302,   44.2248802, -0.909090936
  20136,   27.5702477,   44.2248802, -0.909090936
  20137,   28.3801651,   44.2248802, -0.909090936
  20138,   29.1900826,   44.2248802, -0.909090936
  20139,   20.9917355,    45.023922, -0.909090936
  20140,   21.9834709,    45.023922, -0.909090936
  20141,   22.9752064,    45.023922, -0.909090936
  20142,   23.9669418,    45.023922, -0.909090936
  20143,   24.9586773,    45.023922, -0.909090936
  20144,   25.9504128,    45.023922, -0.909090936
  20145,   26.7603302,    45.023922, -0.909090936
  20146,   27.5702477,    45.023922, -0.909090936
  20147,   28.3801651,    45.023922, -0.909090936
  20148,   29.1900826,    45.023922, -0.909090936
  20149,   20.9779606,   45.8532677, -0.909090936
  20150,   21.9559212,   45.8532677, -0.909090936
  20151,   22.9338856,   45.8532677, -0.909090936
  20152,   23.9118462,   45.8532677, -0.909090936
  20153,   24.8898067,   45.8532677, -0.909090936
  20154,   25.8677673,   45.8532677, -0.909090936
  20155,   26.6942139,   45.8532677, -0.909090936
  20156,   27.5206604,   45.8532677, -0.909090936
  20157,   28.3471069,   45.8532677, -0.909090936
  20158,   29.1735535,   45.8532677, -0.909090936
  20159,   20.9641857,   46.6826172, -0.909090936
  20160,   21.9283752,   46.6826172, -0.909090936
  20161,    22.892561,   46.6826172, -0.909090936
  20162,   23.8567486,   46.6826172, -0.909090936
  20163,   24.8209362,   46.6826172, -0.909090936
  20164,   25.7851238,   46.6826172, -0.909090936
  20165,   26.6280994,   46.6826172, -0.909090936
  20166,   27.4710751,   46.6826172, -0.909090936
  20167,   28.3140488,   46.6826172, -0.909090936
  20168,   29.1570263,   46.6826172, -0.909090936
  20169,   20.9504128,   47.5119629, -0.909090936
  20170,   21.9008255,   47.5119629, -0.909090936
  20171,   22.8512402,   47.5119629, -0.909090936
  20172,   23.8016529,   47.5119629, -0.909090936
  20173,   24.7520676,   47.5119629, -0.909090936
  20174,   25.7024784,   47.5119629, -0.909090936
  20175,   26.5619831,   47.5119629, -0.909090936
  20176,   27.4214878,   47.5119629, -0.909090936
  20177,   28.2809906,   47.5119629, -0.909090936
  20178,   29.1404953,   47.5119629, -0.909090936
  20179,   20.9366398,   48.3413086, -0.909090936
  20180,   21.8732777,   48.3413086, -0.909090936
  20181,   22.8099174,   48.3413086, -0.909090936
  20182,   23.7465572,   48.3413086, -0.909090936
  20183,   24.6831951,   48.3413086, -0.909090936
  20184,   25.6198349,   48.3413086, -0.909090936
  20185,   26.4958668,   48.3413086, -0.909090936
  20186,   27.3719006,   48.3413086, -0.909090936
  20187,   28.2479343,   48.3413086, -0.909090936
  20188,   29.1239681,   48.3413086, -0.909090936
  20189,   20.9228649,   49.1706543, -0.909090936
  20190,   21.8457298,   49.1706543, -0.909090936
  20191,   22.7685947,   49.1706543, -0.909090936
  20192,   23.6914597,   49.1706543, -0.909090936
  20193,   24.6143246,   49.1706543, -0.909090936
  20194,   25.5371895,   49.1706543, -0.909090936
  20195,   26.4297523,   49.1706543, -0.909090936
  20196,   27.3223133,   49.1706543, -0.909090936
  20197,   28.2148762,   49.1706543, -0.909090936
  20198,   29.1074371,   49.1706543, -0.909090936
  20199,   20.9197159,   20.7279568,  -1.81818187
  20200,   21.8394337,   20.7279568,  -1.81818187
  20201,   22.7591496,   20.7279568,  -1.81818187
  20202,   23.6788673,   20.7279568,  -1.81818187
  20203,   24.5985832,   20.7279568,  -1.81818187
  20204,   25.5182991,   20.7279568,  -1.81818187
  20205,   26.4146404,   20.7279568,  -1.81818187
  20206,   27.3109798,   20.7279568,  -1.81818187
  20207,   28.2073212,   20.7279568,  -1.81818187
  20208,   29.1036606,   20.7279568,  -1.81818187
  20209,   20.9303417,   21.4559116,  -1.81818187
  20210,   21.8606853,   21.4559116,  -1.81818187
  20211,   22.7910271,   21.4559116,  -1.81818187
  20212,   23.7213688,   21.4559116,  -1.81818187
  20213,   24.6517124,   21.4559116,  -1.81818187
  20214,   25.5820541,   21.4559116,  -1.81818187
  20215,   26.4656429,   21.4559116,  -1.81818187
  20216,   27.3492336,   21.4559116,  -1.81818187
  20217,   28.2328224,   21.4559116,  -1.81818187
  20218,   29.1164112,   21.4559116,  -1.81818187
  20219,   20.9409676,   22.1838684,  -1.81818187
  20220,    21.881937,   22.1838684,  -1.81818187
  20221,   22.8229046,   22.1838684,  -1.81818187
  20222,   23.7638721,   22.1838684,  -1.81818187
  20223,   24.7048397,   22.1838684,  -1.81818187
  20224,   25.6458092,   22.1838684,  -1.81818187
  20225,   26.5166473,   22.1838684,  -1.81818187
  20226,   27.3874855,   22.1838684,  -1.81818187
  20227,   28.2583237,   22.1838684,  -1.81818187
  20228,   29.1291618,   22.1838684,  -1.81818187
  20229,   20.9515934,   22.9118252,  -1.81818187
  20230,   21.9031868,   22.9118252,  -1.81818187
  20231,   22.8547821,   22.9118252,  -1.81818187
  20232,   23.8063755,   22.9118252,  -1.81818187
  20233,   24.7579689,   22.9118252,  -1.81818187
  20234,   25.7095623,   22.9118252,  -1.81818187
  20235,   26.5676517,   22.9118252,  -1.81818187
  20236,   27.4257374,   22.9118252,  -1.81818187
  20237,   28.2838249,   22.9118252,  -1.81818187
  20238,   29.1419125,   22.9118252,  -1.81818187
  20239,   20.9622192,    23.639782,  -1.81818187
  20240,   21.9244385,    23.639782,  -1.81818187
  20241,   22.8866577,    23.639782,  -1.81818187
  20242,   23.8488789,    23.639782,  -1.81818187
  20243,   24.8110981,    23.639782,  -1.81818187
  20244,   25.7733173,    23.639782,  -1.81818187
  20245,   26.6186543,    23.639782,  -1.81818187
  20246,   27.4639893,    23.639782,  -1.81818187
  20247,   28.3093262,    23.639782,  -1.81818187
  20248,   29.1546631,    23.639782,  -1.81818187
  20249,   20.9728451,   24.3677368,  -1.81818187
  20250,   21.9456902,   24.3677368,  -1.81818187
  20251,   22.9185352,   24.3677368,  -1.81818187
  20252,   23.8913803,   24.3677368,  -1.81818187
  20253,   24.8642254,   24.3677368,  -1.81818187
  20254,   25.8370724,   24.3677368,  -1.81818187
  20255,   26.6696587,   24.3677368,  -1.81818187
  20256,    27.502243,   24.3677368,  -1.81818187
  20257,   28.3348293,   24.3677368,  -1.81818187
  20258,   29.1674156,   24.3677368,  -1.81818187
  20259,   20.9834709,   25.0956936,  -1.81818187
  20260,   21.9669418,   25.0956936,  -1.81818187
  20261,   22.9504128,   25.0956936,  -1.81818187
  20262,   23.9338837,   25.0956936,  -1.81818187
  20263,   24.9173546,   25.0956936,  -1.81818187
  20264,   25.9008274,   25.0956936,  -1.81818187
  20265,   26.7206612,   25.0956936,  -1.81818187
  20266,   27.5404968,   25.0956936,  -1.81818187
  20267,   28.3603306,   25.0956936,  -1.81818187
  20268,   29.1801662,   25.0956936,  -1.81818187
  20269,   20.9834709,   25.8937798,  -1.81818187
  20270,   21.9669418,   25.8937798,  -1.81818187
  20271,   22.9504128,   25.8937798,  -1.81818187
  20272,   23.9338837,   25.8937798,  -1.81818187
  20273,   24.9173546,   25.8937798,  -1.81818187
  20274,   25.9008274,   25.8937798,  -1.81818187
  20275,   26.7206612,   25.8937798,  -1.81818187
  20276,   27.5404968,   25.8937798,  -1.81818187
  20277,   28.3603306,   25.8937798,  -1.81818187
  20278,   29.1801662,   25.8937798,  -1.81818187
  20279,   20.9834709,   26.6918659,  -1.81818187
  20280,   21.9669418,   26.6918659,  -1.81818187
  20281,   22.9504128,   26.6918659,  -1.81818187
  20282,   23.9338837,   26.6918659,  -1.81818187
  20283,   24.9173546,   26.6918659,  -1.81818187
  20284,   25.9008274,   26.6918659,  -1.81818187
  20285,   26.7206612,   26.6918659,  -1.81818187
  20286,   27.5404968,   26.6918659,  -1.81818187
  20287,   28.3603306,   26.6918659,  -1.81818187
  20288,   29.1801662,   26.6918659,  -1.81818187
  20289,   20.9834709,   27.4899521,  -1.81818187
  20290,   21.9669418,   27.4899521,  -1.81818187
  20291,   22.9504128,   27.4899521,  -1.81818187
  20292,   23.9338837,   27.4899521,  -1.81818187
  20293,   24.9173546,   27.4899521,  -1.81818187
  20294,   25.9008274,   27.4899521,  -1.81818187
  20295,   26.7206612,   27.4899521,  -1.81818187
  20296,   27.5404968,   27.4899521,  -1.81818187
  20297,   28.3603306,   27.4899521,  -1.81818187
  20298,   29.1801662,   27.4899521,  -1.81818187
  20299,   20.9834709,   28.2880383,  -1.81818187
  20300,   21.9669418,   28.2880383,  -1.81818187
  20301,   22.9504128,   28.2880383,  -1.81818187
  20302,   23.9338837,   28.2880383,  -1.81818187
  20303,   24.9173546,   28.2880383,  -1.81818187
  20304,   25.9008274,   28.2880383,  -1.81818187
  20305,   26.7206612,   28.2880383,  -1.81818187
  20306,   27.5404968,   28.2880383,  -1.81818187
  20307,   28.3603306,   28.2880383,  -1.81818187
  20308,   29.1801662,   28.2880383,  -1.81818187
  20309,   20.9834709,   29.0861244,  -1.81818187
  20310,   21.9669418,   29.0861244,  -1.81818187
  20311,   22.9504128,   29.0861244,  -1.81818187
  20312,   23.9338837,   29.0861244,  -1.81818187
  20313,   24.9173546,   29.0861244,  -1.81818187
  20314,   25.9008274,   29.0861244,  -1.81818187
  20315,   26.7206612,   29.0861244,  -1.81818187
  20316,   27.5404968,   29.0861244,  -1.81818187
  20317,   28.3603306,   29.0861244,  -1.81818187
  20318,   29.1801662,   29.0861244,  -1.81818187
  20319,   20.9834709,   29.8842106,  -1.81818187
  20320,   21.9669418,   29.8842106,  -1.81818187
  20321,   22.9504128,   29.8842106,  -1.81818187
  20322,   23.9338837,   29.8842106,  -1.81818187
  20323,   24.9173546,   29.8842106,  -1.81818187
  20324,   25.9008274,   29.8842106,  -1.81818187
  20325,   26.7206612,   29.8842106,  -1.81818187
  20326,   27.5404968,   29.8842106,  -1.81818187
  20327,   28.3603306,   29.8842106,  -1.81818187
  20328,   29.1801662,   29.8842106,  -1.81818187
  20329,   20.9834709,   30.6822968,  -1.81818187
  20330,   21.9669418,   30.6822968,  -1.81818187
  20331,   22.9504128,   30.6822968,  -1.81818187
  20332,   23.9338837,   30.6822968,  -1.81818187
  20333,   24.9173546,   30.6822968,  -1.81818187
  20334,   25.9008274,   30.6822968,  -1.81818187
  20335,   26.7206612,   30.6822968,  -1.81818187
  20336,   27.5404968,   30.6822968,  -1.81818187
  20337,   28.3603306,   30.6822968,  -1.81818187
  20338,   29.1801662,   30.6822968,  -1.81818187
  20339,   20.9834709,   31.4803829,  -1.81818187
  20340,   21.9669418,   31.4803829,  -1.81818187
  20341,   22.9504128,   31.4803829,  -1.81818187
  20342,   23.9338837,   31.4803829,  -1.81818187
  20343,   24.9173546,   31.4803829,  -1.81818187
  20344,   25.9008274,   31.4803829,  -1.81818187
  20345,   26.7206612,   31.4803829,  -1.81818187
  20346,   27.5404968,   31.4803829,  -1.81818187
  20347,   28.3603306,   31.4803829,  -1.81818187
  20348,   29.1801662,   31.4803829,  -1.81818187
  20349,   20.9834709,   32.2784691,  -1.81818187
  20350,   21.9669418,   32.2784691,  -1.81818187
  20351,   22.9504128,   32.2784691,  -1.81818187
  20352,   23.9338837,   32.2784691,  -1.81818187
  20353,   24.9173546,   32.2784691,  -1.81818187
  20354,   25.9008274,   32.2784691,  -1.81818187
  20355,   26.7206612,   32.2784691,  -1.81818187
  20356,   27.5404968,   32.2784691,  -1.81818187
  20357,   28.3603306,   32.2784691,  -1.81818187
  20358,   29.1801662,   32.2784691,  -1.81818187
  20359,   20.9834709,   33.0765533,  -1.81818187
  20360,   21.9669418,   33.0765533,  -1.81818187
  20361,   22.9504128,   33.0765533,  -1.81818187
  20362,   23.9338837,   33.0765533,  -1.81818187
  20363,   24.9173546,   33.0765533,  -1.81818187
  20364,   25.9008274,   33.0765533,  -1.81818187
  20365,   26.7206612,   33.0765533,  -1.81818187
  20366,   27.5404968,   33.0765533,  -1.81818187
  20367,   28.3603306,   33.0765533,  -1.81818187
  20368,   29.1801662,   33.0765533,  -1.81818187
  20369,   20.9834709,   33.8746414,  -1.81818187
  20370,   21.9669418,   33.8746414,  -1.81818187
  20371,   22.9504128,   33.8746414,  -1.81818187
  20372,   23.9338837,   33.8746414,  -1.81818187
  20373,   24.9173546,   33.8746414,  -1.81818187
  20374,   25.9008274,   33.8746414,  -1.81818187
  20375,   26.7206612,   33.8746414,  -1.81818187
  20376,   27.5404968,   33.8746414,  -1.81818187
  20377,   28.3603306,   33.8746414,  -1.81818187
  20378,   29.1801662,   33.8746414,  -1.81818187
  20379,   20.9834709,   34.6727257,  -1.81818187
  20380,   21.9669418,   34.6727257,  -1.81818187
  20381,   22.9504128,   34.6727257,  -1.81818187
  20382,   23.9338837,   34.6727257,  -1.81818187
  20383,   24.9173546,   34.6727257,  -1.81818187
  20384,   25.9008274,   34.6727257,  -1.81818187
  20385,   26.7206612,   34.6727257,  -1.81818187
  20386,   27.5404968,   34.6727257,  -1.81818187
  20387,   28.3603306,   34.6727257,  -1.81818187
  20388,   29.1801662,   34.6727257,  -1.81818187
  20389,   20.9834709,   35.4708138,  -1.81818187
  20390,   21.9669418,   35.4708138,  -1.81818187
  20391,   22.9504128,   35.4708138,  -1.81818187
  20392,   23.9338837,   35.4708138,  -1.81818187
  20393,   24.9173546,   35.4708138,  -1.81818187
  20394,   25.9008274,   35.4708138,  -1.81818187
  20395,   26.7206612,   35.4708138,  -1.81818187
  20396,   27.5404968,   35.4708138,  -1.81818187
  20397,   28.3603306,   35.4708138,  -1.81818187
  20398,   29.1801662,   35.4708138,  -1.81818187
  20399,   20.9834709,    36.268898,  -1.81818187
  20400,   21.9669418,    36.268898,  -1.81818187
  20401,   22.9504128,    36.268898,  -1.81818187
  20402,   23.9338837,    36.268898,  -1.81818187
  20403,   24.9173546,    36.268898,  -1.81818187
  20404,   25.9008274,    36.268898,  -1.81818187
  20405,   26.7206612,    36.268898,  -1.81818187
  20406,   27.5404968,    36.268898,  -1.81818187
  20407,   28.3603306,    36.268898,  -1.81818187
  20408,   29.1801662,    36.268898,  -1.81818187
  20409,   20.9834709,   37.0669861,  -1.81818187
  20410,   21.9669418,   37.0669861,  -1.81818187
  20411,   22.9504128,   37.0669861,  -1.81818187
  20412,   23.9338837,   37.0669861,  -1.81818187
  20413,   24.9173546,   37.0669861,  -1.81818187
  20414,   25.9008274,   37.0669861,  -1.81818187
  20415,   26.7206612,   37.0669861,  -1.81818187
  20416,   27.5404968,   37.0669861,  -1.81818187
  20417,   28.3603306,   37.0669861,  -1.81818187
  20418,   29.1801662,   37.0669861,  -1.81818187
  20419,   20.9834709,   37.8650703,  -1.81818187
  20420,   21.9669418,   37.8650703,  -1.81818187
  20421,   22.9504128,   37.8650703,  -1.81818187
  20422,   23.9338837,   37.8650703,  -1.81818187
  20423,   24.9173546,   37.8650703,  -1.81818187
  20424,   25.9008274,   37.8650703,  -1.81818187
  20425,   26.7206612,   37.8650703,  -1.81818187
  20426,   27.5404968,   37.8650703,  -1.81818187
  20427,   28.3603306,   37.8650703,  -1.81818187
  20428,   29.1801662,   37.8650703,  -1.81818187
  20429,   20.9834709,   38.6631584,  -1.81818187
  20430,   21.9669418,   38.6631584,  -1.81818187
  20431,   22.9504128,   38.6631584,  -1.81818187
  20432,   23.9338837,   38.6631584,  -1.81818187
  20433,   24.9173546,   38.6631584,  -1.81818187
  20434,   25.9008274,   38.6631584,  -1.81818187
  20435,   26.7206612,   38.6631584,  -1.81818187
  20436,   27.5404968,   38.6631584,  -1.81818187
  20437,   28.3603306,   38.6631584,  -1.81818187
  20438,   29.1801662,   38.6631584,  -1.81818187
  20439,   20.9834709,   39.4612427,  -1.81818187
  20440,   21.9669418,   39.4612427,  -1.81818187
  20441,   22.9504128,   39.4612427,  -1.81818187
  20442,   23.9338837,   39.4612427,  -1.81818187
  20443,   24.9173546,   39.4612427,  -1.81818187
  20444,   25.9008274,   39.4612427,  -1.81818187
  20445,   26.7206612,   39.4612427,  -1.81818187
  20446,   27.5404968,   39.4612427,  -1.81818187
  20447,   28.3603306,   39.4612427,  -1.81818187
  20448,   29.1801662,   39.4612427,  -1.81818187
  20449,   20.9834709,   40.2593307,  -1.81818187
  20450,   21.9669418,   40.2593307,  -1.81818187
  20451,   22.9504128,   40.2593307,  -1.81818187
  20452,   23.9338837,   40.2593307,  -1.81818187
  20453,   24.9173546,   40.2593307,  -1.81818187
  20454,   25.9008274,   40.2593307,  -1.81818187
  20455,   26.7206612,   40.2593307,  -1.81818187
  20456,   27.5404968,   40.2593307,  -1.81818187
  20457,   28.3603306,   40.2593307,  -1.81818187
  20458,   29.1801662,   40.2593307,  -1.81818187
  20459,   20.9834709,    41.057415,  -1.81818187
  20460,   21.9669418,    41.057415,  -1.81818187
  20461,   22.9504128,    41.057415,  -1.81818187
  20462,   23.9338837,    41.057415,  -1.81818187
  20463,   24.9173546,    41.057415,  -1.81818187
  20464,   25.9008274,    41.057415,  -1.81818187
  20465,   26.7206612,    41.057415,  -1.81818187
  20466,   27.5404968,    41.057415,  -1.81818187
  20467,   28.3603306,    41.057415,  -1.81818187
  20468,   29.1801662,    41.057415,  -1.81818187
  20469,   20.9834709,   41.8555031,  -1.81818187
  20470,   21.9669418,   41.8555031,  -1.81818187
  20471,   22.9504128,   41.8555031,  -1.81818187
  20472,   23.9338837,   41.8555031,  -1.81818187
  20473,   24.9173546,   41.8555031,  -1.81818187
  20474,   25.9008274,   41.8555031,  -1.81818187
  20475,   26.7206612,   41.8555031,  -1.81818187
  20476,   27.5404968,   41.8555031,  -1.81818187
  20477,   28.3603306,   41.8555031,  -1.81818187
  20478,   29.1801662,   41.8555031,  -1.81818187
  20479,   20.9834709,   42.6535873,  -1.81818187
  20480,   21.9669418,   42.6535873,  -1.81818187
  20481,   22.9504128,   42.6535873,  -1.81818187
  20482,   23.9338837,   42.6535873,  -1.81818187
  20483,   24.9173546,   42.6535873,  -1.81818187
  20484,   25.9008274,   42.6535873,  -1.81818187
  20485,   26.7206612,   42.6535873,  -1.81818187
  20486,   27.5404968,   42.6535873,  -1.81818187
  20487,   28.3603306,   42.6535873,  -1.81818187
  20488,   29.1801662,   42.6535873,  -1.81818187
  20489,   20.9834709,   43.4516754,  -1.81818187
  20490,   21.9669418,   43.4516754,  -1.81818187
  20491,   22.9504128,   43.4516754,  -1.81818187
  20492,   23.9338837,   43.4516754,  -1.81818187
  20493,   24.9173546,   43.4516754,  -1.81818187
  20494,   25.9008274,   43.4516754,  -1.81818187
  20495,   26.7206612,   43.4516754,  -1.81818187
  20496,   27.5404968,   43.4516754,  -1.81818187
  20497,   28.3603306,   43.4516754,  -1.81818187
  20498,   29.1801662,   43.4516754,  -1.81818187
  20499,   20.9834709,   44.2497597,  -1.81818187
  20500,   21.9669418,   44.2497597,  -1.81818187
  20501,   22.9504128,   44.2497597,  -1.81818187
  20502,   23.9338837,   44.2497597,  -1.81818187
  20503,   24.9173546,   44.2497597,  -1.81818187
  20504,   25.9008274,   44.2497597,  -1.81818187
  20505,   26.7206612,   44.2497597,  -1.81818187
  20506,   27.5404968,   44.2497597,  -1.81818187
  20507,   28.3603306,   44.2497597,  -1.81818187
  20508,   29.1801662,   44.2497597,  -1.81818187
  20509,   20.9834709,   45.0478477,  -1.81818187
  20510,   21.9669418,   45.0478477,  -1.81818187
  20511,   22.9504128,   45.0478477,  -1.81818187
  20512,   23.9338837,   45.0478477,  -1.81818187
  20513,   24.9173546,   45.0478477,  -1.81818187
  20514,   25.9008274,   45.0478477,  -1.81818187
  20515,   26.7206612,   45.0478477,  -1.81818187
  20516,   27.5404968,   45.0478477,  -1.81818187
  20517,   28.3603306,   45.0478477,  -1.81818187
  20518,   29.1801662,   45.0478477,  -1.81818187
  20519,   20.9710732,   45.8732071,  -1.81818187
  20520,   21.9421482,   45.8732071,  -1.81818187
  20521,   22.9132233,   45.8732071,  -1.81818187
  20522,   23.8842983,   45.8732071,  -1.81818187
  20523,   24.8553715,   45.8732071,  -1.81818187
  20524,   25.8264465,   45.8732071,  -1.81818187
  20525,   26.6611557,   45.8732071,  -1.81818187
  20526,   27.4958668,   45.8732071,  -1.81818187
  20527,   28.3305779,   45.8732071,  -1.81818187
  20528,   29.1652889,   45.8732071,  -1.81818187
  20529,   20.9586773,   46.6985664,  -1.81818187
  20530,   21.9173546,   46.6985664,  -1.81818187
  20531,   22.8760319,   46.6985664,  -1.81818187
  20532,   23.8347111,   46.6985664,  -1.81818187
  20533,   24.7933884,   46.6985664,  -1.81818187
  20534,   25.7520657,   46.6985664,  -1.81818187
  20535,   26.6016521,   46.6985664,  -1.81818187
  20536,   27.4512405,   46.6985664,  -1.81818187
  20537,    28.300827,   46.6985664,  -1.81818187
  20538,   29.1504135,   46.6985664,  -1.81818187
  20539,   20.9462814,    47.523922,  -1.81818187
  20540,    21.892561,    47.523922,  -1.81818187
  20541,   22.8388424,    47.523922,  -1.81818187
  20542,   23.7851238,    47.523922,  -1.81818187
  20543,   24.7314053,    47.523922,  -1.81818187
  20544,   25.6776848,    47.523922,  -1.81818187
  20545,   26.5421486,    47.523922,  -1.81818187
  20546,   27.4066105,    47.523922,  -1.81818187
  20547,   28.2710743,    47.523922,  -1.81818187
  20548,   29.1355381,    47.523922,  -1.81818187
  20549,   20.9338837,   48.3492813,  -1.81818187
  20550,   21.8677692,   48.3492813,  -1.81818187
  20551,   22.8016529,   48.3492813,  -1.81818187
  20552,   23.7355366,   48.3492813,  -1.81818187
  20553,   24.6694221,   48.3492813,  -1.81818187
  20554,   25.6033058,   48.3492813,  -1.81818187
  20555,    26.482645,   48.3492813,  -1.81818187
  20556,   27.3619843,   48.3492813,  -1.81818187
  20557,   28.2413216,   48.3492813,  -1.81818187
  20558,   29.1206627,   48.3492813,  -1.81818187
  20559,   20.9214878,   49.1746407,  -1.81818187
  20560,   21.8429737,   49.1746407,  -1.81818187
  20561,   22.7644634,   49.1746407,  -1.81818187
  20562,   23.6859512,   49.1746407,  -1.81818187
  20563,   24.6074371,   49.1746407,  -1.81818187
  20564,   25.5289249,   49.1746407,  -1.81818187
  20565,   26.4231396,   49.1746407,  -1.81818187
  20566,   27.3173561,   49.1746407,  -1.81818187
  20567,   28.2115707,   49.1746407,  -1.81818187
  20568,   29.1057854,   49.1746407,  -1.81818187
  20569,   20.9185352,   20.7347908,  -2.72727275
  20570,   21.8370724,   20.7347908,  -2.72727275
  20571,   22.7556076,   20.7347908,  -2.72727275
  20572,   23.6741447,   20.7347908,  -2.72727275
  20573,     24.59268,   20.7347908,  -2.72727275
  20574,   25.5112152,   20.7347908,  -2.72727275
  20575,   26.4089718,   20.7347908,  -2.72727275
  20576,   27.3067303,   20.7347908,  -2.72727275
  20577,   28.2044868,   20.7347908,  -2.72727275
  20578,   29.1022434,   20.7347908,  -2.72727275
  20579,   20.9279804,   21.4695835,  -2.72727275
  20580,   21.8559628,   21.4695835,  -2.72727275
  20581,   22.7839432,   21.4695835,  -2.72727275
  20582,   23.7119236,   21.4695835,  -2.72727275
  20583,   24.6399059,   21.4695835,  -2.72727275
  20584,   25.5678864,   21.4695835,  -2.72727275
  20585,   26.4543095,   21.4695835,  -2.72727275
  20586,   27.3407326,   21.4695835,  -2.72727275
  20587,   28.2271538,   21.4695835,  -2.72727275
  20588,   29.1135769,   21.4695835,  -2.72727275
  20589,   20.9374256,   22.2043743,  -2.72727275
  20590,   21.8748531,   22.2043743,  -2.72727275
  20591,   22.8122787,   22.2043743,  -2.72727275
  20592,   23.7497044,   22.2043743,  -2.72727275
  20593,     24.68713,   22.2043743,  -2.72727275
  20594,   25.6245575,   22.2043743,  -2.72727275
  20595,   26.4996452,   22.2043743,  -2.72727275
  20596,   27.3747349,   22.2043743,  -2.72727275
  20597,   28.2498226,   22.2043743,  -2.72727275
  20598,   29.1249123,   22.2043743,  -2.72727275
  20599,   20.9468708,    22.939167,  -2.72727275
  20600,   21.8937416,    22.939167,  -2.72727275
  20601,   22.8406143,    22.939167,  -2.72727275
  20602,   23.7874851,    22.939167,  -2.72727275
  20603,   24.7343559,    22.939167,  -2.72727275
  20604,   25.6812286,    22.939167,  -2.72727275
  20605,   26.5449829,    22.939167,  -2.72727275
  20606,   27.4087372,    22.939167,  -2.72727275
  20607,   28.2724915,    22.939167,  -2.72727275
  20608,   29.1362457,    22.939167,  -2.72727275
  20609,    20.956316,   23.6739578,  -2.72727275
  20610,    21.912632,   23.6739578,  -2.72727275
  20611,    22.868948,   23.6739578,  -2.72727275
  20612,   23.8252659,   23.6739578,  -2.72727275
  20613,   24.7815819,   23.6739578,  -2.72727275
  20614,   25.7378998,   23.6739578,  -2.72727275
  20615,   26.5903187,   23.6739578,  -2.72727275
  20616,   27.4427395,   23.6739578,  -2.72727275
  20617,   28.2951584,   23.6739578,  -2.72727275
  20618,   29.1475792,   23.6739578,  -2.72727275
  20619,   20.9657612,   24.4087486,  -2.72727275
  20620,   21.9315224,   24.4087486,  -2.72727275
  20621,   22.8972836,   24.4087486,  -2.72727275
  20622,   23.8630466,   24.4087486,  -2.72727275
  20623,   24.8288078,   24.4087486,  -2.72727275
  20624,    25.794569,   24.4087486,  -2.72727275
  20625,   26.6356564,   24.4087486,  -2.72727275
  20626,   27.4767418,   24.4087486,  -2.72727275
  20627,   28.3178272,   24.4087486,  -2.72727275
  20628,   29.1589146,   24.4087486,  -2.72727275
  20629,   20.9752064,   25.1435413,  -2.72727275
  20630,   21.9504128,   25.1435413,  -2.72727275
  20631,   22.9256191,   25.1435413,  -2.72727275
  20632,   23.9008274,   25.1435413,  -2.72727275
  20633,   24.8760338,   25.1435413,  -2.72727275
  20634,   25.8512402,   25.1435413,  -2.72727275
  20635,   26.6809902,   25.1435413,  -2.72727275
  20636,   27.5107441,   25.1435413,  -2.72727275
  20637,   28.3404961,   25.1435413,  -2.72727275
  20638,    29.170248,   25.1435413,  -2.72727275
  20639,   20.9752064,     25.94067,  -2.72727275
  20640,   21.9504128,     25.94067,  -2.72727275
  20641,   22.9256191,     25.94067,  -2.72727275
  20642,   23.9008274,     25.94067,  -2.72727275
  20643,   24.8760338,     25.94067,  -2.72727275
  20644,   25.8512402,     25.94067,  -2.72727275
  20645,   26.6809902,     25.94067,  -2.72727275
  20646,   27.5107441,     25.94067,  -2.72727275
  20647,   28.3404961,     25.94067,  -2.72727275
  20648,    29.170248,     25.94067,  -2.72727275
  20649,   20.9752064,   26.7377987,  -2.72727275
  20650,   21.9504128,   26.7377987,  -2.72727275
  20651,   22.9256191,   26.7377987,  -2.72727275
  20652,   23.9008274,   26.7377987,  -2.72727275
  20653,   24.8760338,   26.7377987,  -2.72727275
  20654,   25.8512402,   26.7377987,  -2.72727275
  20655,   26.6809902,   26.7377987,  -2.72727275
  20656,   27.5107441,   26.7377987,  -2.72727275
  20657,   28.3404961,   26.7377987,  -2.72727275
  20658,    29.170248,   26.7377987,  -2.72727275
  20659,   20.9752064,   27.5349274,  -2.72727275
  20660,   21.9504128,   27.5349274,  -2.72727275
  20661,   22.9256191,   27.5349274,  -2.72727275
  20662,   23.9008274,   27.5349274,  -2.72727275
  20663,   24.8760338,   27.5349274,  -2.72727275
  20664,   25.8512402,   27.5349274,  -2.72727275
  20665,   26.6809902,   27.5349274,  -2.72727275
  20666,   27.5107441,   27.5349274,  -2.72727275
  20667,   28.3404961,   27.5349274,  -2.72727275
  20668,    29.170248,   27.5349274,  -2.72727275
  20669,   20.9752064,    28.332058,  -2.72727275
  20670,   21.9504128,    28.332058,  -2.72727275
  20671,   22.9256191,    28.332058,  -2.72727275
  20672,   23.9008274,    28.332058,  -2.72727275
  20673,   24.8760338,    28.332058,  -2.72727275
  20674,   25.8512402,    28.332058,  -2.72727275
  20675,   26.6809902,    28.332058,  -2.72727275
  20676,   27.5107441,    28.332058,  -2.72727275
  20677,   28.3404961,    28.332058,  -2.72727275
  20678,    29.170248,    28.332058,  -2.72727275
  20679,   20.9752064,   29.1291866,  -2.72727275
  20680,   21.9504128,   29.1291866,  -2.72727275
  20681,   22.9256191,   29.1291866,  -2.72727275
  20682,   23.9008274,   29.1291866,  -2.72727275
  20683,   24.8760338,   29.1291866,  -2.72727275
  20684,   25.8512402,   29.1291866,  -2.72727275
  20685,   26.6809902,   29.1291866,  -2.72727275
  20686,   27.5107441,   29.1291866,  -2.72727275
  20687,   28.3404961,   29.1291866,  -2.72727275
  20688,    29.170248,   29.1291866,  -2.72727275
  20689,   20.9752064,   29.9263153,  -2.72727275
  20690,   21.9504128,   29.9263153,  -2.72727275
  20691,   22.9256191,   29.9263153,  -2.72727275
  20692,   23.9008274,   29.9263153,  -2.72727275
  20693,   24.8760338,   29.9263153,  -2.72727275
  20694,   25.8512402,   29.9263153,  -2.72727275
  20695,   26.6809902,   29.9263153,  -2.72727275
  20696,   27.5107441,   29.9263153,  -2.72727275
  20697,   28.3404961,   29.9263153,  -2.72727275
  20698,    29.170248,   29.9263153,  -2.72727275
  20699,   20.9752064,   30.7234459,  -2.72727275
  20700,   21.9504128,   30.7234459,  -2.72727275
  20701,   22.9256191,   30.7234459,  -2.72727275
  20702,   23.9008274,   30.7234459,  -2.72727275
  20703,   24.8760338,   30.7234459,  -2.72727275
  20704,   25.8512402,   30.7234459,  -2.72727275
  20705,   26.6809902,   30.7234459,  -2.72727275
  20706,   27.5107441,   30.7234459,  -2.72727275
  20707,   28.3404961,   30.7234459,  -2.72727275
  20708,    29.170248,   30.7234459,  -2.72727275
  20709,   20.9752064,   31.5205746,  -2.72727275
  20710,   21.9504128,   31.5205746,  -2.72727275
  20711,   22.9256191,   31.5205746,  -2.72727275
  20712,   23.9008274,   31.5205746,  -2.72727275
  20713,   24.8760338,   31.5205746,  -2.72727275
  20714,   25.8512402,   31.5205746,  -2.72727275
  20715,   26.6809902,   31.5205746,  -2.72727275
  20716,   27.5107441,   31.5205746,  -2.72727275
  20717,   28.3404961,   31.5205746,  -2.72727275
  20718,    29.170248,   31.5205746,  -2.72727275
  20719,   20.9752064,   32.3177032,  -2.72727275
  20720,   21.9504128,   32.3177032,  -2.72727275
  20721,   22.9256191,   32.3177032,  -2.72727275
  20722,   23.9008274,   32.3177032,  -2.72727275
  20723,   24.8760338,   32.3177032,  -2.72727275
  20724,   25.8512402,   32.3177032,  -2.72727275
  20725,   26.6809902,   32.3177032,  -2.72727275
  20726,   27.5107441,   32.3177032,  -2.72727275
  20727,   28.3404961,   32.3177032,  -2.72727275
  20728,    29.170248,   32.3177032,  -2.72727275
  20729,   20.9752064,   33.1148338,  -2.72727275
  20730,   21.9504128,   33.1148338,  -2.72727275
  20731,   22.9256191,   33.1148338,  -2.72727275
  20732,   23.9008274,   33.1148338,  -2.72727275
  20733,   24.8760338,   33.1148338,  -2.72727275
  20734,   25.8512402,   33.1148338,  -2.72727275
  20735,   26.6809902,   33.1148338,  -2.72727275
  20736,   27.5107441,   33.1148338,  -2.72727275
  20737,   28.3404961,   33.1148338,  -2.72727275
  20738,    29.170248,   33.1148338,  -2.72727275
  20739,   20.9752064,   33.9119606,  -2.72727275
  20740,   21.9504128,   33.9119606,  -2.72727275
  20741,   22.9256191,   33.9119606,  -2.72727275
  20742,   23.9008274,   33.9119606,  -2.72727275
  20743,   24.8760338,   33.9119606,  -2.72727275
  20744,   25.8512402,   33.9119606,  -2.72727275
  20745,   26.6809902,   33.9119606,  -2.72727275
  20746,   27.5107441,   33.9119606,  -2.72727275
  20747,   28.3404961,   33.9119606,  -2.72727275
  20748,    29.170248,   33.9119606,  -2.72727275
  20749,   20.9752064,   34.7090912,  -2.72727275
  20750,   21.9504128,   34.7090912,  -2.72727275
  20751,   22.9256191,   34.7090912,  -2.72727275
  20752,   23.9008274,   34.7090912,  -2.72727275
  20753,   24.8760338,   34.7090912,  -2.72727275
  20754,   25.8512402,   34.7090912,  -2.72727275
  20755,   26.6809902,   34.7090912,  -2.72727275
  20756,   27.5107441,   34.7090912,  -2.72727275
  20757,   28.3404961,   34.7090912,  -2.72727275
  20758,    29.170248,   34.7090912,  -2.72727275
  20759,   20.9752064,   35.5062218,  -2.72727275
  20760,   21.9504128,   35.5062218,  -2.72727275
  20761,   22.9256191,   35.5062218,  -2.72727275
  20762,   23.9008274,   35.5062218,  -2.72727275
  20763,   24.8760338,   35.5062218,  -2.72727275
  20764,   25.8512402,   35.5062218,  -2.72727275
  20765,   26.6809902,   35.5062218,  -2.72727275
  20766,   27.5107441,   35.5062218,  -2.72727275
  20767,   28.3404961,   35.5062218,  -2.72727275
  20768,    29.170248,   35.5062218,  -2.72727275
  20769,   20.9752064,   36.3033485,  -2.72727275
  20770,   21.9504128,   36.3033485,  -2.72727275
  20771,   22.9256191,   36.3033485,  -2.72727275
  20772,   23.9008274,   36.3033485,  -2.72727275
  20773,   24.8760338,   36.3033485,  -2.72727275
  20774,   25.8512402,   36.3033485,  -2.72727275
  20775,   26.6809902,   36.3033485,  -2.72727275
  20776,   27.5107441,   36.3033485,  -2.72727275
  20777,   28.3404961,   36.3033485,  -2.72727275
  20778,    29.170248,   36.3033485,  -2.72727275
  20779,   20.9752064,   37.1004791,  -2.72727275
  20780,   21.9504128,   37.1004791,  -2.72727275
  20781,   22.9256191,   37.1004791,  -2.72727275
  20782,   23.9008274,   37.1004791,  -2.72727275
  20783,   24.8760338,   37.1004791,  -2.72727275
  20784,   25.8512402,   37.1004791,  -2.72727275
  20785,   26.6809902,   37.1004791,  -2.72727275
  20786,   27.5107441,   37.1004791,  -2.72727275
  20787,   28.3404961,   37.1004791,  -2.72727275
  20788,    29.170248,   37.1004791,  -2.72727275
  20789,   20.9752064,   37.8976059,  -2.72727275
  20790,   21.9504128,   37.8976059,  -2.72727275
  20791,   22.9256191,   37.8976059,  -2.72727275
  20792,   23.9008274,   37.8976059,  -2.72727275
  20793,   24.8760338,   37.8976059,  -2.72727275
  20794,   25.8512402,   37.8976059,  -2.72727275
  20795,   26.6809902,   37.8976059,  -2.72727275
  20796,   27.5107441,   37.8976059,  -2.72727275
  20797,   28.3404961,   37.8976059,  -2.72727275
  20798,    29.170248,   37.8976059,  -2.72727275
  20799,   20.9752064,   38.6947365,  -2.72727275
  20800,   21.9504128,   38.6947365,  -2.72727275
  20801,   22.9256191,   38.6947365,  -2.72727275
  20802,   23.9008274,   38.6947365,  -2.72727275
  20803,   24.8760338,   38.6947365,  -2.72727275
  20804,   25.8512402,   38.6947365,  -2.72727275
  20805,   26.6809902,   38.6947365,  -2.72727275
  20806,   27.5107441,   38.6947365,  -2.72727275
  20807,   28.3404961,   38.6947365,  -2.72727275
  20808,    29.170248,   38.6947365,  -2.72727275
  20809,   20.9752064,   39.4918671,  -2.72727275
  20810,   21.9504128,   39.4918671,  -2.72727275
  20811,   22.9256191,   39.4918671,  -2.72727275
  20812,   23.9008274,   39.4918671,  -2.72727275
  20813,   24.8760338,   39.4918671,  -2.72727275
  20814,   25.8512402,   39.4918671,  -2.72727275
  20815,   26.6809902,   39.4918671,  -2.72727275
  20816,   27.5107441,   39.4918671,  -2.72727275
  20817,   28.3404961,   39.4918671,  -2.72727275
  20818,    29.170248,   39.4918671,  -2.72727275
  20819,   20.9752064,   40.2889938,  -2.72727275
  20820,   21.9504128,   40.2889938,  -2.72727275
  20821,   22.9256191,   40.2889938,  -2.72727275
  20822,   23.9008274,   40.2889938,  -2.72727275
  20823,   24.8760338,   40.2889938,  -2.72727275
  20824,   25.8512402,   40.2889938,  -2.72727275
  20825,   26.6809902,   40.2889938,  -2.72727275
  20826,   27.5107441,   40.2889938,  -2.72727275
  20827,   28.3404961,   40.2889938,  -2.72727275
  20828,    29.170248,   40.2889938,  -2.72727275
  20829,   20.9752064,   41.0861244,  -2.72727275
  20830,   21.9504128,   41.0861244,  -2.72727275
  20831,   22.9256191,   41.0861244,  -2.72727275
  20832,   23.9008274,   41.0861244,  -2.72727275
  20833,   24.8760338,   41.0861244,  -2.72727275
  20834,   25.8512402,   41.0861244,  -2.72727275
  20835,   26.6809902,   41.0861244,  -2.72727275
  20836,   27.5107441,   41.0861244,  -2.72727275
  20837,   28.3404961,   41.0861244,  -2.72727275
  20838,    29.170248,   41.0861244,  -2.72727275
  20839,   20.9752064,    41.883255,  -2.72727275
  20840,   21.9504128,    41.883255,  -2.72727275
  20841,   22.9256191,    41.883255,  -2.72727275
  20842,   23.9008274,    41.883255,  -2.72727275
  20843,   24.8760338,    41.883255,  -2.72727275
  20844,   25.8512402,    41.883255,  -2.72727275
  20845,   26.6809902,    41.883255,  -2.72727275
  20846,   27.5107441,    41.883255,  -2.72727275
  20847,   28.3404961,    41.883255,  -2.72727275
  20848,    29.170248,    41.883255,  -2.72727275
  20849,   20.9752064,   42.6803818,  -2.72727275
  20850,   21.9504128,   42.6803818,  -2.72727275
  20851,   22.9256191,   42.6803818,  -2.72727275
  20852,   23.9008274,   42.6803818,  -2.72727275
  20853,   24.8760338,   42.6803818,  -2.72727275
  20854,   25.8512402,   42.6803818,  -2.72727275
  20855,   26.6809902,   42.6803818,  -2.72727275
  20856,   27.5107441,   42.6803818,  -2.72727275
  20857,   28.3404961,   42.6803818,  -2.72727275
  20858,    29.170248,   42.6803818,  -2.72727275
  20859,   20.9752064,   43.4775124,  -2.72727275
  20860,   21.9504128,   43.4775124,  -2.72727275
  20861,   22.9256191,   43.4775124,  -2.72727275
  20862,   23.9008274,   43.4775124,  -2.72727275
  20863,   24.8760338,   43.4775124,  -2.72727275
  20864,   25.8512402,   43.4775124,  -2.72727275
  20865,   26.6809902,   43.4775124,  -2.72727275
  20866,   27.5107441,   43.4775124,  -2.72727275
  20867,   28.3404961,   43.4775124,  -2.72727275
  20868,    29.170248,   43.4775124,  -2.72727275
  20869,   20.9752064,   44.2746429,  -2.72727275
  20870,   21.9504128,   44.2746429,  -2.72727275
  20871,   22.9256191,   44.2746429,  -2.72727275
  20872,   23.9008274,   44.2746429,  -2.72727275
  20873,   24.8760338,   44.2746429,  -2.72727275
  20874,   25.8512402,   44.2746429,  -2.72727275
  20875,   26.6809902,   44.2746429,  -2.72727275
  20876,   27.5107441,   44.2746429,  -2.72727275
  20877,   28.3404961,   44.2746429,  -2.72727275
  20878,    29.170248,   44.2746429,  -2.72727275
  20879,   20.9752064,   45.0717697,  -2.72727275
  20880,   21.9504128,   45.0717697,  -2.72727275
  20881,   22.9256191,   45.0717697,  -2.72727275
  20882,   23.9008274,   45.0717697,  -2.72727275
  20883,   24.8760338,   45.0717697,  -2.72727275
  20884,   25.8512402,   45.0717697,  -2.72727275
  20885,   26.6809902,   45.0717697,  -2.72727275
  20886,   27.5107441,   45.0717697,  -2.72727275
  20887,   28.3404961,   45.0717697,  -2.72727275
  20888,    29.170248,   45.0717697,  -2.72727275
  20889,   20.9641876,   45.8931427,  -2.72727275
  20890,   21.9283733,   45.8931427,  -2.72727275
  20891,   22.8925629,   45.8931427,  -2.72727275
  20892,   23.8567486,   45.8931427,  -2.72727275
  20893,   24.8209362,   45.8931427,  -2.72727275
  20894,   25.7851238,   45.8931427,  -2.72727275
  20895,   26.6280994,   45.8931427,  -2.72727275
  20896,   27.4710751,   45.8931427,  -2.72727275
  20897,   28.3140488,   45.8931427,  -2.72727275
  20898,   29.1570244,   45.8931427,  -2.72727275
  20899,    20.953167,   46.7145119,  -2.72727275
  20900,   21.9063358,   46.7145119,  -2.72727275
  20901,   22.8595028,   46.7145119,  -2.72727275
  20902,   23.8126717,   46.7145119,  -2.72727275
  20903,   24.7658386,   46.7145119,  -2.72727275
  20904,   25.7190094,   46.7145119,  -2.72727275
  20905,   26.5752068,   46.7145119,  -2.72727275
  20906,    27.431406,   46.7145119,  -2.72727275
  20907,   28.2876034,   46.7145119,  -2.72727275
  20908,   29.1438026,   46.7145119,  -2.72727275
  20909,   20.9421482,   47.5358849,  -2.72727275
  20910,   21.8842964,   47.5358849,  -2.72727275
  20911,   22.8264465,   47.5358849,  -2.72727275
  20912,   23.7685947,   47.5358849,  -2.72727275
  20913,   24.7107449,   47.5358849,  -2.72727275
  20914,   25.6528931,   47.5358849,  -2.72727275
  20915,   26.5223141,   47.5358849,  -2.72727275
  20916,   27.3917351,   47.5358849,  -2.72727275
  20917,   28.2611561,   47.5358849,  -2.72727275
  20918,    29.130579,   47.5358849,  -2.72727275
  20919,   20.9311295,   48.3572578,  -2.72727275
  20920,   21.8622589,   48.3572578,  -2.72727275
  20921,   22.7933884,   48.3572578,  -2.72727275
  20922,   23.7245178,   48.3572578,  -2.72727275
  20923,   24.6556473,   48.3572578,  -2.72727275
  20924,   25.5867767,   48.3572578,  -2.72727275
  20925,   26.4694214,   48.3572578,  -2.72727275
  20926,    27.352066,   48.3572578,  -2.72727275
  20927,   28.2347107,   48.3572578,  -2.72727275
  20928,   29.1173553,   48.3572578,  -2.72727275
  20929,   20.9201088,    49.178627,  -2.72727275
  20930,   21.8402195,    49.178627,  -2.72727275
  20931,   22.7603302,    49.178627,  -2.72727275
  20932,   23.6804409,    49.178627,  -2.72727275
  20933,   24.6005516,    49.178627,  -2.72727275
  20934,   25.5206604,    49.178627,  -2.72727275
  20935,   26.4165287,    49.178627,  -2.72727275
  20936,    27.312397,    49.178627,  -2.72727275
  20937,   28.2082634,    49.178627,  -2.72727275
  20938,   29.1041317,    49.178627,  -2.72727275
  20939,   20.9173546,   20.7416267,  -3.63636374
  20940,   21.8347111,   20.7416267,  -3.63636374
  20941,   22.7520657,   20.7416267,  -3.63636374
  20942,   23.6694221,   20.7416267,  -3.63636374
  20943,   24.5867767,   20.7416267,  -3.63636374
  20944,   25.5041313,   20.7416267,  -3.63636374
  20945,   26.4033051,   20.7416267,  -3.63636374
  20946,   27.3024807,   20.7416267,  -3.63636374
  20947,   28.2016525,   20.7416267,  -3.63636374
  20948,   29.1008263,   20.7416267,  -3.63636374
  20949,   20.9256191,   21.4832535,  -3.63636374
  20950,   21.8512402,   21.4832535,  -3.63636374
  20951,   22.7768593,   21.4832535,  -3.63636374
  20952,   23.7024784,   21.4832535,  -3.63636374
  20953,   24.6280994,   21.4832535,  -3.63636374
  20954,   25.5537186,   21.4832535,  -3.63636374
  20955,    26.442976,   21.4832535,  -3.63636374
  20956,   27.3322315,   21.4832535,  -3.63636374
  20957,    28.221487,   21.4832535,  -3.63636374
  20958,   29.1107445,   21.4832535,  -3.63636374
  20959,   20.9338837,   22.2248802,  -3.63636374
  20960,   21.8677692,   22.2248802,  -3.63636374
  20961,   22.8016529,   22.2248802,  -3.63636374
  20962,   23.7355366,   22.2248802,  -3.63636374
  20963,   24.6694202,   22.2248802,  -3.63636374
  20964,   25.6033058,   22.2248802,  -3.63636374
  20965,    26.482645,   22.2248802,  -3.63636374
  20966,   27.3619843,   22.2248802,  -3.63636374
  20967,   28.2413216,   22.2248802,  -3.63636374
  20968,   29.1206627,   22.2248802,  -3.63636374
  20969,   20.9421482,    22.966507,  -3.63636374
  20970,   21.8842964,    22.966507,  -3.63636374
  20971,   22.8264465,    22.966507,  -3.63636374
  20972,   23.7685947,    22.966507,  -3.63636374
  20973,    24.710743,    22.966507,  -3.63636374
  20974,   25.6528931,    22.966507,  -3.63636374
  20975,   26.5223141,    22.966507,  -3.63636374
  20976,   27.3917351,    22.966507,  -3.63636374
  20977,    28.261158,    22.966507,  -3.63636374
  20978,    29.130579,    22.966507,  -3.63636374
  20979,   20.9504128,   23.7081337,  -3.63636374
  20980,   21.9008255,   23.7081337,  -3.63636374
  20981,   22.8512383,   23.7081337,  -3.63636374
  20982,   23.8016529,   23.7081337,  -3.63636374
  20983,   24.7520657,   23.7081337,  -3.63636374
  20984,   25.7024803,   23.7081337,  -3.63636374
  20985,   26.5619831,   23.7081337,  -3.63636374
  20986,   27.4214878,   23.7081337,  -3.63636374
  20987,   28.2809906,   23.7081337,  -3.63636374
  20988,   29.1404953,   23.7081337,  -3.63636374
  20989,   20.9586773,   24.4497604,  -3.63636374
  20990,   21.9173546,   24.4497604,  -3.63636374
  20991,   22.8760319,   24.4497604,  -3.63636374
  20992,   23.8347111,   24.4497604,  -3.63636374
  20993,   24.7933884,   24.4497604,  -3.63636374
  20994,   25.7520657,   24.4497604,  -3.63636374
  20995,   26.6016541,   24.4497604,  -3.63636374
  20996,   27.4512405,   24.4497604,  -3.63636374
  20997,    28.300827,   24.4497604,  -3.63636374
  20998,   29.1504135,   24.4497604,  -3.63636374
  20999,   20.9669418,   25.1913872,  -3.63636374
  21000,   21.9338837,   25.1913872,  -3.63636374
  21001,   22.9008255,   25.1913872,  -3.63636374
  21002,   23.8677692,   25.1913872,  -3.63636374
  21003,   24.8347111,   25.1913872,  -3.63636374
  21004,   25.8016529,   25.1913872,  -3.63636374
  21005,   26.6413212,   25.1913872,  -3.63636374
  21006,   27.4809914,   25.1913872,  -3.63636374
  21007,   28.3206615,   25.1913872,  -3.63636374
  21008,   29.1603317,   25.1913872,  -3.63636374
  21009,   20.9669418,   25.9875603,  -3.63636374
  21010,   21.9338837,   25.9875603,  -3.63636374
  21011,   22.9008255,   25.9875603,  -3.63636374
  21012,   23.8677692,   25.9875603,  -3.63636374
  21013,   24.8347111,   25.9875603,  -3.63636374
  21014,   25.8016529,   25.9875603,  -3.63636374
  21015,   26.6413212,   25.9875603,  -3.63636374
  21016,   27.4809914,   25.9875603,  -3.63636374
  21017,   28.3206615,   25.9875603,  -3.63636374
  21018,   29.1603317,   25.9875603,  -3.63636374
  21019,   20.9669418,   26.7837315,  -3.63636374
  21020,   21.9338837,   26.7837315,  -3.63636374
  21021,   22.9008255,   26.7837315,  -3.63636374
  21022,   23.8677692,   26.7837315,  -3.63636374
  21023,   24.8347111,   26.7837315,  -3.63636374
  21024,   25.8016529,   26.7837315,  -3.63636374
  21025,   26.6413212,   26.7837315,  -3.63636374
  21026,   27.4809914,   26.7837315,  -3.63636374
  21027,   28.3206615,   26.7837315,  -3.63636374
  21028,   29.1603317,   26.7837315,  -3.63636374
  21029,   20.9669418,   27.5799046,  -3.63636374
  21030,   21.9338837,   27.5799046,  -3.63636374
  21031,   22.9008255,   27.5799046,  -3.63636374
  21032,   23.8677692,   27.5799046,  -3.63636374
  21033,   24.8347111,   27.5799046,  -3.63636374
  21034,   25.8016529,   27.5799046,  -3.63636374
  21035,   26.6413212,   27.5799046,  -3.63636374
  21036,   27.4809914,   27.5799046,  -3.63636374
  21037,   28.3206615,   27.5799046,  -3.63636374
  21038,   29.1603317,   27.5799046,  -3.63636374
  21039,   20.9669418,   28.3760757,  -3.63636374
  21040,   21.9338837,   28.3760757,  -3.63636374
  21041,   22.9008255,   28.3760757,  -3.63636374
  21042,   23.8677692,   28.3760757,  -3.63636374
  21043,   24.8347111,   28.3760757,  -3.63636374
  21044,   25.8016529,   28.3760757,  -3.63636374
  21045,   26.6413212,   28.3760757,  -3.63636374
  21046,   27.4809914,   28.3760757,  -3.63636374
  21047,   28.3206615,   28.3760757,  -3.63636374
  21048,   29.1603317,   28.3760757,  -3.63636374
  21049,   20.9669418,   29.1722488,  -3.63636374
  21050,   21.9338837,   29.1722488,  -3.63636374
  21051,   22.9008255,   29.1722488,  -3.63636374
  21052,   23.8677692,   29.1722488,  -3.63636374
  21053,   24.8347111,   29.1722488,  -3.63636374
  21054,   25.8016529,   29.1722488,  -3.63636374
  21055,   26.6413212,   29.1722488,  -3.63636374
  21056,   27.4809914,   29.1722488,  -3.63636374
  21057,   28.3206615,   29.1722488,  -3.63636374
  21058,   29.1603317,   29.1722488,  -3.63636374
  21059,   20.9669418,   29.9684219,  -3.63636374
  21060,   21.9338837,   29.9684219,  -3.63636374
  21061,   22.9008255,   29.9684219,  -3.63636374
  21062,   23.8677692,   29.9684219,  -3.63636374
  21063,   24.8347111,   29.9684219,  -3.63636374
  21064,   25.8016529,   29.9684219,  -3.63636374
  21065,   26.6413212,   29.9684219,  -3.63636374
  21066,   27.4809914,   29.9684219,  -3.63636374
  21067,   28.3206615,   29.9684219,  -3.63636374
  21068,   29.1603317,   29.9684219,  -3.63636374
  21069,   20.9669418,   30.7645931,  -3.63636374
  21070,   21.9338837,   30.7645931,  -3.63636374
  21071,   22.9008255,   30.7645931,  -3.63636374
  21072,   23.8677692,   30.7645931,  -3.63636374
  21073,   24.8347111,   30.7645931,  -3.63636374
  21074,   25.8016529,   30.7645931,  -3.63636374
  21075,   26.6413212,   30.7645931,  -3.63636374
  21076,   27.4809914,   30.7645931,  -3.63636374
  21077,   28.3206615,   30.7645931,  -3.63636374
  21078,   29.1603317,   30.7645931,  -3.63636374
  21079,   20.9669418,   31.5607662,  -3.63636374
  21080,   21.9338837,   31.5607662,  -3.63636374
  21081,   22.9008255,   31.5607662,  -3.63636374
  21082,   23.8677692,   31.5607662,  -3.63636374
  21083,   24.8347111,   31.5607662,  -3.63636374
  21084,   25.8016529,   31.5607662,  -3.63636374
  21085,   26.6413212,   31.5607662,  -3.63636374
  21086,   27.4809914,   31.5607662,  -3.63636374
  21087,   28.3206615,   31.5607662,  -3.63636374
  21088,   29.1603317,   31.5607662,  -3.63636374
  21089,   20.9669418,   32.3569374,  -3.63636374
  21090,   21.9338837,   32.3569374,  -3.63636374
  21091,   22.9008255,   32.3569374,  -3.63636374
  21092,   23.8677692,   32.3569374,  -3.63636374
  21093,   24.8347111,   32.3569374,  -3.63636374
  21094,   25.8016529,   32.3569374,  -3.63636374
  21095,   26.6413212,   32.3569374,  -3.63636374
  21096,   27.4809914,   32.3569374,  -3.63636374
  21097,   28.3206615,   32.3569374,  -3.63636374
  21098,   29.1603317,   32.3569374,  -3.63636374
  21099,   20.9669418,   33.1531105,  -3.63636374
  21100,   21.9338837,   33.1531105,  -3.63636374
  21101,   22.9008255,   33.1531105,  -3.63636374
  21102,   23.8677692,   33.1531105,  -3.63636374
  21103,   24.8347111,   33.1531105,  -3.63636374
  21104,   25.8016529,   33.1531105,  -3.63636374
  21105,   26.6413212,   33.1531105,  -3.63636374
  21106,   27.4809914,   33.1531105,  -3.63636374
  21107,   28.3206615,   33.1531105,  -3.63636374
  21108,   29.1603317,   33.1531105,  -3.63636374
  21109,   20.9669418,   33.9492836,  -3.63636374
  21110,   21.9338837,   33.9492836,  -3.63636374
  21111,   22.9008255,   33.9492836,  -3.63636374
  21112,   23.8677692,   33.9492836,  -3.63636374
  21113,   24.8347111,   33.9492836,  -3.63636374
  21114,   25.8016529,   33.9492836,  -3.63636374
  21115,   26.6413212,   33.9492836,  -3.63636374
  21116,   27.4809914,   33.9492836,  -3.63636374
  21117,   28.3206615,   33.9492836,  -3.63636374
  21118,   29.1603317,   33.9492836,  -3.63636374
  21119,   20.9669418,   34.7454529,  -3.63636374
  21120,   21.9338837,   34.7454529,  -3.63636374
  21121,   22.9008255,   34.7454529,  -3.63636374
  21122,   23.8677692,   34.7454529,  -3.63636374
  21123,   24.8347111,   34.7454529,  -3.63636374
  21124,   25.8016529,   34.7454529,  -3.63636374
  21125,   26.6413212,   34.7454529,  -3.63636374
  21126,   27.4809914,   34.7454529,  -3.63636374
  21127,   28.3206615,   34.7454529,  -3.63636374
  21128,   29.1603317,   34.7454529,  -3.63636374
  21129,   20.9669418,    35.541626,  -3.63636374
  21130,   21.9338837,    35.541626,  -3.63636374
  21131,   22.9008255,    35.541626,  -3.63636374
  21132,   23.8677692,    35.541626,  -3.63636374
  21133,   24.8347111,    35.541626,  -3.63636374
  21134,   25.8016529,    35.541626,  -3.63636374
  21135,   26.6413212,    35.541626,  -3.63636374
  21136,   27.4809914,    35.541626,  -3.63636374
  21137,   28.3206615,    35.541626,  -3.63636374
  21138,   29.1603317,    35.541626,  -3.63636374
  21139,   20.9669418,   36.3377991,  -3.63636374
  21140,   21.9338837,   36.3377991,  -3.63636374
  21141,   22.9008255,   36.3377991,  -3.63636374
  21142,   23.8677692,   36.3377991,  -3.63636374
  21143,   24.8347111,   36.3377991,  -3.63636374
  21144,   25.8016529,   36.3377991,  -3.63636374
  21145,   26.6413212,   36.3377991,  -3.63636374
  21146,   27.4809914,   36.3377991,  -3.63636374
  21147,   28.3206615,   36.3377991,  -3.63636374
  21148,   29.1603317,   36.3377991,  -3.63636374
  21149,   20.9669418,   37.1339722,  -3.63636374
  21150,   21.9338837,   37.1339722,  -3.63636374
  21151,   22.9008255,   37.1339722,  -3.63636374
  21152,   23.8677692,   37.1339722,  -3.63636374
  21153,   24.8347111,   37.1339722,  -3.63636374
  21154,   25.8016529,   37.1339722,  -3.63636374
  21155,   26.6413212,   37.1339722,  -3.63636374
  21156,   27.4809914,   37.1339722,  -3.63636374
  21157,   28.3206615,   37.1339722,  -3.63636374
  21158,   29.1603317,   37.1339722,  -3.63636374
  21159,   20.9669418,   37.9301453,  -3.63636374
  21160,   21.9338837,   37.9301453,  -3.63636374
  21161,   22.9008255,   37.9301453,  -3.63636374
  21162,   23.8677692,   37.9301453,  -3.63636374
  21163,   24.8347111,   37.9301453,  -3.63636374
  21164,   25.8016529,   37.9301453,  -3.63636374
  21165,   26.6413212,   37.9301453,  -3.63636374
  21166,   27.4809914,   37.9301453,  -3.63636374
  21167,   28.3206615,   37.9301453,  -3.63636374
  21168,   29.1603317,   37.9301453,  -3.63636374
  21169,   20.9669418,   38.7263145,  -3.63636374
  21170,   21.9338837,   38.7263145,  -3.63636374
  21171,   22.9008255,   38.7263145,  -3.63636374
  21172,   23.8677692,   38.7263145,  -3.63636374
  21173,   24.8347111,   38.7263145,  -3.63636374
  21174,   25.8016529,   38.7263145,  -3.63636374
  21175,   26.6413212,   38.7263145,  -3.63636374
  21176,   27.4809914,   38.7263145,  -3.63636374
  21177,   28.3206615,   38.7263145,  -3.63636374
  21178,   29.1603317,   38.7263145,  -3.63636374
  21179,   20.9669418,   39.5224876,  -3.63636374
  21180,   21.9338837,   39.5224876,  -3.63636374
  21181,   22.9008255,   39.5224876,  -3.63636374
  21182,   23.8677692,   39.5224876,  -3.63636374
  21183,   24.8347111,   39.5224876,  -3.63636374
  21184,   25.8016529,   39.5224876,  -3.63636374
  21185,   26.6413212,   39.5224876,  -3.63636374
  21186,   27.4809914,   39.5224876,  -3.63636374
  21187,   28.3206615,   39.5224876,  -3.63636374
  21188,   29.1603317,   39.5224876,  -3.63636374
  21189,   20.9669418,   40.3186607,  -3.63636374
  21190,   21.9338837,   40.3186607,  -3.63636374
  21191,   22.9008255,   40.3186607,  -3.63636374
  21192,   23.8677692,   40.3186607,  -3.63636374
  21193,   24.8347111,   40.3186607,  -3.63636374
  21194,   25.8016529,   40.3186607,  -3.63636374
  21195,   26.6413212,   40.3186607,  -3.63636374
  21196,   27.4809914,   40.3186607,  -3.63636374
  21197,   28.3206615,   40.3186607,  -3.63636374
  21198,   29.1603317,   40.3186607,  -3.63636374
  21199,   20.9669418,   41.1148338,  -3.63636374
  21200,   21.9338837,   41.1148338,  -3.63636374
  21201,   22.9008255,   41.1148338,  -3.63636374
  21202,   23.8677692,   41.1148338,  -3.63636374
  21203,   24.8347111,   41.1148338,  -3.63636374
  21204,   25.8016529,   41.1148338,  -3.63636374
  21205,   26.6413212,   41.1148338,  -3.63636374
  21206,   27.4809914,   41.1148338,  -3.63636374
  21207,   28.3206615,   41.1148338,  -3.63636374
  21208,   29.1603317,   41.1148338,  -3.63636374
  21209,   20.9669418,   41.9110031,  -3.63636374
  21210,   21.9338837,   41.9110031,  -3.63636374
  21211,   22.9008255,   41.9110031,  -3.63636374
  21212,   23.8677692,   41.9110031,  -3.63636374
  21213,   24.8347111,   41.9110031,  -3.63636374
  21214,   25.8016529,   41.9110031,  -3.63636374
  21215,   26.6413212,   41.9110031,  -3.63636374
  21216,   27.4809914,   41.9110031,  -3.63636374
  21217,   28.3206615,   41.9110031,  -3.63636374
  21218,   29.1603317,   41.9110031,  -3.63636374
  21219,   20.9669418,   42.7071762,  -3.63636374
  21220,   21.9338837,   42.7071762,  -3.63636374
  21221,   22.9008255,   42.7071762,  -3.63636374
  21222,   23.8677692,   42.7071762,  -3.63636374
  21223,   24.8347111,   42.7071762,  -3.63636374
  21224,   25.8016529,   42.7071762,  -3.63636374
  21225,   26.6413212,   42.7071762,  -3.63636374
  21226,   27.4809914,   42.7071762,  -3.63636374
  21227,   28.3206615,   42.7071762,  -3.63636374
  21228,   29.1603317,   42.7071762,  -3.63636374
  21229,   20.9669418,   43.5033493,  -3.63636374
  21230,   21.9338837,   43.5033493,  -3.63636374
  21231,   22.9008255,   43.5033493,  -3.63636374
  21232,   23.8677692,   43.5033493,  -3.63636374
  21233,   24.8347111,   43.5033493,  -3.63636374
  21234,   25.8016529,   43.5033493,  -3.63636374
  21235,   26.6413212,   43.5033493,  -3.63636374
  21236,   27.4809914,   43.5033493,  -3.63636374
  21237,   28.3206615,   43.5033493,  -3.63636374
  21238,   29.1603317,   43.5033493,  -3.63636374
  21239,   20.9669418,   44.2995224,  -3.63636374
  21240,   21.9338837,   44.2995224,  -3.63636374
  21241,   22.9008255,   44.2995224,  -3.63636374
  21242,   23.8677692,   44.2995224,  -3.63636374
  21243,   24.8347111,   44.2995224,  -3.63636374
  21244,   25.8016529,   44.2995224,  -3.63636374
  21245,   26.6413212,   44.2995224,  -3.63636374
  21246,   27.4809914,   44.2995224,  -3.63636374
  21247,   28.3206615,   44.2995224,  -3.63636374
  21248,   29.1603317,   44.2995224,  -3.63636374
  21249,   20.9669418,   45.0956955,  -3.63636374
  21250,   21.9338837,   45.0956955,  -3.63636374
  21251,   22.9008255,   45.0956955,  -3.63636374
  21252,   23.8677692,   45.0956955,  -3.63636374
  21253,   24.8347111,   45.0956955,  -3.63636374
  21254,   25.8016529,   45.0956955,  -3.63636374
  21255,   26.6413212,   45.0956955,  -3.63636374
  21256,   27.4809914,   45.0956955,  -3.63636374
  21257,   28.3206615,   45.0956955,  -3.63636374
  21258,   29.1603317,   45.0956955,  -3.63636374
  21259,   20.9573002,   45.9130783,  -3.63636374
  21260,   21.9146004,   45.9130783,  -3.63636374
  21261,   22.8719006,   45.9130783,  -3.63636374
  21262,   23.8292007,   45.9130783,  -3.63636374
  21263,   24.7865009,   45.9130783,  -3.63636374
  21264,   25.7438011,   45.9130783,  -3.63636374
  21265,   26.5950413,   45.9130783,  -3.63636374
  21266,   27.4462814,   45.9130783,  -3.63636374
  21267,   28.2975197,   45.9130783,  -3.63636374
  21268,   29.1487598,   45.9130783,  -3.63636374
  21269,   20.9476566,   46.7304611,  -3.63636374
  21270,   21.8953171,   46.7304611,  -3.63636374
  21271,   22.8429737,   46.7304611,  -3.63636374
  21272,   23.7906342,   46.7304611,  -3.63636374
  21273,   24.7382908,   46.7304611,  -3.63636374
  21274,   25.6859512,   46.7304611,  -3.63636374
  21275,   26.5487595,   46.7304611,  -3.63636374
  21276,   27.4115715,   46.7304611,  -3.63636374
  21277,   28.2743797,   46.7304611,  -3.63636374
  21278,   29.1371918,   46.7304611,  -3.63636374
  21279,   20.9380169,   47.5478477,  -3.63636374
  21280,   21.8760319,   47.5478477,  -3.63636374
  21281,   22.8140488,   47.5478477,  -3.63636374
  21282,   23.7520657,   47.5478477,  -3.63636374
  21283,   24.6900826,   47.5478477,  -3.63636374
  21284,   25.6280994,   47.5478477,  -3.63636374
  21285,   26.5024796,   47.5478477,  -3.63636374
  21286,   27.3768597,   47.5478477,  -3.63636374
  21287,   28.2512398,   47.5478477,  -3.63636374
  21288,   29.1256199,   47.5478477,  -3.63636374
  21289,   20.9283752,   48.3652306,  -3.63636374
  21290,   21.8567486,   48.3652306,  -3.63636374
  21291,   22.7851238,   48.3652306,  -3.63636374
  21292,   23.7134991,   48.3652306,  -3.63636374
  21293,   24.6418724,   48.3652306,  -3.63636374
  21294,   25.5702477,   48.3652306,  -3.63636374
  21295,   26.4561977,   48.3652306,  -3.63636374
  21296,   27.3421497,   48.3652306,  -3.63636374
  21297,   28.2280998,   48.3652306,  -3.63636374
  21298,   29.1140499,   48.3652306,  -3.63636374
  21299,   20.9187317,   49.1826172,  -3.63636374
  21300,   21.8374653,   49.1826172,  -3.63636374
  21301,   22.7561989,   49.1826172,  -3.63636374
  21302,   23.6749306,   49.1826172,  -3.63636374
  21303,   24.5936642,   49.1826172,  -3.63636374
  21304,   25.5123959,   49.1826172,  -3.63636374
  21305,   26.4099178,   49.1826172,  -3.63636374
  21306,   27.3074379,   49.1826172,  -3.63636374
  21307,    28.204958,   49.1826172,  -3.63636374
  21308,   29.1024799,   49.1826172,  -3.63636374
  21309,   20.9161739,   20.7484627,   -4.5454545
  21310,   21.8323498,   20.7484627,   -4.5454545
  21311,   22.7485237,   20.7484627,   -4.5454545
  21312,   23.6646996,   20.7484627,   -4.5454545
  21313,   24.5808735,   20.7484627,   -4.5454545
  21314,   25.4970474,   20.7484627,   -4.5454545
  21315,   26.3976383,   20.7484627,   -4.5454545
  21316,   27.2982292,   20.7484627,   -4.5454545
  21317,   28.1988201,   20.7484627,   -4.5454545
  21318,   29.0994091,   20.7484627,   -4.5454545
  21319,   20.9232578,   21.4969234,   -4.5454545
  21320,   21.8465176,   21.4969234,   -4.5454545
  21321,   22.7697754,   21.4969234,   -4.5454545
  21322,   23.6930332,   21.4969234,   -4.5454545
  21323,    24.616293,   21.4969234,   -4.5454545
  21324,   25.5395508,   21.4969234,   -4.5454545
  21325,   26.4316406,   21.4969234,   -4.5454545
  21326,   27.3237305,   21.4969234,   -4.5454545
  21327,   28.2158203,   21.4969234,   -4.5454545
  21328,   29.1079102,   21.4969234,   -4.5454545
  21329,   20.9303417,   22.2453861,   -4.5454545
  21330,   21.8606853,   22.2453861,   -4.5454545
  21331,   22.7910271,   22.2453861,   -4.5454545
  21332,   23.7213688,   22.2453861,   -4.5454545
  21333,   24.6517105,   22.2453861,   -4.5454545
  21334,   25.5820541,   22.2453861,   -4.5454545
  21335,   26.4656429,   22.2453861,   -4.5454545
  21336,   27.3492336,   22.2453861,   -4.5454545
  21337,   28.2328205,   22.2453861,   -4.5454545
  21338,   29.1164112,   22.2453861,   -4.5454545
  21339,   20.9374256,   22.9938488,   -4.5454545
  21340,   21.8748512,   22.9938488,   -4.5454545
  21341,   22.8122787,   22.9938488,   -4.5454545
  21342,   23.7497044,   22.9938488,   -4.5454545
  21343,     24.68713,   22.9938488,   -4.5454545
  21344,   25.6245575,   22.9938488,   -4.5454545
  21345,   26.4996452,   22.9938488,   -4.5454545
  21346,   27.3747349,   22.9938488,   -4.5454545
  21347,   28.2498226,   22.9938488,   -4.5454545
  21348,   29.1249123,   22.9938488,   -4.5454545
  21349,   20.9445095,   23.7423096,   -4.5454545
  21350,    21.889019,   23.7423096,   -4.5454545
  21351,   22.8335285,   23.7423096,   -4.5454545
  21352,   23.7780399,   23.7423096,   -4.5454545
  21353,   24.7225494,   23.7423096,   -4.5454545
  21354,   25.6670609,   23.7423096,   -4.5454545
  21355,   26.5336475,   23.7423096,   -4.5454545
  21356,   27.4002361,   23.7423096,   -4.5454545
  21357,   28.2668228,   23.7423096,   -4.5454545
  21358,   29.1334114,   23.7423096,   -4.5454545
  21359,   20.9515934,   24.4907722,   -4.5454545
  21360,   21.9031868,   24.4907722,   -4.5454545
  21361,   22.8547802,   24.4907722,   -4.5454545
  21362,   23.8063755,   24.4907722,   -4.5454545
  21363,   24.7579689,   24.4907722,   -4.5454545
  21364,   25.7095623,   24.4907722,   -4.5454545
  21365,   26.5676517,   24.4907722,   -4.5454545
  21366,   27.4257393,   24.4907722,   -4.5454545
  21367,   28.2838249,   24.4907722,   -4.5454545
  21368,   29.1419125,   24.4907722,   -4.5454545
  21369,   20.9586773,   25.2392349,   -4.5454545
  21370,   21.9173546,   25.2392349,   -4.5454545
  21371,   22.8760319,   25.2392349,   -4.5454545
  21372,   23.8347111,   25.2392349,   -4.5454545
  21373,   24.7933884,   25.2392349,   -4.5454545
  21374,   25.7520657,   25.2392349,   -4.5454545
  21375,   26.6016521,   25.2392349,   -4.5454545
  21376,   27.4512405,   25.2392349,   -4.5454545
  21377,    28.300827,   25.2392349,   -4.5454545
  21378,   29.1504135,   25.2392349,   -4.5454545
  21379,   20.9586773,   26.0344505,   -4.5454545
  21380,   21.9173546,   26.0344505,   -4.5454545
  21381,   22.8760319,   26.0344505,   -4.5454545
  21382,   23.8347111,   26.0344505,   -4.5454545
  21383,   24.7933884,   26.0344505,   -4.5454545
  21384,   25.7520657,   26.0344505,   -4.5454545
  21385,   26.6016521,   26.0344505,   -4.5454545
  21386,   27.4512405,   26.0344505,   -4.5454545
  21387,    28.300827,   26.0344505,   -4.5454545
  21388,   29.1504135,   26.0344505,   -4.5454545
  21389,   20.9586773,   26.8296642,   -4.5454545
  21390,   21.9173546,   26.8296642,   -4.5454545
  21391,   22.8760319,   26.8296642,   -4.5454545
  21392,   23.8347111,   26.8296642,   -4.5454545
  21393,   24.7933884,   26.8296642,   -4.5454545
  21394,   25.7520657,   26.8296642,   -4.5454545
  21395,   26.6016521,   26.8296642,   -4.5454545
  21396,   27.4512405,   26.8296642,   -4.5454545
  21397,    28.300827,   26.8296642,   -4.5454545
  21398,   29.1504135,   26.8296642,   -4.5454545
  21399,   20.9586773,   27.6248798,   -4.5454545
  21400,   21.9173546,   27.6248798,   -4.5454545
  21401,   22.8760319,   27.6248798,   -4.5454545
  21402,   23.8347111,   27.6248798,   -4.5454545
  21403,   24.7933884,   27.6248798,   -4.5454545
  21404,   25.7520657,   27.6248798,   -4.5454545
  21405,   26.6016521,   27.6248798,   -4.5454545
  21406,   27.4512405,   27.6248798,   -4.5454545
  21407,    28.300827,   27.6248798,   -4.5454545
  21408,   29.1504135,   27.6248798,   -4.5454545
  21409,   20.9586773,   28.4200954,   -4.5454545
  21410,   21.9173546,   28.4200954,   -4.5454545
  21411,   22.8760319,   28.4200954,   -4.5454545
  21412,   23.8347111,   28.4200954,   -4.5454545
  21413,   24.7933884,   28.4200954,   -4.5454545
  21414,   25.7520657,   28.4200954,   -4.5454545
  21415,   26.6016521,   28.4200954,   -4.5454545
  21416,   27.4512405,   28.4200954,   -4.5454545
  21417,    28.300827,   28.4200954,   -4.5454545
  21418,   29.1504135,   28.4200954,   -4.5454545
  21419,   20.9586773,   29.2153111,   -4.5454545
  21420,   21.9173546,   29.2153111,   -4.5454545
  21421,   22.8760319,   29.2153111,   -4.5454545
  21422,   23.8347111,   29.2153111,   -4.5454545
  21423,   24.7933884,   29.2153111,   -4.5454545
  21424,   25.7520657,   29.2153111,   -4.5454545
  21425,   26.6016521,   29.2153111,   -4.5454545
  21426,   27.4512405,   29.2153111,   -4.5454545
  21427,    28.300827,   29.2153111,   -4.5454545
  21428,   29.1504135,   29.2153111,   -4.5454545
  21429,   20.9586773,   30.0105267,   -4.5454545
  21430,   21.9173546,   30.0105267,   -4.5454545
  21431,   22.8760319,   30.0105267,   -4.5454545
  21432,   23.8347111,   30.0105267,   -4.5454545
  21433,   24.7933884,   30.0105267,   -4.5454545
  21434,   25.7520657,   30.0105267,   -4.5454545
  21435,   26.6016521,   30.0105267,   -4.5454545
  21436,   27.4512405,   30.0105267,   -4.5454545
  21437,    28.300827,   30.0105267,   -4.5454545
  21438,   29.1504135,   30.0105267,   -4.5454545
  21439,   20.9586773,   30.8057423,   -4.5454545
  21440,   21.9173546,   30.8057423,   -4.5454545
  21441,   22.8760319,   30.8057423,   -4.5454545
  21442,   23.8347111,   30.8057423,   -4.5454545
  21443,   24.7933884,   30.8057423,   -4.5454545
  21444,   25.7520657,   30.8057423,   -4.5454545
  21445,   26.6016521,   30.8057423,   -4.5454545
  21446,   27.4512405,   30.8057423,   -4.5454545
  21447,    28.300827,   30.8057423,   -4.5454545
  21448,   29.1504135,   30.8057423,   -4.5454545
  21449,   20.9586773,   31.6009579,   -4.5454545
  21450,   21.9173546,   31.6009579,   -4.5454545
  21451,   22.8760319,   31.6009579,   -4.5454545
  21452,   23.8347111,   31.6009579,   -4.5454545
  21453,   24.7933884,   31.6009579,   -4.5454545
  21454,   25.7520657,   31.6009579,   -4.5454545
  21455,   26.6016521,   31.6009579,   -4.5454545
  21456,   27.4512405,   31.6009579,   -4.5454545
  21457,    28.300827,   31.6009579,   -4.5454545
  21458,   29.1504135,   31.6009579,   -4.5454545
  21459,   20.9586773,   32.3961716,   -4.5454545
  21460,   21.9173546,   32.3961716,   -4.5454545
  21461,   22.8760319,   32.3961716,   -4.5454545
  21462,   23.8347111,   32.3961716,   -4.5454545
  21463,   24.7933884,   32.3961716,   -4.5454545
  21464,   25.7520657,   32.3961716,   -4.5454545
  21465,   26.6016521,   32.3961716,   -4.5454545
  21466,   27.4512405,   32.3961716,   -4.5454545
  21467,    28.300827,   32.3961716,   -4.5454545
  21468,   29.1504135,   32.3961716,   -4.5454545
  21469,   20.9586773,   33.1913872,   -4.5454545
  21470,   21.9173546,   33.1913872,   -4.5454545
  21471,   22.8760319,   33.1913872,   -4.5454545
  21472,   23.8347111,   33.1913872,   -4.5454545
  21473,   24.7933884,   33.1913872,   -4.5454545
  21474,   25.7520657,   33.1913872,   -4.5454545
  21475,   26.6016521,   33.1913872,   -4.5454545
  21476,   27.4512405,   33.1913872,   -4.5454545
  21477,    28.300827,   33.1913872,   -4.5454545
  21478,   29.1504135,   33.1913872,   -4.5454545
  21479,   20.9586773,   33.9866028,   -4.5454545
  21480,   21.9173546,   33.9866028,   -4.5454545
  21481,   22.8760319,   33.9866028,   -4.5454545
  21482,   23.8347111,   33.9866028,   -4.5454545
  21483,   24.7933884,   33.9866028,   -4.5454545
  21484,   25.7520657,   33.9866028,   -4.5454545
  21485,   26.6016521,   33.9866028,   -4.5454545
  21486,   27.4512405,   33.9866028,   -4.5454545
  21487,    28.300827,   33.9866028,   -4.5454545
  21488,   29.1504135,   33.9866028,   -4.5454545
  21489,   20.9586773,   34.7818184,   -4.5454545
  21490,   21.9173546,   34.7818184,   -4.5454545
  21491,   22.8760319,   34.7818184,   -4.5454545
  21492,   23.8347111,   34.7818184,   -4.5454545
  21493,   24.7933884,   34.7818184,   -4.5454545
  21494,   25.7520657,   34.7818184,   -4.5454545
  21495,   26.6016521,   34.7818184,   -4.5454545
  21496,   27.4512405,   34.7818184,   -4.5454545
  21497,    28.300827,   34.7818184,   -4.5454545
  21498,   29.1504135,   34.7818184,   -4.5454545
  21499,   20.9586773,    35.577034,   -4.5454545
  21500,   21.9173546,    35.577034,   -4.5454545
  21501,   22.8760319,    35.577034,   -4.5454545
  21502,   23.8347111,    35.577034,   -4.5454545
  21503,   24.7933884,    35.577034,   -4.5454545
  21504,   25.7520657,    35.577034,   -4.5454545
  21505,   26.6016521,    35.577034,   -4.5454545
  21506,   27.4512405,    35.577034,   -4.5454545
  21507,    28.300827,    35.577034,   -4.5454545
  21508,   29.1504135,    35.577034,   -4.5454545
  21509,   20.9586773,   36.3722496,   -4.5454545
  21510,   21.9173546,   36.3722496,   -4.5454545
  21511,   22.8760319,   36.3722496,   -4.5454545
  21512,   23.8347111,   36.3722496,   -4.5454545
  21513,   24.7933884,   36.3722496,   -4.5454545
  21514,   25.7520657,   36.3722496,   -4.5454545
  21515,   26.6016521,   36.3722496,   -4.5454545
  21516,   27.4512405,   36.3722496,   -4.5454545
  21517,    28.300827,   36.3722496,   -4.5454545
  21518,   29.1504135,   36.3722496,   -4.5454545
  21519,   20.9586773,   37.1674652,   -4.5454545
  21520,   21.9173546,   37.1674652,   -4.5454545
  21521,   22.8760319,   37.1674652,   -4.5454545
  21522,   23.8347111,   37.1674652,   -4.5454545
  21523,   24.7933884,   37.1674652,   -4.5454545
  21524,   25.7520657,   37.1674652,   -4.5454545
  21525,   26.6016521,   37.1674652,   -4.5454545
  21526,   27.4512405,   37.1674652,   -4.5454545
  21527,    28.300827,   37.1674652,   -4.5454545
  21528,   29.1504135,   37.1674652,   -4.5454545
  21529,   20.9586773,   37.9626808,   -4.5454545
  21530,   21.9173546,   37.9626808,   -4.5454545
  21531,   22.8760319,   37.9626808,   -4.5454545
  21532,   23.8347111,   37.9626808,   -4.5454545
  21533,   24.7933884,   37.9626808,   -4.5454545
  21534,   25.7520657,   37.9626808,   -4.5454545
  21535,   26.6016521,   37.9626808,   -4.5454545
  21536,   27.4512405,   37.9626808,   -4.5454545
  21537,    28.300827,   37.9626808,   -4.5454545
  21538,   29.1504135,   37.9626808,   -4.5454545
  21539,   20.9586773,   38.7578964,   -4.5454545
  21540,   21.9173546,   38.7578964,   -4.5454545
  21541,   22.8760319,   38.7578964,   -4.5454545
  21542,   23.8347111,   38.7578964,   -4.5454545
  21543,   24.7933884,   38.7578964,   -4.5454545
  21544,   25.7520657,   38.7578964,   -4.5454545
  21545,   26.6016521,   38.7578964,   -4.5454545
  21546,   27.4512405,   38.7578964,   -4.5454545
  21547,    28.300827,   38.7578964,   -4.5454545
  21548,   29.1504135,   38.7578964,   -4.5454545
  21549,   20.9586773,   39.5531082,   -4.5454545
  21550,   21.9173546,   39.5531082,   -4.5454545
  21551,   22.8760319,   39.5531082,   -4.5454545
  21552,   23.8347111,   39.5531082,   -4.5454545
  21553,   24.7933884,   39.5531082,   -4.5454545
  21554,   25.7520657,   39.5531082,   -4.5454545
  21555,   26.6016521,   39.5531082,   -4.5454545
  21556,   27.4512405,   39.5531082,   -4.5454545
  21557,    28.300827,   39.5531082,   -4.5454545
  21558,   29.1504135,   39.5531082,   -4.5454545
  21559,   20.9586773,   40.3483238,   -4.5454545
  21560,   21.9173546,   40.3483238,   -4.5454545
  21561,   22.8760319,   40.3483238,   -4.5454545
  21562,   23.8347111,   40.3483238,   -4.5454545
  21563,   24.7933884,   40.3483238,   -4.5454545
  21564,   25.7520657,   40.3483238,   -4.5454545
  21565,   26.6016521,   40.3483238,   -4.5454545
  21566,   27.4512405,   40.3483238,   -4.5454545
  21567,    28.300827,   40.3483238,   -4.5454545
  21568,   29.1504135,   40.3483238,   -4.5454545
  21569,   20.9586773,   41.1435394,   -4.5454545
  21570,   21.9173546,   41.1435394,   -4.5454545
  21571,   22.8760319,   41.1435394,   -4.5454545
  21572,   23.8347111,   41.1435394,   -4.5454545
  21573,   24.7933884,   41.1435394,   -4.5454545
  21574,   25.7520657,   41.1435394,   -4.5454545
  21575,   26.6016521,   41.1435394,   -4.5454545
  21576,   27.4512405,   41.1435394,   -4.5454545
  21577,    28.300827,   41.1435394,   -4.5454545
  21578,   29.1504135,   41.1435394,   -4.5454545
  21579,   20.9586773,    41.938755,   -4.5454545
  21580,   21.9173546,    41.938755,   -4.5454545
  21581,   22.8760319,    41.938755,   -4.5454545
  21582,   23.8347111,    41.938755,   -4.5454545
  21583,   24.7933884,    41.938755,   -4.5454545
  21584,   25.7520657,    41.938755,   -4.5454545
  21585,   26.6016521,    41.938755,   -4.5454545
  21586,   27.4512405,    41.938755,   -4.5454545
  21587,    28.300827,    41.938755,   -4.5454545
  21588,   29.1504135,    41.938755,   -4.5454545
  21589,   20.9586773,   42.7339706,   -4.5454545
  21590,   21.9173546,   42.7339706,   -4.5454545
  21591,   22.8760319,   42.7339706,   -4.5454545
  21592,   23.8347111,   42.7339706,   -4.5454545
  21593,   24.7933884,   42.7339706,   -4.5454545
  21594,   25.7520657,   42.7339706,   -4.5454545
  21595,   26.6016521,   42.7339706,   -4.5454545
  21596,   27.4512405,   42.7339706,   -4.5454545
  21597,    28.300827,   42.7339706,   -4.5454545
  21598,   29.1504135,   42.7339706,   -4.5454545
  21599,   20.9586773,   43.5291862,   -4.5454545
  21600,   21.9173546,   43.5291862,   -4.5454545
  21601,   22.8760319,   43.5291862,   -4.5454545
  21602,   23.8347111,   43.5291862,   -4.5454545
  21603,   24.7933884,   43.5291862,   -4.5454545
  21604,   25.7520657,   43.5291862,   -4.5454545
  21605,   26.6016521,   43.5291862,   -4.5454545
  21606,   27.4512405,   43.5291862,   -4.5454545
  21607,    28.300827,   43.5291862,   -4.5454545
  21608,   29.1504135,   43.5291862,   -4.5454545
  21609,   20.9586773,   44.3244019,   -4.5454545
  21610,   21.9173546,   44.3244019,   -4.5454545
  21611,   22.8760319,   44.3244019,   -4.5454545
  21612,   23.8347111,   44.3244019,   -4.5454545
  21613,   24.7933884,   44.3244019,   -4.5454545
  21614,   25.7520657,   44.3244019,   -4.5454545
  21615,   26.6016521,   44.3244019,   -4.5454545
  21616,   27.4512405,   44.3244019,   -4.5454545
  21617,    28.300827,   44.3244019,   -4.5454545
  21618,   29.1504135,   44.3244019,   -4.5454545
  21619,   20.9586773,   45.1196175,   -4.5454545
  21620,   21.9173546,   45.1196175,   -4.5454545
  21621,   22.8760319,   45.1196175,   -4.5454545
  21622,   23.8347111,   45.1196175,   -4.5454545
  21623,   24.7933884,   45.1196175,   -4.5454545
  21624,   25.7520657,   45.1196175,   -4.5454545
  21625,   26.6016521,   45.1196175,   -4.5454545
  21626,   27.4512405,   45.1196175,   -4.5454545
  21627,    28.300827,   45.1196175,   -4.5454545
  21628,   29.1504135,   45.1196175,   -4.5454545
  21629,   20.9504128,   45.9330139,   -4.5454545
  21630,   21.9008255,   45.9330139,   -4.5454545
  21631,   22.8512402,   45.9330139,   -4.5454545
  21632,   23.8016529,   45.9330139,   -4.5454545
  21633,   24.7520657,   45.9330139,   -4.5454545
  21634,   25.7024784,   45.9330139,   -4.5454545
  21635,   26.5619831,   45.9330139,   -4.5454545
  21636,   27.4214878,   45.9330139,   -4.5454545
  21637,   28.2809906,   45.9330139,   -4.5454545
  21638,   29.1404953,   45.9330139,   -4.5454545
  21639,   20.9421482,   46.7464104,   -4.5454545
  21640,   21.8842983,   46.7464104,   -4.5454545
  21641,   22.8264446,   46.7464104,   -4.5454545
  21642,   23.7685947,   46.7464104,   -4.5454545
  21643,    24.710743,   46.7464104,   -4.5454545
  21644,   25.6528931,   46.7464104,   -4.5454545
  21645,   26.5223141,   46.7464104,   -4.5454545
  21646,    27.391737,   46.7464104,   -4.5454545
  21647,   28.2611561,   46.7464104,   -4.5454545
  21648,    29.130579,   46.7464104,   -4.5454545
  21649,   20.9338837,   47.5598068,   -4.5454545
  21650,   21.8677673,   47.5598068,   -4.5454545
  21651,   22.8016529,   47.5598068,   -4.5454545
  21652,   23.7355366,   47.5598068,   -4.5454545
  21653,   24.6694221,   47.5598068,   -4.5454545
  21654,   25.6033058,   47.5598068,   -4.5454545
  21655,    26.482645,   47.5598068,   -4.5454545
  21656,   27.3619843,   47.5598068,   -4.5454545
  21657,   28.2413216,   47.5598068,   -4.5454545
  21658,   29.1206608,   47.5598068,   -4.5454545
  21659,   20.9256191,   48.3732071,   -4.5454545
  21660,   21.8512402,   48.3732071,   -4.5454545
  21661,   22.7768593,   48.3732071,   -4.5454545
  21662,   23.7024803,   48.3732071,   -4.5454545
  21663,   24.6280994,   48.3732071,   -4.5454545
  21664,   25.5537186,   48.3732071,   -4.5454545
  21665,   26.4429741,   48.3732071,   -4.5454545
  21666,   27.3322315,   48.3732071,   -4.5454545
  21667,    28.221487,   48.3732071,   -4.5454545
  21668,   29.1107445,   48.3732071,   -4.5454545
  21669,   20.9173546,   49.1866035,   -4.5454545
  21670,   21.8347111,   49.1866035,   -4.5454545
  21671,   22.7520657,   49.1866035,   -4.5454545
  21672,   23.6694221,   49.1866035,   -4.5454545
  21673,   24.5867767,   49.1866035,   -4.5454545
  21674,   25.5041313,   49.1866035,   -4.5454545
  21675,   26.4033051,   49.1866035,   -4.5454545
  21676,   27.3024788,   49.1866035,   -4.5454545
  21677,   28.2016525,   49.1866035,   -4.5454545
  21678,   29.1008263,   49.1866035,   -4.5454545
  21679,   20.9149933,   20.7552967,   -5.4545455
  21680,   21.8299885,   20.7552967,   -5.4545455
  21681,   22.7449818,   20.7552967,   -5.4545455
  21682,    23.659977,   20.7552967,   -5.4545455
  21683,   24.5749702,   20.7552967,   -5.4545455
  21684,   25.4899654,   20.7552967,   -5.4545455
  21685,   26.3919716,   20.7552967,   -5.4545455
  21686,   27.2939796,   20.7552967,   -5.4545455
  21687,   28.1959858,   20.7552967,   -5.4545455
  21688,   29.0979939,   20.7552967,   -5.4545455
  21689,   20.9208965,   21.5105953,   -5.4545455
  21690,    21.841795,   21.5105953,   -5.4545455
  21691,   22.7626915,   21.5105953,   -5.4545455
  21692,   23.6835899,   21.5105953,   -5.4545455
  21693,   24.6044865,   21.5105953,   -5.4545455
  21694,   25.5253849,   21.5105953,   -5.4545455
  21695,   26.4203072,   21.5105953,   -5.4545455
  21696,   27.3152313,   21.5105953,   -5.4545455
  21697,   28.2101536,   21.5105953,   -5.4545455
  21698,   29.1050777,   21.5105953,   -5.4545455
  21699,   20.9267998,    22.265892,   -5.4545455
  21700,   21.8536015,    22.265892,   -5.4545455
  21701,   22.7804012,    22.265892,   -5.4545455
  21702,   23.7072029,    22.265892,   -5.4545455
  21703,   24.6340027,    22.265892,   -5.4545455
  21704,   25.5608044,    22.265892,   -5.4545455
  21705,   26.4486427,    22.265892,   -5.4545455
  21706,   27.3364811,    22.265892,   -5.4545455
  21707,   28.2243214,    22.265892,   -5.4545455
  21708,   29.1121616,    22.265892,   -5.4545455
  21709,    20.932703,   23.0211887,   -5.4545455
  21710,   21.8654079,   23.0211887,   -5.4545455
  21711,    22.798111,   23.0211887,   -5.4545455
  21712,   23.7308159,   23.0211887,   -5.4545455
  21713,   24.6635189,   23.0211887,   -5.4545455
  21714,   25.5962219,   23.0211887,   -5.4545455
  21715,   26.4769783,   23.0211887,   -5.4545455
  21716,   27.3577328,   23.0211887,   -5.4545455
  21717,   28.2384892,   23.0211887,   -5.4545455
  21718,   29.1192436,   23.0211887,   -5.4545455
  21719,   20.9386063,   23.7764874,   -5.4545455
  21720,   21.8772144,   23.7764874,   -5.4545455
  21721,   22.8158207,   23.7764874,   -5.4545455
  21722,   23.7544289,   23.7764874,   -5.4545455
  21723,   24.6930351,   23.7764874,   -5.4545455
  21724,   25.6316414,   23.7764874,   -5.4545455
  21725,   26.5053139,   23.7764874,   -5.4545455
  21726,   27.3789845,   23.7764874,   -5.4545455
  21727,   28.2526569,   23.7764874,   -5.4545455
  21728,   29.1263294,   23.7764874,   -5.4545455
  21729,   20.9445095,   24.5317841,   -5.4545455
  21730,   21.8890209,   24.5317841,   -5.4545455
  21731,   22.8335304,   24.5317841,   -5.4545455
  21732,   23.7780399,   24.5317841,   -5.4545455
  21733,   24.7225494,   24.5317841,   -5.4545455
  21734,   25.6670609,   24.5317841,   -5.4545455
  21735,   26.5336475,   24.5317841,   -5.4545455
  21736,   27.4002361,   24.5317841,   -5.4545455
  21737,   28.2668247,   24.5317841,   -5.4545455
  21738,   29.1334133,   24.5317841,   -5.4545455
  21739,   20.9504128,   25.2870808,   -5.4545455
  21740,   21.9008274,   25.2870808,   -5.4545455
  21741,   22.8512402,   25.2870808,   -5.4545455
  21742,   23.8016529,   25.2870808,   -5.4545455
  21743,   24.7520657,   25.2870808,   -5.4545455
  21744,   25.7024803,   25.2870808,   -5.4545455
  21745,   26.5619831,   25.2870808,   -5.4545455
  21746,   27.4214878,   25.2870808,   -5.4545455
  21747,   28.2809906,   25.2870808,   -5.4545455
  21748,   29.1404972,   25.2870808,   -5.4545455
  21749,   20.9504128,   26.0813389,   -5.4545455
  21750,   21.9008274,   26.0813389,   -5.4545455
  21751,   22.8512402,   26.0813389,   -5.4545455
  21752,   23.8016529,   26.0813389,   -5.4545455
  21753,   24.7520657,   26.0813389,   -5.4545455
  21754,   25.7024803,   26.0813389,   -5.4545455
  21755,   26.5619831,   26.0813389,   -5.4545455
  21756,   27.4214878,   26.0813389,   -5.4545455
  21757,   28.2809906,   26.0813389,   -5.4545455
  21758,   29.1404972,   26.0813389,   -5.4545455
  21759,   20.9504128,   26.8755989,   -5.4545455
  21760,   21.9008274,   26.8755989,   -5.4545455
  21761,   22.8512402,   26.8755989,   -5.4545455
  21762,   23.8016529,   26.8755989,   -5.4545455
  21763,   24.7520657,   26.8755989,   -5.4545455
  21764,   25.7024803,   26.8755989,   -5.4545455
  21765,   26.5619831,   26.8755989,   -5.4545455
  21766,   27.4214878,   26.8755989,   -5.4545455
  21767,   28.2809906,   26.8755989,   -5.4545455
  21768,   29.1404972,   26.8755989,   -5.4545455
  21769,   20.9504128,    27.669857,   -5.4545455
  21770,   21.9008274,    27.669857,   -5.4545455
  21771,   22.8512402,    27.669857,   -5.4545455
  21772,   23.8016529,    27.669857,   -5.4545455
  21773,   24.7520657,    27.669857,   -5.4545455
  21774,   25.7024803,    27.669857,   -5.4545455
  21775,   26.5619831,    27.669857,   -5.4545455
  21776,   27.4214878,    27.669857,   -5.4545455
  21777,   28.2809906,    27.669857,   -5.4545455
  21778,   29.1404972,    27.669857,   -5.4545455
  21779,   20.9504128,   28.4641151,   -5.4545455
  21780,   21.9008274,   28.4641151,   -5.4545455
  21781,   22.8512402,   28.4641151,   -5.4545455
  21782,   23.8016529,   28.4641151,   -5.4545455
  21783,   24.7520657,   28.4641151,   -5.4545455
  21784,   25.7024803,   28.4641151,   -5.4545455
  21785,   26.5619831,   28.4641151,   -5.4545455
  21786,   27.4214878,   28.4641151,   -5.4545455
  21787,   28.2809906,   28.4641151,   -5.4545455
  21788,   29.1404972,   28.4641151,   -5.4545455
  21789,   20.9504128,   29.2583733,   -5.4545455
  21790,   21.9008274,   29.2583733,   -5.4545455
  21791,   22.8512402,   29.2583733,   -5.4545455
  21792,   23.8016529,   29.2583733,   -5.4545455
  21793,   24.7520657,   29.2583733,   -5.4545455
  21794,   25.7024803,   29.2583733,   -5.4545455
  21795,   26.5619831,   29.2583733,   -5.4545455
  21796,   27.4214878,   29.2583733,   -5.4545455
  21797,   28.2809906,   29.2583733,   -5.4545455
  21798,   29.1404972,   29.2583733,   -5.4545455
  21799,   20.9504128,   30.0526314,   -5.4545455
  21800,   21.9008274,   30.0526314,   -5.4545455
  21801,   22.8512402,   30.0526314,   -5.4545455
  21802,   23.8016529,   30.0526314,   -5.4545455
  21803,   24.7520657,   30.0526314,   -5.4545455
  21804,   25.7024803,   30.0526314,   -5.4545455
  21805,   26.5619831,   30.0526314,   -5.4545455
  21806,   27.4214878,   30.0526314,   -5.4545455
  21807,   28.2809906,   30.0526314,   -5.4545455
  21808,   29.1404972,   30.0526314,   -5.4545455
  21809,   20.9504128,   30.8468895,   -5.4545455
  21810,   21.9008274,   30.8468895,   -5.4545455
  21811,   22.8512402,   30.8468895,   -5.4545455
  21812,   23.8016529,   30.8468895,   -5.4545455
  21813,   24.7520657,   30.8468895,   -5.4545455
  21814,   25.7024803,   30.8468895,   -5.4545455
  21815,   26.5619831,   30.8468895,   -5.4545455
  21816,   27.4214878,   30.8468895,   -5.4545455
  21817,   28.2809906,   30.8468895,   -5.4545455
  21818,   29.1404972,   30.8468895,   -5.4545455
  21819,   20.9504128,   31.6411476,   -5.4545455
  21820,   21.9008274,   31.6411476,   -5.4545455
  21821,   22.8512402,   31.6411476,   -5.4545455
  21822,   23.8016529,   31.6411476,   -5.4545455
  21823,   24.7520657,   31.6411476,   -5.4545455
  21824,   25.7024803,   31.6411476,   -5.4545455
  21825,   26.5619831,   31.6411476,   -5.4545455
  21826,   27.4214878,   31.6411476,   -5.4545455
  21827,   28.2809906,   31.6411476,   -5.4545455
  21828,   29.1404972,   31.6411476,   -5.4545455
  21829,   20.9504128,   32.4354057,   -5.4545455
  21830,   21.9008274,   32.4354057,   -5.4545455
  21831,   22.8512402,   32.4354057,   -5.4545455
  21832,   23.8016529,   32.4354057,   -5.4545455
  21833,   24.7520657,   32.4354057,   -5.4545455
  21834,   25.7024803,   32.4354057,   -5.4545455
  21835,   26.5619831,   32.4354057,   -5.4545455
  21836,   27.4214878,   32.4354057,   -5.4545455
  21837,   28.2809906,   32.4354057,   -5.4545455
  21838,   29.1404972,   32.4354057,   -5.4545455
  21839,   20.9504128,   33.2296638,   -5.4545455
  21840,   21.9008274,   33.2296638,   -5.4545455
  21841,   22.8512402,   33.2296638,   -5.4545455
  21842,   23.8016529,   33.2296638,   -5.4545455
  21843,   24.7520657,   33.2296638,   -5.4545455
  21844,   25.7024803,   33.2296638,   -5.4545455
  21845,   26.5619831,   33.2296638,   -5.4545455
  21846,   27.4214878,   33.2296638,   -5.4545455
  21847,   28.2809906,   33.2296638,   -5.4545455
  21848,   29.1404972,   33.2296638,   -5.4545455
  21849,   20.9504128,    34.023922,   -5.4545455
  21850,   21.9008274,    34.023922,   -5.4545455
  21851,   22.8512402,    34.023922,   -5.4545455
  21852,   23.8016529,    34.023922,   -5.4545455
  21853,   24.7520657,    34.023922,   -5.4545455
  21854,   25.7024803,    34.023922,   -5.4545455
  21855,   26.5619831,    34.023922,   -5.4545455
  21856,   27.4214878,    34.023922,   -5.4545455
  21857,   28.2809906,    34.023922,   -5.4545455
  21858,   29.1404972,    34.023922,   -5.4545455
  21859,   20.9504128,   34.8181801,   -5.4545455
  21860,   21.9008274,   34.8181801,   -5.4545455
  21861,   22.8512402,   34.8181801,   -5.4545455
  21862,   23.8016529,   34.8181801,   -5.4545455
  21863,   24.7520657,   34.8181801,   -5.4545455
  21864,   25.7024803,   34.8181801,   -5.4545455
  21865,   26.5619831,   34.8181801,   -5.4545455
  21866,   27.4214878,   34.8181801,   -5.4545455
  21867,   28.2809906,   34.8181801,   -5.4545455
  21868,   29.1404972,   34.8181801,   -5.4545455
  21869,   20.9504128,    35.612442,   -5.4545455
  21870,   21.9008274,    35.612442,   -5.4545455
  21871,   22.8512402,    35.612442,   -5.4545455
  21872,   23.8016529,    35.612442,   -5.4545455
  21873,   24.7520657,    35.612442,   -5.4545455
  21874,   25.7024803,    35.612442,   -5.4545455
  21875,   26.5619831,    35.612442,   -5.4545455
  21876,   27.4214878,    35.612442,   -5.4545455
  21877,   28.2809906,    35.612442,   -5.4545455
  21878,   29.1404972,    35.612442,   -5.4545455
  21879,   20.9504128,   36.4067001,   -5.4545455
  21880,   21.9008274,   36.4067001,   -5.4545455
  21881,   22.8512402,   36.4067001,   -5.4545455
  21882,   23.8016529,   36.4067001,   -5.4545455
  21883,   24.7520657,   36.4067001,   -5.4545455
  21884,   25.7024803,   36.4067001,   -5.4545455
  21885,   26.5619831,   36.4067001,   -5.4545455
  21886,   27.4214878,   36.4067001,   -5.4545455
  21887,   28.2809906,   36.4067001,   -5.4545455
  21888,   29.1404972,   36.4067001,   -5.4545455
  21889,   20.9504128,   37.2009583,   -5.4545455
  21890,   21.9008274,   37.2009583,   -5.4545455
  21891,   22.8512402,   37.2009583,   -5.4545455
  21892,   23.8016529,   37.2009583,   -5.4545455
  21893,   24.7520657,   37.2009583,   -5.4545455
  21894,   25.7024803,   37.2009583,   -5.4545455
  21895,   26.5619831,   37.2009583,   -5.4545455
  21896,   27.4214878,   37.2009583,   -5.4545455
  21897,   28.2809906,   37.2009583,   -5.4545455
  21898,   29.1404972,   37.2009583,   -5.4545455
  21899,   20.9504128,   37.9952164,   -5.4545455
  21900,   21.9008274,   37.9952164,   -5.4545455
  21901,   22.8512402,   37.9952164,   -5.4545455
  21902,   23.8016529,   37.9952164,   -5.4545455
  21903,   24.7520657,   37.9952164,   -5.4545455
  21904,   25.7024803,   37.9952164,   -5.4545455
  21905,   26.5619831,   37.9952164,   -5.4545455
  21906,   27.4214878,   37.9952164,   -5.4545455
  21907,   28.2809906,   37.9952164,   -5.4545455
  21908,   29.1404972,   37.9952164,   -5.4545455
  21909,   20.9504128,   38.7894745,   -5.4545455
  21910,   21.9008274,   38.7894745,   -5.4545455
  21911,   22.8512402,   38.7894745,   -5.4545455
  21912,   23.8016529,   38.7894745,   -5.4545455
  21913,   24.7520657,   38.7894745,   -5.4545455
  21914,   25.7024803,   38.7894745,   -5.4545455
  21915,   26.5619831,   38.7894745,   -5.4545455
  21916,   27.4214878,   38.7894745,   -5.4545455
  21917,   28.2809906,   38.7894745,   -5.4545455
  21918,   29.1404972,   38.7894745,   -5.4545455
  21919,   20.9504128,   39.5837326,   -5.4545455
  21920,   21.9008274,   39.5837326,   -5.4545455
  21921,   22.8512402,   39.5837326,   -5.4545455
  21922,   23.8016529,   39.5837326,   -5.4545455
  21923,   24.7520657,   39.5837326,   -5.4545455
  21924,   25.7024803,   39.5837326,   -5.4545455
  21925,   26.5619831,   39.5837326,   -5.4545455
  21926,   27.4214878,   39.5837326,   -5.4545455
  21927,   28.2809906,   39.5837326,   -5.4545455
  21928,   29.1404972,   39.5837326,   -5.4545455
  21929,   20.9504128,   40.3779907,   -5.4545455
  21930,   21.9008274,   40.3779907,   -5.4545455
  21931,   22.8512402,   40.3779907,   -5.4545455
  21932,   23.8016529,   40.3779907,   -5.4545455
  21933,   24.7520657,   40.3779907,   -5.4545455
  21934,   25.7024803,   40.3779907,   -5.4545455
  21935,   26.5619831,   40.3779907,   -5.4545455
  21936,   27.4214878,   40.3779907,   -5.4545455
  21937,   28.2809906,   40.3779907,   -5.4545455
  21938,   29.1404972,   40.3779907,   -5.4545455
  21939,   20.9504128,   41.1722488,   -5.4545455
  21940,   21.9008274,   41.1722488,   -5.4545455
  21941,   22.8512402,   41.1722488,   -5.4545455
  21942,   23.8016529,   41.1722488,   -5.4545455
  21943,   24.7520657,   41.1722488,   -5.4545455
  21944,   25.7024803,   41.1722488,   -5.4545455
  21945,   26.5619831,   41.1722488,   -5.4545455
  21946,   27.4214878,   41.1722488,   -5.4545455
  21947,   28.2809906,   41.1722488,   -5.4545455
  21948,   29.1404972,   41.1722488,   -5.4545455
  21949,   20.9504128,    41.966507,   -5.4545455
  21950,   21.9008274,    41.966507,   -5.4545455
  21951,   22.8512402,    41.966507,   -5.4545455
  21952,   23.8016529,    41.966507,   -5.4545455
  21953,   24.7520657,    41.966507,   -5.4545455
  21954,   25.7024803,    41.966507,   -5.4545455
  21955,   26.5619831,    41.966507,   -5.4545455
  21956,   27.4214878,    41.966507,   -5.4545455
  21957,   28.2809906,    41.966507,   -5.4545455
  21958,   29.1404972,    41.966507,   -5.4545455
  21959,   20.9504128,   42.7607651,   -5.4545455
  21960,   21.9008274,   42.7607651,   -5.4545455
  21961,   22.8512402,   42.7607651,   -5.4545455
  21962,   23.8016529,   42.7607651,   -5.4545455
  21963,   24.7520657,   42.7607651,   -5.4545455
  21964,   25.7024803,   42.7607651,   -5.4545455
  21965,   26.5619831,   42.7607651,   -5.4545455
  21966,   27.4214878,   42.7607651,   -5.4545455
  21967,   28.2809906,   42.7607651,   -5.4545455
  21968,   29.1404972,   42.7607651,   -5.4545455
  21969,   20.9504128,   43.5550232,   -5.4545455
  21970,   21.9008274,   43.5550232,   -5.4545455
  21971,   22.8512402,   43.5550232,   -5.4545455
  21972,   23.8016529,   43.5550232,   -5.4545455
  21973,   24.7520657,   43.5550232,   -5.4545455
  21974,   25.7024803,   43.5550232,   -5.4545455
  21975,   26.5619831,   43.5550232,   -5.4545455
  21976,   27.4214878,   43.5550232,   -5.4545455
  21977,   28.2809906,   43.5550232,   -5.4545455
  21978,   29.1404972,   43.5550232,   -5.4545455
  21979,   20.9504128,   44.3492813,   -5.4545455
  21980,   21.9008274,   44.3492813,   -5.4545455
  21981,   22.8512402,   44.3492813,   -5.4545455
  21982,   23.8016529,   44.3492813,   -5.4545455
  21983,   24.7520657,   44.3492813,   -5.4545455
  21984,   25.7024803,   44.3492813,   -5.4545455
  21985,   26.5619831,   44.3492813,   -5.4545455
  21986,   27.4214878,   44.3492813,   -5.4545455
  21987,   28.2809906,   44.3492813,   -5.4545455
  21988,   29.1404972,   44.3492813,   -5.4545455
  21989,   20.9504128,   45.1435394,   -5.4545455
  21990,   21.9008274,   45.1435394,   -5.4545455
  21991,   22.8512402,   45.1435394,   -5.4545455
  21992,   23.8016529,   45.1435394,   -5.4545455
  21993,   24.7520657,   45.1435394,   -5.4545455
  21994,   25.7024803,   45.1435394,   -5.4545455
