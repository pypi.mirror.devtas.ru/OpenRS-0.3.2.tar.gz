  21995,   26.5619831,   45.1435394,   -5.4545455
  21996,   27.4214878,   45.1435394,   -5.4545455
  21997,   28.2809906,   45.1435394,   -5.4545455
  21998,   29.1404972,   45.1435394,   -5.4545455
  21999,   20.9435253,   45.9529495,   -5.4545455
  22000,   21.8870525,   45.9529495,   -5.4545455
  22001,   22.8305779,   45.9529495,   -5.4545455
  22002,   23.7741051,   45.9529495,   -5.4545455
  22003,   24.7176304,   45.9529495,   -5.4545455
  22004,   25.6611576,   45.9529495,   -5.4545455
  22005,   26.5289249,   45.9529495,   -5.4545455
  22006,   27.3966942,   45.9529495,   -5.4545455
  22007,   28.2644634,   45.9529495,   -5.4545455
  22008,   29.1322327,   45.9529495,   -5.4545455
  22009,   20.9366379,   46.7623596,   -5.4545455
  22010,   21.8732777,   46.7623596,   -5.4545455
  22011,   22.8099174,   46.7623596,   -5.4545455
  22012,   23.7465572,   46.7623596,   -5.4545455
  22013,   24.6831951,   46.7623596,   -5.4545455
  22014,   25.6198349,   46.7623596,   -5.4545455
  22015,   26.4958668,   46.7623596,   -5.4545455
  22016,   27.3719006,   46.7623596,   -5.4545455
  22017,   28.2479343,   46.7623596,   -5.4545455
  22018,   29.1239681,   46.7623596,   -5.4545455
  22019,   20.9297523,   47.5717697,   -5.4545455
  22020,   21.8595047,   47.5717697,   -5.4545455
  22021,   22.7892551,   47.5717697,   -5.4545455
  22022,   23.7190094,   47.5717697,   -5.4545455
  22023,   24.6487598,   47.5717697,   -5.4545455
  22024,   25.5785122,   47.5717697,   -5.4545455
  22025,   26.4628086,   47.5717697,   -5.4545455
  22026,   27.3471069,   47.5717697,   -5.4545455
  22027,   28.2314053,   47.5717697,   -5.4545455
  22028,   29.1157036,   47.5717697,   -5.4545455
  22029,   20.9228649,   48.3811798,   -5.4545455
  22030,   21.8457298,   48.3811798,   -5.4545455
  22031,   22.7685947,   48.3811798,   -5.4545455
  22032,   23.6914597,   48.3811798,   -5.4545455
  22033,   24.6143246,   48.3811798,   -5.4545455
  22034,   25.5371914,   48.3811798,   -5.4545455
  22035,   26.4297523,   48.3811798,   -5.4545455
  22036,   27.3223152,   48.3811798,   -5.4545455
  22037,   28.2148762,   48.3811798,   -5.4545455
  22038,    29.107439,   48.3811798,   -5.4545455
  22039,   20.9159775,   49.1905899,   -5.4545455
  22040,    21.831955,   49.1905899,   -5.4545455
  22041,   22.7479343,   49.1905899,   -5.4545455
  22042,   23.6639118,   49.1905899,   -5.4545455
  22043,   24.5798893,   49.1905899,   -5.4545455
  22044,   25.4958687,   49.1905899,   -5.4545455
  22045,   26.3966942,   49.1905899,   -5.4545455
  22046,   27.2975216,   49.1905899,   -5.4545455
  22047,   28.1983471,   49.1905899,   -5.4545455
  22048,   29.0991745,   49.1905899,   -5.4545455
  22049,   20.9138126,   20.7621326,  -6.36363649
  22050,   21.8276272,   20.7621326,  -6.36363649
  22051,   22.7414398,   20.7621326,  -6.36363649
  22052,   23.6552544,   20.7621326,  -6.36363649
  22053,    24.569067,   20.7621326,  -6.36363649
  22054,   25.4828815,   20.7621326,  -6.36363649
  22055,   26.3863049,   20.7621326,  -6.36363649
  22056,   27.2897282,   20.7621326,  -6.36363649
  22057,   28.1931534,   20.7621326,  -6.36363649
  22058,   29.0965767,   20.7621326,  -6.36363649
  22059,   20.9185352,   21.5242653,  -6.36363649
  22060,   21.8370724,   21.5242653,  -6.36363649
  22061,   22.7556076,   21.5242653,  -6.36363649
  22062,   23.6741447,   21.5242653,  -6.36363649
  22063,     24.59268,   21.5242653,  -6.36363649
  22064,   25.5112171,   21.5242653,  -6.36363649
  22065,   26.4089718,   21.5242653,  -6.36363649
  22066,   27.3067303,   21.5242653,  -6.36363649
  22067,   28.2044868,   21.5242653,  -6.36363649
  22068,   29.1022434,   21.5242653,  -6.36363649
  22069,   20.9232578,   22.2863979,  -6.36363649
  22070,   21.8465176,   22.2863979,  -6.36363649
  22071,   22.7697754,   22.2863979,  -6.36363649
  22072,   23.6930351,   22.2863979,  -6.36363649
  22073,    24.616293,   22.2863979,  -6.36363649
  22074,   25.5395527,   22.2863979,  -6.36363649
  22075,   26.4316406,   22.2863979,  -6.36363649
  22076,   27.3237305,   22.2863979,  -6.36363649
  22077,   28.2158203,   22.2863979,  -6.36363649
  22078,   29.1079102,   22.2863979,  -6.36363649
  22079,   20.9279804,   23.0485306,  -6.36363649
  22080,   21.8559628,   23.0485306,  -6.36363649
  22081,   22.7839432,   23.0485306,  -6.36363649
  22082,   23.7119255,   23.0485306,  -6.36363649
  22083,   24.6399059,   23.0485306,  -6.36363649
  22084,   25.5678864,   23.0485306,  -6.36363649
  22085,   26.4543095,   23.0485306,  -6.36363649
  22086,   27.3407326,   23.0485306,  -6.36363649
  22087,   28.2271538,   23.0485306,  -6.36363649
  22088,   29.1135769,   23.0485306,  -6.36363649
  22089,    20.932703,   23.8106632,  -6.36363649
  22090,   21.8654079,   23.8106632,  -6.36363649
  22091,    22.798111,   23.8106632,  -6.36363649
  22092,   23.7308159,   23.8106632,  -6.36363649
  22093,   24.6635189,   23.8106632,  -6.36363649
  22094,   25.5962219,   23.8106632,  -6.36363649
  22095,   26.4769783,   23.8106632,  -6.36363649
  22096,   27.3577328,   23.8106632,  -6.36363649
  22097,   28.2384892,   23.8106632,  -6.36363649
  22098,   29.1192455,   23.8106632,  -6.36363649
  22099,   20.9374256,   24.5727959,  -6.36363649
  22100,   21.8748531,   24.5727959,  -6.36363649
  22101,   22.8122787,   24.5727959,  -6.36363649
  22102,   23.7497044,   24.5727959,  -6.36363649
  22103,     24.68713,   24.5727959,  -6.36363649
  22104,   25.6245575,   24.5727959,  -6.36363649
  22105,   26.4996452,   24.5727959,  -6.36363649
  22106,   27.3747349,   24.5727959,  -6.36363649
  22107,   28.2498226,   24.5727959,  -6.36363649
  22108,   29.1249123,   24.5727959,  -6.36363649
  22109,   20.9421482,   25.3349285,  -6.36363649
  22110,   21.8842983,   25.3349285,  -6.36363649
  22111,   22.8264465,   25.3349285,  -6.36363649
  22112,   23.7685947,   25.3349285,  -6.36363649
  22113,    24.710743,   25.3349285,  -6.36363649
  22114,   25.6528931,   25.3349285,  -6.36363649
  22115,   26.5223141,   25.3349285,  -6.36363649
  22116,    27.391737,   25.3349285,  -6.36363649
  22117,   28.2611561,   25.3349285,  -6.36363649
  22118,    29.130579,   25.3349285,  -6.36363649
  22119,   20.9421482,   26.1282291,  -6.36363649
  22120,   21.8842983,   26.1282291,  -6.36363649
  22121,   22.8264465,   26.1282291,  -6.36363649
  22122,   23.7685947,   26.1282291,  -6.36363649
  22123,    24.710743,   26.1282291,  -6.36363649
  22124,   25.6528931,   26.1282291,  -6.36363649
  22125,   26.5223141,   26.1282291,  -6.36363649
  22126,    27.391737,   26.1282291,  -6.36363649
  22127,   28.2611561,   26.1282291,  -6.36363649
  22128,    29.130579,   26.1282291,  -6.36363649
  22129,   20.9421482,   26.9215317,  -6.36363649
  22130,   21.8842983,   26.9215317,  -6.36363649
  22131,   22.8264465,   26.9215317,  -6.36363649
  22132,   23.7685947,   26.9215317,  -6.36363649
  22133,    24.710743,   26.9215317,  -6.36363649
  22134,   25.6528931,   26.9215317,  -6.36363649
  22135,   26.5223141,   26.9215317,  -6.36363649
  22136,    27.391737,   26.9215317,  -6.36363649
  22137,   28.2611561,   26.9215317,  -6.36363649
  22138,    29.130579,   26.9215317,  -6.36363649
  22139,   20.9421482,   27.7148323,  -6.36363649
  22140,   21.8842983,   27.7148323,  -6.36363649
  22141,   22.8264465,   27.7148323,  -6.36363649
  22142,   23.7685947,   27.7148323,  -6.36363649
  22143,    24.710743,   27.7148323,  -6.36363649
  22144,   25.6528931,   27.7148323,  -6.36363649
  22145,   26.5223141,   27.7148323,  -6.36363649
  22146,    27.391737,   27.7148323,  -6.36363649
  22147,   28.2611561,   27.7148323,  -6.36363649
  22148,    29.130579,   27.7148323,  -6.36363649
  22149,   20.9421482,   28.5081348,  -6.36363649
  22150,   21.8842983,   28.5081348,  -6.36363649
  22151,   22.8264465,   28.5081348,  -6.36363649
  22152,   23.7685947,   28.5081348,  -6.36363649
  22153,    24.710743,   28.5081348,  -6.36363649
  22154,   25.6528931,   28.5081348,  -6.36363649
  22155,   26.5223141,   28.5081348,  -6.36363649
  22156,    27.391737,   28.5081348,  -6.36363649
  22157,   28.2611561,   28.5081348,  -6.36363649
  22158,    29.130579,   28.5081348,  -6.36363649
  22159,   20.9421482,   29.3014355,  -6.36363649
  22160,   21.8842983,   29.3014355,  -6.36363649
  22161,   22.8264465,   29.3014355,  -6.36363649
  22162,   23.7685947,   29.3014355,  -6.36363649
  22163,    24.710743,   29.3014355,  -6.36363649
  22164,   25.6528931,   29.3014355,  -6.36363649
  22165,   26.5223141,   29.3014355,  -6.36363649
  22166,    27.391737,   29.3014355,  -6.36363649
  22167,   28.2611561,   29.3014355,  -6.36363649
  22168,    29.130579,   29.3014355,  -6.36363649
  22169,   20.9421482,   30.0947361,  -6.36363649
  22170,   21.8842983,   30.0947361,  -6.36363649
  22171,   22.8264465,   30.0947361,  -6.36363649
  22172,   23.7685947,   30.0947361,  -6.36363649
  22173,    24.710743,   30.0947361,  -6.36363649
  22174,   25.6528931,   30.0947361,  -6.36363649
  22175,   26.5223141,   30.0947361,  -6.36363649
  22176,    27.391737,   30.0947361,  -6.36363649
  22177,   28.2611561,   30.0947361,  -6.36363649
  22178,    29.130579,   30.0947361,  -6.36363649
  22179,   20.9421482,   30.8880386,  -6.36363649
  22180,   21.8842983,   30.8880386,  -6.36363649
  22181,   22.8264465,   30.8880386,  -6.36363649
  22182,   23.7685947,   30.8880386,  -6.36363649
  22183,    24.710743,   30.8880386,  -6.36363649
  22184,   25.6528931,   30.8880386,  -6.36363649
  22185,   26.5223141,   30.8880386,  -6.36363649
  22186,    27.391737,   30.8880386,  -6.36363649
  22187,   28.2611561,   30.8880386,  -6.36363649
  22188,    29.130579,   30.8880386,  -6.36363649
  22189,   20.9421482,   31.6813393,  -6.36363649
  22190,   21.8842983,   31.6813393,  -6.36363649
  22191,   22.8264465,   31.6813393,  -6.36363649
  22192,   23.7685947,   31.6813393,  -6.36363649
  22193,    24.710743,   31.6813393,  -6.36363649
  22194,   25.6528931,   31.6813393,  -6.36363649
  22195,   26.5223141,   31.6813393,  -6.36363649
  22196,    27.391737,   31.6813393,  -6.36363649
  22197,   28.2611561,   31.6813393,  -6.36363649
  22198,    29.130579,   31.6813393,  -6.36363649
  22199,   20.9421482,   32.4746399,  -6.36363649
  22200,   21.8842983,   32.4746399,  -6.36363649
  22201,   22.8264465,   32.4746399,  -6.36363649
  22202,   23.7685947,   32.4746399,  -6.36363649
  22203,    24.710743,   32.4746399,  -6.36363649
  22204,   25.6528931,   32.4746399,  -6.36363649
  22205,   26.5223141,   32.4746399,  -6.36363649
  22206,    27.391737,   32.4746399,  -6.36363649
  22207,   28.2611561,   32.4746399,  -6.36363649
  22208,    29.130579,   32.4746399,  -6.36363649
  22209,   20.9421482,   33.2679443,  -6.36363649
  22210,   21.8842983,   33.2679443,  -6.36363649
  22211,   22.8264465,   33.2679443,  -6.36363649
  22212,   23.7685947,   33.2679443,  -6.36363649
  22213,    24.710743,   33.2679443,  -6.36363649
  22214,   25.6528931,   33.2679443,  -6.36363649
  22215,   26.5223141,   33.2679443,  -6.36363649
  22216,    27.391737,   33.2679443,  -6.36363649
  22217,   28.2611561,   33.2679443,  -6.36363649
  22218,    29.130579,   33.2679443,  -6.36363649
  22219,   20.9421482,    34.061245,  -6.36363649
  22220,   21.8842983,    34.061245,  -6.36363649
  22221,   22.8264465,    34.061245,  -6.36363649
  22222,   23.7685947,    34.061245,  -6.36363649
  22223,    24.710743,    34.061245,  -6.36363649
  22224,   25.6528931,    34.061245,  -6.36363649
  22225,   26.5223141,    34.061245,  -6.36363649
  22226,    27.391737,    34.061245,  -6.36363649
  22227,   28.2611561,    34.061245,  -6.36363649
  22228,    29.130579,    34.061245,  -6.36363649
  22229,   20.9421482,   34.8545456,  -6.36363649
  22230,   21.8842983,   34.8545456,  -6.36363649
  22231,   22.8264465,   34.8545456,  -6.36363649
  22232,   23.7685947,   34.8545456,  -6.36363649
  22233,    24.710743,   34.8545456,  -6.36363649
  22234,   25.6528931,   34.8545456,  -6.36363649
  22235,   26.5223141,   34.8545456,  -6.36363649
  22236,    27.391737,   34.8545456,  -6.36363649
  22237,   28.2611561,   34.8545456,  -6.36363649
  22238,    29.130579,   34.8545456,  -6.36363649
  22239,   20.9421482,   35.6478462,  -6.36363649
  22240,   21.8842983,   35.6478462,  -6.36363649
  22241,   22.8264465,   35.6478462,  -6.36363649
  22242,   23.7685947,   35.6478462,  -6.36363649
  22243,    24.710743,   35.6478462,  -6.36363649
  22244,   25.6528931,   35.6478462,  -6.36363649
  22245,   26.5223141,   35.6478462,  -6.36363649
  22246,    27.391737,   35.6478462,  -6.36363649
  22247,   28.2611561,   35.6478462,  -6.36363649
  22248,    29.130579,   35.6478462,  -6.36363649
  22249,   20.9421482,   36.4411469,  -6.36363649
  22250,   21.8842983,   36.4411469,  -6.36363649
  22251,   22.8264465,   36.4411469,  -6.36363649
  22252,   23.7685947,   36.4411469,  -6.36363649
  22253,    24.710743,   36.4411469,  -6.36363649
  22254,   25.6528931,   36.4411469,  -6.36363649
  22255,   26.5223141,   36.4411469,  -6.36363649
  22256,    27.391737,   36.4411469,  -6.36363649
  22257,   28.2611561,   36.4411469,  -6.36363649
  22258,    29.130579,   36.4411469,  -6.36363649
  22259,   20.9421482,   37.2344513,  -6.36363649
  22260,   21.8842983,   37.2344513,  -6.36363649
  22261,   22.8264465,   37.2344513,  -6.36363649
  22262,   23.7685947,   37.2344513,  -6.36363649
  22263,    24.710743,   37.2344513,  -6.36363649
  22264,   25.6528931,   37.2344513,  -6.36363649
  22265,   26.5223141,   37.2344513,  -6.36363649
  22266,    27.391737,   37.2344513,  -6.36363649
  22267,   28.2611561,   37.2344513,  -6.36363649
  22268,    29.130579,   37.2344513,  -6.36363649
  22269,   20.9421482,   38.0277519,  -6.36363649
  22270,   21.8842983,   38.0277519,  -6.36363649
  22271,   22.8264465,   38.0277519,  -6.36363649
  22272,   23.7685947,   38.0277519,  -6.36363649
  22273,    24.710743,   38.0277519,  -6.36363649
  22274,   25.6528931,   38.0277519,  -6.36363649
  22275,   26.5223141,   38.0277519,  -6.36363649
  22276,    27.391737,   38.0277519,  -6.36363649
  22277,   28.2611561,   38.0277519,  -6.36363649
  22278,    29.130579,   38.0277519,  -6.36363649
  22279,   20.9421482,   38.8210526,  -6.36363649
  22280,   21.8842983,   38.8210526,  -6.36363649
  22281,   22.8264465,   38.8210526,  -6.36363649
  22282,   23.7685947,   38.8210526,  -6.36363649
  22283,    24.710743,   38.8210526,  -6.36363649
  22284,   25.6528931,   38.8210526,  -6.36363649
  22285,   26.5223141,   38.8210526,  -6.36363649
  22286,    27.391737,   38.8210526,  -6.36363649
  22287,   28.2611561,   38.8210526,  -6.36363649
  22288,    29.130579,   38.8210526,  -6.36363649
  22289,   20.9421482,   39.6143532,  -6.36363649
  22290,   21.8842983,   39.6143532,  -6.36363649
  22291,   22.8264465,   39.6143532,  -6.36363649
  22292,   23.7685947,   39.6143532,  -6.36363649
  22293,    24.710743,   39.6143532,  -6.36363649
  22294,   25.6528931,   39.6143532,  -6.36363649
  22295,   26.5223141,   39.6143532,  -6.36363649
  22296,    27.391737,   39.6143532,  -6.36363649
  22297,   28.2611561,   39.6143532,  -6.36363649
  22298,    29.130579,   39.6143532,  -6.36363649
  22299,   20.9421482,   40.4076538,  -6.36363649
  22300,   21.8842983,   40.4076538,  -6.36363649
  22301,   22.8264465,   40.4076538,  -6.36363649
  22302,   23.7685947,   40.4076538,  -6.36363649
  22303,    24.710743,   40.4076538,  -6.36363649
  22304,   25.6528931,   40.4076538,  -6.36363649
  22305,   26.5223141,   40.4076538,  -6.36363649
  22306,    27.391737,   40.4076538,  -6.36363649
  22307,   28.2611561,   40.4076538,  -6.36363649
  22308,    29.130579,   40.4076538,  -6.36363649
  22309,   20.9421482,   41.2009583,  -6.36363649
  22310,   21.8842983,   41.2009583,  -6.36363649
  22311,   22.8264465,   41.2009583,  -6.36363649
  22312,   23.7685947,   41.2009583,  -6.36363649
  22313,    24.710743,   41.2009583,  -6.36363649
  22314,   25.6528931,   41.2009583,  -6.36363649
  22315,   26.5223141,   41.2009583,  -6.36363649
  22316,    27.391737,   41.2009583,  -6.36363649
  22317,   28.2611561,   41.2009583,  -6.36363649
  22318,    29.130579,   41.2009583,  -6.36363649
  22319,   20.9421482,   41.9942589,  -6.36363649
  22320,   21.8842983,   41.9942589,  -6.36363649
  22321,   22.8264465,   41.9942589,  -6.36363649
  22322,   23.7685947,   41.9942589,  -6.36363649
  22323,    24.710743,   41.9942589,  -6.36363649
  22324,   25.6528931,   41.9942589,  -6.36363649
  22325,   26.5223141,   41.9942589,  -6.36363649
  22326,    27.391737,   41.9942589,  -6.36363649
  22327,   28.2611561,   41.9942589,  -6.36363649
  22328,    29.130579,   41.9942589,  -6.36363649
  22329,   20.9421482,   42.7875595,  -6.36363649
  22330,   21.8842983,   42.7875595,  -6.36363649
  22331,   22.8264465,   42.7875595,  -6.36363649
  22332,   23.7685947,   42.7875595,  -6.36363649
  22333,    24.710743,   42.7875595,  -6.36363649
  22334,   25.6528931,   42.7875595,  -6.36363649
  22335,   26.5223141,   42.7875595,  -6.36363649
  22336,    27.391737,   42.7875595,  -6.36363649
  22337,   28.2611561,   42.7875595,  -6.36363649
  22338,    29.130579,   42.7875595,  -6.36363649
  22339,   20.9421482,   43.5808601,  -6.36363649
  22340,   21.8842983,   43.5808601,  -6.36363649
  22341,   22.8264465,   43.5808601,  -6.36363649
  22342,   23.7685947,   43.5808601,  -6.36363649
  22343,    24.710743,   43.5808601,  -6.36363649
  22344,   25.6528931,   43.5808601,  -6.36363649
  22345,   26.5223141,   43.5808601,  -6.36363649
  22346,    27.391737,   43.5808601,  -6.36363649
  22347,   28.2611561,   43.5808601,  -6.36363649
  22348,    29.130579,   43.5808601,  -6.36363649
  22349,   20.9421482,   44.3741646,  -6.36363649
  22350,   21.8842983,   44.3741646,  -6.36363649
  22351,   22.8264465,   44.3741646,  -6.36363649
  22352,   23.7685947,   44.3741646,  -6.36363649
  22353,    24.710743,   44.3741646,  -6.36363649
  22354,   25.6528931,   44.3741646,  -6.36363649
  22355,   26.5223141,   44.3741646,  -6.36363649
  22356,    27.391737,   44.3741646,  -6.36363649
  22357,   28.2611561,   44.3741646,  -6.36363649
  22358,    29.130579,   44.3741646,  -6.36363649
  22359,   20.9421482,   45.1674652,  -6.36363649
  22360,   21.8842983,   45.1674652,  -6.36363649
  22361,   22.8264465,   45.1674652,  -6.36363649
  22362,   23.7685947,   45.1674652,  -6.36363649
  22363,    24.710743,   45.1674652,  -6.36363649
  22364,   25.6528931,   45.1674652,  -6.36363649
  22365,   26.5223141,   45.1674652,  -6.36363649
  22366,    27.391737,   45.1674652,  -6.36363649
  22367,   28.2611561,   45.1674652,  -6.36363649
  22368,    29.130579,   45.1674652,  -6.36363649
  22369,   20.9366379,   45.9728851,  -6.36363649
  22370,   21.8732777,   45.9728851,  -6.36363649
  22371,   22.8099174,   45.9728851,  -6.36363649
  22372,   23.7465572,   45.9728851,  -6.36363649
  22373,   24.6831951,   45.9728851,  -6.36363649
  22374,   25.6198349,   45.9728851,  -6.36363649
  22375,   26.4958668,   45.9728851,  -6.36363649
  22376,   27.3719006,   45.9728851,  -6.36363649
  22377,   28.2479343,   45.9728851,  -6.36363649
  22378,   29.1239681,   45.9728851,  -6.36363649
  22379,   20.9311295,   46.7783089,  -6.36363649
  22380,   21.8622589,   46.7783089,  -6.36363649
  22381,   22.7933884,   46.7783089,  -6.36363649
  22382,   23.7245178,   46.7783089,  -6.36363649
  22383,   24.6556473,   46.7783089,  -6.36363649
  22384,   25.5867767,   46.7783089,  -6.36363649
  22385,   26.4694214,   46.7783089,  -6.36363649
  22386,    27.352066,   46.7783089,  -6.36363649
  22387,   28.2347107,   46.7783089,  -6.36363649
  22388,   29.1173553,   46.7783089,  -6.36363649
  22389,   20.9256191,   47.5837326,  -6.36363649
  22390,   21.8512402,   47.5837326,  -6.36363649
  22391,   22.7768593,   47.5837326,  -6.36363649
  22392,   23.7024803,   47.5837326,  -6.36363649
  22393,   24.6280994,   47.5837326,  -6.36363649
  22394,   25.5537186,   47.5837326,  -6.36363649
  22395,   26.4429741,   47.5837326,  -6.36363649
  22396,   27.3322315,   47.5837326,  -6.36363649
  22397,    28.221487,   47.5837326,  -6.36363649
  22398,   29.1107445,   47.5837326,  -6.36363649
  22399,   20.9201088,   48.3891563,  -6.36363649
  22400,   21.8402214,   48.3891563,  -6.36363649
  22401,   22.7603302,   48.3891563,  -6.36363649
  22402,   23.6804409,   48.3891563,  -6.36363649
  22403,   24.6005516,   48.3891563,  -6.36363649
  22404,   25.5206623,   48.3891563,  -6.36363649
  22405,   26.4165287,   48.3891563,  -6.36363649
  22406,    27.312397,   48.3891563,  -6.36363649
  22407,   28.2082634,   48.3891563,  -6.36363649
  22408,   29.1041336,   48.3891563,  -6.36363649
  22409,   20.9146004,   49.1945763,  -6.36363649
  22410,   21.8292007,   49.1945763,  -6.36363649
  22411,   22.7438011,   49.1945763,  -6.36363649
  22412,   23.6584034,   49.1945763,  -6.36363649
  22413,   24.5730019,   49.1945763,  -6.36363649
  22414,   25.4876041,   49.1945763,  -6.36363649
  22415,   26.3900814,   49.1945763,  -6.36363649
  22416,   27.2925625,   49.1945763,  -6.36363649
  22417,   28.1950417,   49.1945763,  -6.36363649
  22418,   29.0975208,   49.1945763,  -6.36363649
  22419,    20.912632,   20.7689686,  -7.27272749
  22420,   21.8252659,   20.7689686,  -7.27272749
  22421,   22.7378979,   20.7689686,  -7.27272749
  22422,   23.6505318,   20.7689686,  -7.27272749
  22423,   24.5631638,   20.7689686,  -7.27272749
  22424,   25.4757977,   20.7689686,  -7.27272749
  22425,   26.3806381,   20.7689686,  -7.27272749
  22426,   27.2854786,   20.7689686,  -7.27272749
  22427,   28.1903191,   20.7689686,  -7.27272749
  22428,   29.0951595,   20.7689686,  -7.27272749
  22429,   20.9161739,   21.5379353,  -7.27272749
  22430,   21.8323498,   21.5379353,  -7.27272749
  22431,   22.7485237,   21.5379353,  -7.27272749
  22432,   23.6646996,   21.5379353,  -7.27272749
  22433,   24.5808735,   21.5379353,  -7.27272749
  22434,   25.4970493,   21.5379353,  -7.27272749
  22435,   26.3976383,   21.5379353,  -7.27272749
  22436,   27.2982292,   21.5379353,  -7.27272749
  22437,   28.1988201,   21.5379353,  -7.27272749
  22438,    29.099411,   21.5379353,  -7.27272749
  22439,   20.9197159,   22.3069038,  -7.27272749
  22440,   21.8394337,   22.3069038,  -7.27272749
  22441,   22.7591496,   22.3069038,  -7.27272749
  22442,   23.6788673,   22.3069038,  -7.27272749
  22443,   24.5985832,   22.3069038,  -7.27272749
  22444,    25.518301,   22.3069038,  -7.27272749
  22445,   26.4146404,   22.3069038,  -7.27272749
  22446,   27.3109798,   22.3069038,  -7.27272749
  22447,   28.2073193,   22.3069038,  -7.27272749
  22448,   29.1036606,   22.3069038,  -7.27272749
  22449,   20.9232578,   23.0758724,  -7.27272749
  22450,   21.8465176,   23.0758724,  -7.27272749
  22451,   22.7697754,   23.0758724,  -7.27272749
  22452,   23.6930351,   23.0758724,  -7.27272749
  22453,    24.616293,   23.0758724,  -7.27272749
  22454,   25.5395508,   23.0758724,  -7.27272749
  22455,   26.4316406,   23.0758724,  -7.27272749
  22456,   27.3237305,   23.0758724,  -7.27272749
  22457,   28.2158203,   23.0758724,  -7.27272749
  22458,   29.1079102,   23.0758724,  -7.27272749
  22459,   20.9267998,   23.8448391,  -7.27272749
  22460,   21.8536015,   23.8448391,  -7.27272749
  22461,   22.7804012,   23.8448391,  -7.27272749
  22462,   23.7072029,   23.8448391,  -7.27272749
  22463,   24.6340027,   23.8448391,  -7.27272749
  22464,   25.5608025,   23.8448391,  -7.27272749
  22465,   26.4486427,   23.8448391,  -7.27272749
  22466,   27.3364811,   23.8448391,  -7.27272749
  22467,   28.2243214,   23.8448391,  -7.27272749
  22468,   29.1121616,   23.8448391,  -7.27272749
  22469,   20.9303417,   24.6138077,  -7.27272749
  22470,   21.8606853,   24.6138077,  -7.27272749
  22471,   22.7910271,   24.6138077,  -7.27272749
  22472,   23.7213688,   24.6138077,  -7.27272749
  22473,   24.6517105,   24.6138077,  -7.27272749
  22474,   25.5820541,   24.6138077,  -7.27272749
  22475,   26.4656429,   24.6138077,  -7.27272749
  22476,   27.3492336,   24.6138077,  -7.27272749
  22477,   28.2328224,   24.6138077,  -7.27272749
  22478,   29.1164112,   24.6138077,  -7.27272749
  22479,   20.9338837,   25.3827744,  -7.27272749
  22480,   21.8677692,   25.3827744,  -7.27272749
  22481,   22.8016529,   25.3827744,  -7.27272749
  22482,   23.7355366,   25.3827744,  -7.27272749
  22483,   24.6694202,   25.3827744,  -7.27272749
  22484,   25.6033058,   25.3827744,  -7.27272749
  22485,    26.482645,   25.3827744,  -7.27272749
  22486,   27.3619843,   25.3827744,  -7.27272749
  22487,   28.2413216,   25.3827744,  -7.27272749
  22488,   29.1206627,   25.3827744,  -7.27272749
  22489,   20.9338837,   26.1751194,  -7.27272749
  22490,   21.8677692,   26.1751194,  -7.27272749
  22491,   22.8016529,   26.1751194,  -7.27272749
  22492,   23.7355366,   26.1751194,  -7.27272749
  22493,   24.6694202,   26.1751194,  -7.27272749
  22494,   25.6033058,   26.1751194,  -7.27272749
  22495,    26.482645,   26.1751194,  -7.27272749
  22496,   27.3619843,   26.1751194,  -7.27272749
  22497,   28.2413216,   26.1751194,  -7.27272749
  22498,   29.1206627,   26.1751194,  -7.27272749
  22499,   20.9338837,   26.9674644,  -7.27272749
  22500,   21.8677692,   26.9674644,  -7.27272749
  22501,   22.8016529,   26.9674644,  -7.27272749
  22502,   23.7355366,   26.9674644,  -7.27272749
  22503,   24.6694202,   26.9674644,  -7.27272749
  22504,   25.6033058,   26.9674644,  -7.27272749
  22505,    26.482645,   26.9674644,  -7.27272749
  22506,   27.3619843,   26.9674644,  -7.27272749
  22507,   28.2413216,   26.9674644,  -7.27272749
  22508,   29.1206627,   26.9674644,  -7.27272749
  22509,   20.9338837,   27.7598095,  -7.27272749
  22510,   21.8677692,   27.7598095,  -7.27272749
  22511,   22.8016529,   27.7598095,  -7.27272749
  22512,   23.7355366,   27.7598095,  -7.27272749
  22513,   24.6694202,   27.7598095,  -7.27272749
  22514,   25.6033058,   27.7598095,  -7.27272749
  22515,    26.482645,   27.7598095,  -7.27272749
  22516,   27.3619843,   27.7598095,  -7.27272749
  22517,   28.2413216,   27.7598095,  -7.27272749
  22518,   29.1206627,   27.7598095,  -7.27272749
  22519,   20.9338837,   28.5521526,  -7.27272749
  22520,   21.8677692,   28.5521526,  -7.27272749
  22521,   22.8016529,   28.5521526,  -7.27272749
  22522,   23.7355366,   28.5521526,  -7.27272749
  22523,   24.6694202,   28.5521526,  -7.27272749
  22524,   25.6033058,   28.5521526,  -7.27272749
  22525,    26.482645,   28.5521526,  -7.27272749
  22526,   27.3619843,   28.5521526,  -7.27272749
  22527,   28.2413216,   28.5521526,  -7.27272749
  22528,   29.1206627,   28.5521526,  -7.27272749
  22529,   20.9338837,   29.3444977,  -7.27272749
  22530,   21.8677692,   29.3444977,  -7.27272749
  22531,   22.8016529,   29.3444977,  -7.27272749
  22532,   23.7355366,   29.3444977,  -7.27272749
  22533,   24.6694202,   29.3444977,  -7.27272749
  22534,   25.6033058,   29.3444977,  -7.27272749
  22535,    26.482645,   29.3444977,  -7.27272749
  22536,   27.3619843,   29.3444977,  -7.27272749
  22537,   28.2413216,   29.3444977,  -7.27272749
  22538,   29.1206627,   29.3444977,  -7.27272749
  22539,   20.9338837,   30.1368427,  -7.27272749
  22540,   21.8677692,   30.1368427,  -7.27272749
  22541,   22.8016529,   30.1368427,  -7.27272749
  22542,   23.7355366,   30.1368427,  -7.27272749
  22543,   24.6694202,   30.1368427,  -7.27272749
  22544,   25.6033058,   30.1368427,  -7.27272749
  22545,    26.482645,   30.1368427,  -7.27272749
  22546,   27.3619843,   30.1368427,  -7.27272749
  22547,   28.2413216,   30.1368427,  -7.27272749
  22548,   29.1206627,   30.1368427,  -7.27272749
  22549,   20.9338837,   30.9291859,  -7.27272749
  22550,   21.8677692,   30.9291859,  -7.27272749
  22551,   22.8016529,   30.9291859,  -7.27272749
  22552,   23.7355366,   30.9291859,  -7.27272749
  22553,   24.6694202,   30.9291859,  -7.27272749
  22554,   25.6033058,   30.9291859,  -7.27272749
  22555,    26.482645,   30.9291859,  -7.27272749
  22556,   27.3619843,   30.9291859,  -7.27272749
  22557,   28.2413216,   30.9291859,  -7.27272749
  22558,   29.1206627,   30.9291859,  -7.27272749
  22559,   20.9338837,   31.7215309,  -7.27272749
  22560,   21.8677692,   31.7215309,  -7.27272749
  22561,   22.8016529,   31.7215309,  -7.27272749
  22562,   23.7355366,   31.7215309,  -7.27272749
  22563,   24.6694202,   31.7215309,  -7.27272749
  22564,   25.6033058,   31.7215309,  -7.27272749
  22565,    26.482645,   31.7215309,  -7.27272749
  22566,   27.3619843,   31.7215309,  -7.27272749
  22567,   28.2413216,   31.7215309,  -7.27272749
  22568,   29.1206627,   31.7215309,  -7.27272749
  22569,   20.9338837,   32.5138741,  -7.27272749
  22570,   21.8677692,   32.5138741,  -7.27272749
  22571,   22.8016529,   32.5138741,  -7.27272749
  22572,   23.7355366,   32.5138741,  -7.27272749
  22573,   24.6694202,   32.5138741,  -7.27272749
  22574,   25.6033058,   32.5138741,  -7.27272749
  22575,    26.482645,   32.5138741,  -7.27272749
  22576,   27.3619843,   32.5138741,  -7.27272749
  22577,   28.2413216,   32.5138741,  -7.27272749
  22578,   29.1206627,   32.5138741,  -7.27272749
  22579,   20.9338837,    33.306221,  -7.27272749
  22580,   21.8677692,    33.306221,  -7.27272749
  22581,   22.8016529,    33.306221,  -7.27272749
  22582,   23.7355366,    33.306221,  -7.27272749
  22583,   24.6694202,    33.306221,  -7.27272749
  22584,   25.6033058,    33.306221,  -7.27272749
  22585,    26.482645,    33.306221,  -7.27272749
  22586,   27.3619843,    33.306221,  -7.27272749
  22587,   28.2413216,    33.306221,  -7.27272749
  22588,   29.1206627,    33.306221,  -7.27272749
  22589,   20.9338837,   34.0985641,  -7.27272749
  22590,   21.8677692,   34.0985641,  -7.27272749
  22591,   22.8016529,   34.0985641,  -7.27272749
  22592,   23.7355366,   34.0985641,  -7.27272749
  22593,   24.6694202,   34.0985641,  -7.27272749
  22594,   25.6033058,   34.0985641,  -7.27272749
  22595,    26.482645,   34.0985641,  -7.27272749
  22596,   27.3619843,   34.0985641,  -7.27272749
  22597,   28.2413216,   34.0985641,  -7.27272749
  22598,   29.1206627,   34.0985641,  -7.27272749
  22599,   20.9338837,   34.8909073,  -7.27272749
  22600,   21.8677692,   34.8909073,  -7.27272749
  22601,   22.8016529,   34.8909073,  -7.27272749
  22602,   23.7355366,   34.8909073,  -7.27272749
  22603,   24.6694202,   34.8909073,  -7.27272749
  22604,   25.6033058,   34.8909073,  -7.27272749
  22605,    26.482645,   34.8909073,  -7.27272749
  22606,   27.3619843,   34.8909073,  -7.27272749
  22607,   28.2413216,   34.8909073,  -7.27272749
  22608,   29.1206627,   34.8909073,  -7.27272749
  22609,   20.9338837,   35.6832542,  -7.27272749
  22610,   21.8677692,   35.6832542,  -7.27272749
  22611,   22.8016529,   35.6832542,  -7.27272749
  22612,   23.7355366,   35.6832542,  -7.27272749
  22613,   24.6694202,   35.6832542,  -7.27272749
  22614,   25.6033058,   35.6832542,  -7.27272749
  22615,    26.482645,   35.6832542,  -7.27272749
  22616,   27.3619843,   35.6832542,  -7.27272749
  22617,   28.2413216,   35.6832542,  -7.27272749
  22618,   29.1206627,   35.6832542,  -7.27272749
  22619,   20.9338837,   36.4755974,  -7.27272749
  22620,   21.8677692,   36.4755974,  -7.27272749
  22621,   22.8016529,   36.4755974,  -7.27272749
  22622,   23.7355366,   36.4755974,  -7.27272749
  22623,   24.6694202,   36.4755974,  -7.27272749
  22624,   25.6033058,   36.4755974,  -7.27272749
  22625,    26.482645,   36.4755974,  -7.27272749
  22626,   27.3619843,   36.4755974,  -7.27272749
  22627,   28.2413216,   36.4755974,  -7.27272749
  22628,   29.1206627,   36.4755974,  -7.27272749
  22629,   20.9338837,   37.2679443,  -7.27272749
  22630,   21.8677692,   37.2679443,  -7.27272749
  22631,   22.8016529,   37.2679443,  -7.27272749
  22632,   23.7355366,   37.2679443,  -7.27272749
  22633,   24.6694202,   37.2679443,  -7.27272749
  22634,   25.6033058,   37.2679443,  -7.27272749
  22635,    26.482645,   37.2679443,  -7.27272749
  22636,   27.3619843,   37.2679443,  -7.27272749
  22637,   28.2413216,   37.2679443,  -7.27272749
  22638,   29.1206627,   37.2679443,  -7.27272749
  22639,   20.9338837,   38.0602875,  -7.27272749
  22640,   21.8677692,   38.0602875,  -7.27272749
  22641,   22.8016529,   38.0602875,  -7.27272749
  22642,   23.7355366,   38.0602875,  -7.27272749
  22643,   24.6694202,   38.0602875,  -7.27272749
  22644,   25.6033058,   38.0602875,  -7.27272749
  22645,    26.482645,   38.0602875,  -7.27272749
  22646,   27.3619843,   38.0602875,  -7.27272749
  22647,   28.2413216,   38.0602875,  -7.27272749
  22648,   29.1206627,   38.0602875,  -7.27272749
  22649,   20.9338837,   38.8526306,  -7.27272749
  22650,   21.8677692,   38.8526306,  -7.27272749
  22651,   22.8016529,   38.8526306,  -7.27272749
  22652,   23.7355366,   38.8526306,  -7.27272749
  22653,   24.6694202,   38.8526306,  -7.27272749
  22654,   25.6033058,   38.8526306,  -7.27272749
  22655,    26.482645,   38.8526306,  -7.27272749
  22656,   27.3619843,   38.8526306,  -7.27272749
  22657,   28.2413216,   38.8526306,  -7.27272749
  22658,   29.1206627,   38.8526306,  -7.27272749
  22659,   20.9338837,   39.6449776,  -7.27272749
  22660,   21.8677692,   39.6449776,  -7.27272749
  22661,   22.8016529,   39.6449776,  -7.27272749
  22662,   23.7355366,   39.6449776,  -7.27272749
  22663,   24.6694202,   39.6449776,  -7.27272749
  22664,   25.6033058,   39.6449776,  -7.27272749
  22665,    26.482645,   39.6449776,  -7.27272749
  22666,   27.3619843,   39.6449776,  -7.27272749
  22667,   28.2413216,   39.6449776,  -7.27272749
  22668,   29.1206627,   39.6449776,  -7.27272749
  22669,   20.9338837,   40.4373207,  -7.27272749
  22670,   21.8677692,   40.4373207,  -7.27272749
  22671,   22.8016529,   40.4373207,  -7.27272749
  22672,   23.7355366,   40.4373207,  -7.27272749
  22673,   24.6694202,   40.4373207,  -7.27272749
  22674,   25.6033058,   40.4373207,  -7.27272749
  22675,    26.482645,   40.4373207,  -7.27272749
  22676,   27.3619843,   40.4373207,  -7.27272749
  22677,   28.2413216,   40.4373207,  -7.27272749
  22678,   29.1206627,   40.4373207,  -7.27272749
  22679,   20.9338837,   41.2296638,  -7.27272749
  22680,   21.8677692,   41.2296638,  -7.27272749
  22681,   22.8016529,   41.2296638,  -7.27272749
  22682,   23.7355366,   41.2296638,  -7.27272749
  22683,   24.6694202,   41.2296638,  -7.27272749
  22684,   25.6033058,   41.2296638,  -7.27272749
  22685,    26.482645,   41.2296638,  -7.27272749
  22686,   27.3619843,   41.2296638,  -7.27272749
  22687,   28.2413216,   41.2296638,  -7.27272749
  22688,   29.1206627,   41.2296638,  -7.27272749
  22689,   20.9338837,   42.0220108,  -7.27272749
  22690,   21.8677692,   42.0220108,  -7.27272749
  22691,   22.8016529,   42.0220108,  -7.27272749
  22692,   23.7355366,   42.0220108,  -7.27272749
  22693,   24.6694202,   42.0220108,  -7.27272749
  22694,   25.6033058,   42.0220108,  -7.27272749
  22695,    26.482645,   42.0220108,  -7.27272749
  22696,   27.3619843,   42.0220108,  -7.27272749
  22697,   28.2413216,   42.0220108,  -7.27272749
  22698,   29.1206627,   42.0220108,  -7.27272749
  22699,   20.9338837,   42.8143539,  -7.27272749
  22700,   21.8677692,   42.8143539,  -7.27272749
  22701,   22.8016529,   42.8143539,  -7.27272749
  22702,   23.7355366,   42.8143539,  -7.27272749
  22703,   24.6694202,   42.8143539,  -7.27272749
  22704,   25.6033058,   42.8143539,  -7.27272749
  22705,    26.482645,   42.8143539,  -7.27272749
  22706,   27.3619843,   42.8143539,  -7.27272749
  22707,   28.2413216,   42.8143539,  -7.27272749
  22708,   29.1206627,   42.8143539,  -7.27272749
  22709,   20.9338837,   43.6066971,  -7.27272749
  22710,   21.8677692,   43.6066971,  -7.27272749
  22711,   22.8016529,   43.6066971,  -7.27272749
  22712,   23.7355366,   43.6066971,  -7.27272749
  22713,   24.6694202,   43.6066971,  -7.27272749
  22714,   25.6033058,   43.6066971,  -7.27272749
  22715,    26.482645,   43.6066971,  -7.27272749
  22716,   27.3619843,   43.6066971,  -7.27272749
  22717,   28.2413216,   43.6066971,  -7.27272749
  22718,   29.1206627,   43.6066971,  -7.27272749
  22719,   20.9338837,    44.399044,  -7.27272749
  22720,   21.8677692,    44.399044,  -7.27272749
  22721,   22.8016529,    44.399044,  -7.27272749
  22722,   23.7355366,    44.399044,  -7.27272749
  22723,   24.6694202,    44.399044,  -7.27272749
  22724,   25.6033058,    44.399044,  -7.27272749
  22725,    26.482645,    44.399044,  -7.27272749
  22726,   27.3619843,    44.399044,  -7.27272749
  22727,   28.2413216,    44.399044,  -7.27272749
  22728,   29.1206627,    44.399044,  -7.27272749
  22729,   20.9338837,   45.1913872,  -7.27272749
  22730,   21.8677692,   45.1913872,  -7.27272749
  22731,   22.8016529,   45.1913872,  -7.27272749
  22732,   23.7355366,   45.1913872,  -7.27272749
  22733,   24.6694202,   45.1913872,  -7.27272749
  22734,   25.6033058,   45.1913872,  -7.27272749
  22735,    26.482645,   45.1913872,  -7.27272749
  22736,   27.3619843,   45.1913872,  -7.27272749
  22737,   28.2413216,   45.1913872,  -7.27272749
  22738,   29.1206627,   45.1913872,  -7.27272749
  22739,   20.9297504,   45.9928246,  -7.27272749
  22740,   21.8595047,   45.9928246,  -7.27272749
  22741,   22.7892551,   45.9928246,  -7.27272749
  22742,   23.7190094,   45.9928246,  -7.27272749
  22743,   24.6487598,   45.9928246,  -7.27272749
  22744,   25.5785122,   45.9928246,  -7.27272749
  22745,   26.4628086,   45.9928246,  -7.27272749
  22746,   27.3471069,   45.9928246,  -7.27272749
  22747,   28.2314053,   45.9928246,  -7.27272749
  22748,   29.1157036,   45.9928246,  -7.27272749
  22749,   20.9256191,   46.7942581,  -7.27272749
  22750,   21.8512402,   46.7942581,  -7.27272749
  22751,   22.7768593,   46.7942581,  -7.27272749
  22752,   23.7024803,   46.7942581,  -7.27272749
  22753,   24.6280994,   46.7942581,  -7.27272749
  22754,   25.5537186,   46.7942581,  -7.27272749
  22755,   26.4429741,   46.7942581,  -7.27272749
  22756,   27.3322315,   46.7942581,  -7.27272749
  22757,    28.221487,   46.7942581,  -7.27272749
  22758,   29.1107445,   46.7942581,  -7.27272749
  22759,   20.9214878,   47.5956955,  -7.27272749
  22760,   21.8429756,   47.5956955,  -7.27272749
  22761,   22.7644615,   47.5956955,  -7.27272749
  22762,   23.6859512,   47.5956955,  -7.27272749
  22763,   24.6074371,   47.5956955,  -7.27272749
  22764,   25.5289249,   47.5956955,  -7.27272749
  22765,   26.4231396,   47.5956955,  -7.27272749
  22766,   27.3173561,   47.5956955,  -7.27272749
  22767,   28.2115707,   47.5956955,  -7.27272749
  22768,   29.1057854,   47.5956955,  -7.27272749
  22769,   20.9173546,   48.3971291,  -7.27272749
  22770,   21.8347111,   48.3971291,  -7.27272749
  22771,   22.7520657,   48.3971291,  -7.27272749
  22772,   23.6694221,   48.3971291,  -7.27272749
  22773,   24.5867767,   48.3971291,  -7.27272749
  22774,   25.5041332,   48.3971291,  -7.27272749
  22775,   26.4033051,   48.3971291,  -7.27272749
  22776,   27.3024807,   48.3971291,  -7.27272749
  22777,   28.2016525,   48.3971291,  -7.27272749
  22778,   29.1008282,   48.3971291,  -7.27272749
  22779,   20.9132233,   49.1985664,  -7.27272749
  22780,   21.8264465,   49.1985664,  -7.27272749
  22781,   22.7396698,   49.1985664,  -7.27272749
  22782,   23.6528931,   49.1985664,  -7.27272749
  22783,   24.5661144,   49.1985664,  -7.27272749
  22784,   25.4793396,   49.1985664,  -7.27272749
  22785,   26.3834705,   49.1985664,  -7.27272749
  22786,   27.2876034,   49.1985664,  -7.27272749
  22787,   28.1917362,   49.1985664,  -7.27272749
  22788,   29.0958691,   49.1985664,  -7.27272749
  22789,   20.9114513,   20.7758026,  -8.18181801
  22790,   21.8229046,   20.7758026,  -8.18181801
  22791,   22.7343559,   20.7758026,  -8.18181801
  22792,   23.6458092,   20.7758026,  -8.18181801
  22793,   24.5572605,   20.7758026,  -8.18181801
  22794,   25.4687138,   20.7758026,  -8.18181801
  22795,   26.3749695,   20.7758026,  -8.18181801
  22796,    27.281229,   20.7758026,  -8.18181801
  22797,   28.1874847,   20.7758026,  -8.18181801
  22798,   29.0937424,   20.7758026,  -8.18181801
  22799,   20.9138126,   21.5516071,  -8.18181801
  22800,   21.8276272,   21.5516071,  -8.18181801
  22801,   22.7414398,   21.5516071,  -8.18181801
  22802,   23.6552544,   21.5516071,  -8.18181801
  22803,    24.569067,   21.5516071,  -8.18181801
  22804,   25.4828815,   21.5516071,  -8.18181801
  22805,   26.3863049,   21.5516071,  -8.18181801
  22806,   27.2897282,   21.5516071,  -8.18181801
  22807,   28.1931515,   21.5516071,  -8.18181801
  22808,   29.0965767,   21.5516071,  -8.18181801
  22809,   20.9161739,   22.3274097,  -8.18181801
  22810,   21.8323498,   22.3274097,  -8.18181801
  22811,   22.7485237,   22.3274097,  -8.18181801
  22812,   23.6646996,   22.3274097,  -8.18181801
  22813,   24.5808735,   22.3274097,  -8.18181801
  22814,   25.4970493,   22.3274097,  -8.18181801
  22815,   26.3976383,   22.3274097,  -8.18181801
  22816,   27.2982292,   22.3274097,  -8.18181801
  22817,   28.1988182,   22.3274097,  -8.18181801
  22818,    29.099411,   22.3274097,  -8.18181801
  22819,   20.9185352,   23.1032124,  -8.18181801
  22820,   21.8370724,   23.1032124,  -8.18181801
  22821,   22.7556076,   23.1032124,  -8.18181801
  22822,   23.6741447,   23.1032124,  -8.18181801
  22823,     24.59268,   23.1032124,  -8.18181801
  22824,   25.5112171,   23.1032124,  -8.18181801
  22825,   26.4089718,   23.1032124,  -8.18181801
  22826,   27.3067303,   23.1032124,  -8.18181801
  22827,   28.2044868,   23.1032124,  -8.18181801
  22828,   29.1022434,   23.1032124,  -8.18181801
  22829,   20.9208965,    23.879015,  -8.18181801
  22830,    21.841795,    23.879015,  -8.18181801
  22831,   22.7626915,    23.879015,  -8.18181801
  22832,   23.6835899,    23.879015,  -8.18181801
  22833,   24.6044865,    23.879015,  -8.18181801
  22834,   25.5253849,    23.879015,  -8.18181801
  22835,   26.4203072,    23.879015,  -8.18181801
  22836,   27.3152313,    23.879015,  -8.18181801
  22837,   28.2101536,    23.879015,  -8.18181801
  22838,   29.1050777,    23.879015,  -8.18181801
  22839,   20.9232578,   24.6548195,  -8.18181801
  22840,   21.8465176,   24.6548195,  -8.18181801
  22841,   22.7697754,   24.6548195,  -8.18181801
  22842,   23.6930351,   24.6548195,  -8.18181801
  22843,    24.616293,   24.6548195,  -8.18181801
  22844,   25.5395508,   24.6548195,  -8.18181801
  22845,   26.4316406,   24.6548195,  -8.18181801
  22846,   27.3237324,   24.6548195,  -8.18181801
  22847,   28.2158203,   24.6548195,  -8.18181801
  22848,   29.1079102,   24.6548195,  -8.18181801
  22849,   20.9256191,   25.4306221,  -8.18181801
  22850,   21.8512402,   25.4306221,  -8.18181801
  22851,   22.7768593,   25.4306221,  -8.18181801
  22852,   23.7024803,   25.4306221,  -8.18181801
  22853,   24.6280994,   25.4306221,  -8.18181801
  22854,   25.5537186,   25.4306221,  -8.18181801
  22855,   26.4429741,   25.4306221,  -8.18181801
  22856,   27.3322315,   25.4306221,  -8.18181801
  22857,    28.221487,   25.4306221,  -8.18181801
  22858,   29.1107445,   25.4306221,  -8.18181801
  22859,   20.9256191,   26.2220097,  -8.18181801
  22860,   21.8512402,   26.2220097,  -8.18181801
  22861,   22.7768593,   26.2220097,  -8.18181801
  22862,   23.7024803,   26.2220097,  -8.18181801
  22863,   24.6280994,   26.2220097,  -8.18181801
  22864,   25.5537186,   26.2220097,  -8.18181801
  22865,   26.4429741,   26.2220097,  -8.18181801
  22866,   27.3322315,   26.2220097,  -8.18181801
  22867,    28.221487,   26.2220097,  -8.18181801
  22868,   29.1107445,   26.2220097,  -8.18181801
  22869,   20.9256191,   27.0133972,  -8.18181801
  22870,   21.8512402,   27.0133972,  -8.18181801
  22871,   22.7768593,   27.0133972,  -8.18181801
  22872,   23.7024803,   27.0133972,  -8.18181801
  22873,   24.6280994,   27.0133972,  -8.18181801
  22874,   25.5537186,   27.0133972,  -8.18181801
  22875,   26.4429741,   27.0133972,  -8.18181801
  22876,   27.3322315,   27.0133972,  -8.18181801
  22877,    28.221487,   27.0133972,  -8.18181801
  22878,   29.1107445,   27.0133972,  -8.18181801
  22879,   20.9256191,   27.8047848,  -8.18181801
  22880,   21.8512402,   27.8047848,  -8.18181801
  22881,   22.7768593,   27.8047848,  -8.18181801
  22882,   23.7024803,   27.8047848,  -8.18181801
  22883,   24.6280994,   27.8047848,  -8.18181801
  22884,   25.5537186,   27.8047848,  -8.18181801
  22885,   26.4429741,   27.8047848,  -8.18181801
  22886,   27.3322315,   27.8047848,  -8.18181801
  22887,    28.221487,   27.8047848,  -8.18181801
  22888,   29.1107445,   27.8047848,  -8.18181801
  22889,   20.9256191,   28.5961723,  -8.18181801
  22890,   21.8512402,   28.5961723,  -8.18181801
  22891,   22.7768593,   28.5961723,  -8.18181801
  22892,   23.7024803,   28.5961723,  -8.18181801
  22893,   24.6280994,   28.5961723,  -8.18181801
  22894,   25.5537186,   28.5961723,  -8.18181801
  22895,   26.4429741,   28.5961723,  -8.18181801
  22896,   27.3322315,   28.5961723,  -8.18181801
  22897,    28.221487,   28.5961723,  -8.18181801
  22898,   29.1107445,   28.5961723,  -8.18181801
  22899,   20.9256191,   29.3875599,  -8.18181801
  22900,   21.8512402,   29.3875599,  -8.18181801
  22901,   22.7768593,   29.3875599,  -8.18181801
  22902,   23.7024803,   29.3875599,  -8.18181801
  22903,   24.6280994,   29.3875599,  -8.18181801
  22904,   25.5537186,   29.3875599,  -8.18181801
  22905,   26.4429741,   29.3875599,  -8.18181801
  22906,   27.3322315,   29.3875599,  -8.18181801
  22907,    28.221487,   29.3875599,  -8.18181801
  22908,   29.1107445,   29.3875599,  -8.18181801
  22909,   20.9256191,   30.1789474,  -8.18181801
  22910,   21.8512402,   30.1789474,  -8.18181801
  22911,   22.7768593,   30.1789474,  -8.18181801
  22912,   23.7024803,   30.1789474,  -8.18181801
  22913,   24.6280994,   30.1789474,  -8.18181801
  22914,   25.5537186,   30.1789474,  -8.18181801
  22915,   26.4429741,   30.1789474,  -8.18181801
  22916,   27.3322315,   30.1789474,  -8.18181801
  22917,    28.221487,   30.1789474,  -8.18181801
  22918,   29.1107445,   30.1789474,  -8.18181801
  22919,   20.9256191,    30.970335,  -8.18181801
  22920,   21.8512402,    30.970335,  -8.18181801
  22921,   22.7768593,    30.970335,  -8.18181801
  22922,   23.7024803,    30.970335,  -8.18181801
  22923,   24.6280994,    30.970335,  -8.18181801
  22924,   25.5537186,    30.970335,  -8.18181801
  22925,   26.4429741,    30.970335,  -8.18181801
  22926,   27.3322315,    30.970335,  -8.18181801
  22927,    28.221487,    30.970335,  -8.18181801
  22928,   29.1107445,    30.970335,  -8.18181801
  22929,   20.9256191,   31.7617226,  -8.18181801
  22930,   21.8512402,   31.7617226,  -8.18181801
  22931,   22.7768593,   31.7617226,  -8.18181801
  22932,   23.7024803,   31.7617226,  -8.18181801
  22933,   24.6280994,   31.7617226,  -8.18181801
  22934,   25.5537186,   31.7617226,  -8.18181801
  22935,   26.4429741,   31.7617226,  -8.18181801
  22936,   27.3322315,   31.7617226,  -8.18181801
  22937,    28.221487,   31.7617226,  -8.18181801
  22938,   29.1107445,   31.7617226,  -8.18181801
  22939,   20.9256191,   32.5531082,  -8.18181801
  22940,   21.8512402,   32.5531082,  -8.18181801
  22941,   22.7768593,   32.5531082,  -8.18181801
  22942,   23.7024803,   32.5531082,  -8.18181801
  22943,   24.6280994,   32.5531082,  -8.18181801
  22944,   25.5537186,   32.5531082,  -8.18181801
  22945,   26.4429741,   32.5531082,  -8.18181801
  22946,   27.3322315,   32.5531082,  -8.18181801
  22947,    28.221487,   32.5531082,  -8.18181801
  22948,   29.1107445,   32.5531082,  -8.18181801
  22949,   20.9256191,   33.3444977,  -8.18181801
  22950,   21.8512402,   33.3444977,  -8.18181801
  22951,   22.7768593,   33.3444977,  -8.18181801
  22952,   23.7024803,   33.3444977,  -8.18181801
  22953,   24.6280994,   33.3444977,  -8.18181801
  22954,   25.5537186,   33.3444977,  -8.18181801
  22955,   26.4429741,   33.3444977,  -8.18181801
  22956,   27.3322315,   33.3444977,  -8.18181801
  22957,    28.221487,   33.3444977,  -8.18181801
  22958,   29.1107445,   33.3444977,  -8.18181801
  22959,   20.9256191,   34.1358833,  -8.18181801
  22960,   21.8512402,   34.1358833,  -8.18181801
  22961,   22.7768593,   34.1358833,  -8.18181801
  22962,   23.7024803,   34.1358833,  -8.18181801
  22963,   24.6280994,   34.1358833,  -8.18181801
  22964,   25.5537186,   34.1358833,  -8.18181801
  22965,   26.4429741,   34.1358833,  -8.18181801
  22966,   27.3322315,   34.1358833,  -8.18181801
  22967,    28.221487,   34.1358833,  -8.18181801
  22968,   29.1107445,   34.1358833,  -8.18181801
  22969,   20.9256191,   34.9272728,  -8.18181801
  22970,   21.8512402,   34.9272728,  -8.18181801
  22971,   22.7768593,   34.9272728,  -8.18181801
  22972,   23.7024803,   34.9272728,  -8.18181801
  22973,   24.6280994,   34.9272728,  -8.18181801
  22974,   25.5537186,   34.9272728,  -8.18181801
  22975,   26.4429741,   34.9272728,  -8.18181801
  22976,   27.3322315,   34.9272728,  -8.18181801
  22977,    28.221487,   34.9272728,  -8.18181801
  22978,   29.1107445,   34.9272728,  -8.18181801
  22979,   20.9256191,   35.7186584,  -8.18181801
  22980,   21.8512402,   35.7186584,  -8.18181801
  22981,   22.7768593,   35.7186584,  -8.18181801
  22982,   23.7024803,   35.7186584,  -8.18181801
  22983,   24.6280994,   35.7186584,  -8.18181801
  22984,   25.5537186,   35.7186584,  -8.18181801
  22985,   26.4429741,   35.7186584,  -8.18181801
  22986,   27.3322315,   35.7186584,  -8.18181801
  22987,    28.221487,   35.7186584,  -8.18181801
  22988,   29.1107445,   35.7186584,  -8.18181801
  22989,   20.9256191,   36.5100479,  -8.18181801
  22990,   21.8512402,   36.5100479,  -8.18181801
  22991,   22.7768593,   36.5100479,  -8.18181801
  22992,   23.7024803,   36.5100479,  -8.18181801
  22993,   24.6280994,   36.5100479,  -8.18181801
  22994,   25.5537186,   36.5100479,  -8.18181801
  22995,   26.4429741,   36.5100479,  -8.18181801
  22996,   27.3322315,   36.5100479,  -8.18181801
  22997,    28.221487,   36.5100479,  -8.18181801
  22998,   29.1107445,   36.5100479,  -8.18181801
  22999,   20.9256191,   37.3014336,  -8.18181801
  23000,   21.8512402,   37.3014336,  -8.18181801
  23001,   22.7768593,   37.3014336,  -8.18181801
  23002,   23.7024803,   37.3014336,  -8.18181801
  23003,   24.6280994,   37.3014336,  -8.18181801
  23004,   25.5537186,   37.3014336,  -8.18181801
  23005,   26.4429741,   37.3014336,  -8.18181801
  23006,   27.3322315,   37.3014336,  -8.18181801
  23007,    28.221487,   37.3014336,  -8.18181801
  23008,   29.1107445,   37.3014336,  -8.18181801
  23009,   20.9256191,    38.092823,  -8.18181801
  23010,   21.8512402,    38.092823,  -8.18181801
  23011,   22.7768593,    38.092823,  -8.18181801
  23012,   23.7024803,    38.092823,  -8.18181801
  23013,   24.6280994,    38.092823,  -8.18181801
  23014,   25.5537186,    38.092823,  -8.18181801
  23015,   26.4429741,    38.092823,  -8.18181801
  23016,   27.3322315,    38.092823,  -8.18181801
  23017,    28.221487,    38.092823,  -8.18181801
  23018,   29.1107445,    38.092823,  -8.18181801
  23019,   20.9256191,   38.8842087,  -8.18181801
  23020,   21.8512402,   38.8842087,  -8.18181801
  23021,   22.7768593,   38.8842087,  -8.18181801
  23022,   23.7024803,   38.8842087,  -8.18181801
  23023,   24.6280994,   38.8842087,  -8.18181801
  23024,   25.5537186,   38.8842087,  -8.18181801
  23025,   26.4429741,   38.8842087,  -8.18181801
  23026,   27.3322315,   38.8842087,  -8.18181801
  23027,    28.221487,   38.8842087,  -8.18181801
  23028,   29.1107445,   38.8842087,  -8.18181801
  23029,   20.9256191,   39.6755981,  -8.18181801
  23030,   21.8512402,   39.6755981,  -8.18181801
  23031,   22.7768593,   39.6755981,  -8.18181801
  23032,   23.7024803,   39.6755981,  -8.18181801
  23033,   24.6280994,   39.6755981,  -8.18181801
  23034,   25.5537186,   39.6755981,  -8.18181801
  23035,   26.4429741,   39.6755981,  -8.18181801
  23036,   27.3322315,   39.6755981,  -8.18181801
  23037,    28.221487,   39.6755981,  -8.18181801
  23038,   29.1107445,   39.6755981,  -8.18181801
  23039,   20.9256191,   40.4669838,  -8.18181801
  23040,   21.8512402,   40.4669838,  -8.18181801
  23041,   22.7768593,   40.4669838,  -8.18181801
  23042,   23.7024803,   40.4669838,  -8.18181801
  23043,   24.6280994,   40.4669838,  -8.18181801
  23044,   25.5537186,   40.4669838,  -8.18181801
  23045,   26.4429741,   40.4669838,  -8.18181801
  23046,   27.3322315,   40.4669838,  -8.18181801
  23047,    28.221487,   40.4669838,  -8.18181801
  23048,   29.1107445,   40.4669838,  -8.18181801
  23049,   20.9256191,   41.2583733,  -8.18181801
  23050,   21.8512402,   41.2583733,  -8.18181801
  23051,   22.7768593,   41.2583733,  -8.18181801
  23052,   23.7024803,   41.2583733,  -8.18181801
  23053,   24.6280994,   41.2583733,  -8.18181801
  23054,   25.5537186,   41.2583733,  -8.18181801
  23055,   26.4429741,   41.2583733,  -8.18181801
  23056,   27.3322315,   41.2583733,  -8.18181801
  23057,    28.221487,   41.2583733,  -8.18181801
  23058,   29.1107445,   41.2583733,  -8.18181801
  23059,   20.9256191,   42.0497589,  -8.18181801
  23060,   21.8512402,   42.0497589,  -8.18181801
  23061,   22.7768593,   42.0497589,  -8.18181801
  23062,   23.7024803,   42.0497589,  -8.18181801
  23063,   24.6280994,   42.0497589,  -8.18181801
  23064,   25.5537186,   42.0497589,  -8.18181801
  23065,   26.4429741,   42.0497589,  -8.18181801
  23066,   27.3322315,   42.0497589,  -8.18181801
  23067,    28.221487,   42.0497589,  -8.18181801
  23068,   29.1107445,   42.0497589,  -8.18181801
  23069,   20.9256191,   42.8411484,  -8.18181801
  23070,   21.8512402,   42.8411484,  -8.18181801
  23071,   22.7768593,   42.8411484,  -8.18181801
  23072,   23.7024803,   42.8411484,  -8.18181801
  23073,   24.6280994,   42.8411484,  -8.18181801
  23074,   25.5537186,   42.8411484,  -8.18181801
  23075,   26.4429741,   42.8411484,  -8.18181801
  23076,   27.3322315,   42.8411484,  -8.18181801
  23077,    28.221487,   42.8411484,  -8.18181801
  23078,   29.1107445,   42.8411484,  -8.18181801
  23079,   20.9256191,    43.632534,  -8.18181801
  23080,   21.8512402,    43.632534,  -8.18181801
  23081,   22.7768593,    43.632534,  -8.18181801
  23082,   23.7024803,    43.632534,  -8.18181801
  23083,   24.6280994,    43.632534,  -8.18181801
  23084,   25.5537186,    43.632534,  -8.18181801
  23085,   26.4429741,    43.632534,  -8.18181801
  23086,   27.3322315,    43.632534,  -8.18181801
  23087,    28.221487,    43.632534,  -8.18181801
  23088,   29.1107445,    43.632534,  -8.18181801
  23089,   20.9256191,   44.4239235,  -8.18181801
  23090,   21.8512402,   44.4239235,  -8.18181801
  23091,   22.7768593,   44.4239235,  -8.18181801
  23092,   23.7024803,   44.4239235,  -8.18181801
  23093,   24.6280994,   44.4239235,  -8.18181801
  23094,   25.5537186,   44.4239235,  -8.18181801
  23095,   26.4429741,   44.4239235,  -8.18181801
  23096,   27.3322315,   44.4239235,  -8.18181801
  23097,    28.221487,   44.4239235,  -8.18181801
  23098,   29.1107445,   44.4239235,  -8.18181801
  23099,   20.9256191,   45.2153091,  -8.18181801
  23100,   21.8512402,   45.2153091,  -8.18181801
  23101,   22.7768593,   45.2153091,  -8.18181801
  23102,   23.7024803,   45.2153091,  -8.18181801
  23103,   24.6280994,   45.2153091,  -8.18181801
  23104,   25.5537186,   45.2153091,  -8.18181801
  23105,   26.4429741,   45.2153091,  -8.18181801
  23106,   27.3322315,   45.2153091,  -8.18181801
  23107,    28.221487,   45.2153091,  -8.18181801
  23108,   29.1107445,   45.2153091,  -8.18181801
  23109,   20.9228649,   46.0127602,  -8.18181801
  23110,   21.8457298,   46.0127602,  -8.18181801
  23111,   22.7685947,   46.0127602,  -8.18181801
  23112,   23.6914597,   46.0127602,  -8.18181801
  23113,   24.6143246,   46.0127602,  -8.18181801
  23114,   25.5371895,   46.0127602,  -8.18181801
  23115,   26.4297523,   46.0127602,  -8.18181801
  23116,   27.3223152,   46.0127602,  -8.18181801
  23117,   28.2148762,   46.0127602,  -8.18181801
  23118,    29.107439,   46.0127602,  -8.18181801
  23119,   20.9201088,   46.8102074,  -8.18181801
  23120,   21.8402214,   46.8102074,  -8.18181801
  23121,   22.7603302,   46.8102074,  -8.18181801
  23122,   23.6804409,   46.8102074,  -8.18181801
  23123,   24.6005497,   46.8102074,  -8.18181801
  23124,   25.5206623,   46.8102074,  -8.18181801
  23125,   26.4165287,   46.8102074,  -8.18181801
  23126,    27.312397,   46.8102074,  -8.18181801
  23127,   28.2082634,   46.8102074,  -8.18181801
  23128,   29.1041336,   46.8102074,  -8.18181801
  23129,   20.9173546,   47.6076546,  -8.18181801
  23130,   21.8347111,   47.6076546,  -8.18181801
  23131,   22.7520657,   47.6076546,  -8.18181801
  23132,   23.6694221,   47.6076546,  -8.18181801
  23133,   24.5867767,   47.6076546,  -8.18181801
  23134,   25.5041332,   47.6076546,  -8.18181801
  23135,   26.4033051,   47.6076546,  -8.18181801
  23136,   27.3024807,   47.6076546,  -8.18181801
  23137,   28.2016525,   47.6076546,  -8.18181801
  23138,   29.1008263,   47.6076546,  -8.18181801
  23139,   20.9146004,   48.4051018,  -8.18181801
  23140,   21.8292007,   48.4051018,  -8.18181801
  23141,   22.7438011,   48.4051018,  -8.18181801
  23142,   23.6584034,   48.4051018,  -8.18181801
  23143,   24.5730019,   48.4051018,  -8.18181801
  23144,   25.4876041,   48.4051018,  -8.18181801
  23145,   26.3900814,   48.4051018,  -8.18181801
  23146,   27.2925625,   48.4051018,  -8.18181801
  23147,   28.1950417,   48.4051018,  -8.18181801
  23148,   29.0975208,   48.4051018,  -8.18181801
  23149,   20.9118443,   49.2025528,  -8.18181801
  23150,   21.8236923,   49.2025528,  -8.18181801
  23151,   22.7355366,   49.2025528,  -8.18181801
  23152,   23.6473827,   49.2025528,  -8.18181801
  23153,   24.5592289,   49.2025528,  -8.18181801
  23154,   25.4710751,   49.2025528,  -8.18181801
  23155,   26.3768597,   49.2025528,  -8.18181801
  23156,   27.2826443,   49.2025528,  -8.18181801
  23157,   28.1884289,   49.2025528,  -8.18181801
  23158,   29.0942154,   49.2025528,  -8.18181801
  23159,   20.9102707,   20.7826385,    -9.090909
  23160,   21.8205433,   20.7826385,    -9.090909
  23161,    22.730814,   20.7826385,    -9.090909
  23162,   23.6410866,   20.7826385,    -9.090909
  23163,   24.5513573,   20.7826385,    -9.090909
  23164,   25.4616299,   20.7826385,    -9.090909
  23165,   26.3693027,   20.7826385,    -9.090909
  23166,   27.2769775,   20.7826385,    -9.090909
  23167,   28.1846523,   20.7826385,    -9.090909
  23168,   29.0923271,   20.7826385,    -9.090909
  23169,   20.9114513,   21.5652771,    -9.090909
  23170,   21.8229046,   21.5652771,    -9.090909
  23171,   22.7343559,   21.5652771,    -9.090909
  23172,   23.6458092,   21.5652771,    -9.090909
  23173,   24.5572605,   21.5652771,    -9.090909
  23174,   25.4687138,   21.5652771,    -9.090909
  23175,   26.3749695,   21.5652771,    -9.090909
  23176,    27.281229,   21.5652771,    -9.090909
  23177,   28.1874847,   21.5652771,    -9.090909
  23178,   29.0937443,   21.5652771,    -9.090909
  23179,    20.912632,   22.3479156,    -9.090909
  23180,   21.8252659,   22.3479156,    -9.090909
  23181,   22.7378979,   22.3479156,    -9.090909
  23182,   23.6505318,   22.3479156,    -9.090909
  23183,   24.5631638,   22.3479156,    -9.090909
  23184,   25.4757977,   22.3479156,    -9.090909
  23185,   26.3806381,   22.3479156,    -9.090909
  23186,   27.2854786,   22.3479156,    -9.090909
  23187,   28.1903191,   22.3479156,    -9.090909
  23188,   29.0951595,   22.3479156,    -9.090909
  23189,   20.9138126,   23.1305542,    -9.090909
  23190,   21.8276272,   23.1305542,    -9.090909
  23191,   22.7414398,   23.1305542,    -9.090909
  23192,   23.6552544,   23.1305542,    -9.090909
  23193,    24.569067,   23.1305542,    -9.090909
  23194,   25.4828815,   23.1305542,    -9.090909
  23195,   26.3863049,   23.1305542,    -9.090909
  23196,   27.2897282,   23.1305542,    -9.090909
  23197,   28.1931515,   23.1305542,    -9.090909
  23198,   29.0965767,   23.1305542,    -9.090909
  23199,   20.9149933,   23.9131927,    -9.090909
  23200,   21.8299885,   23.9131927,    -9.090909
  23201,   22.7449818,   23.9131927,    -9.090909
  23202,    23.659977,   23.9131927,    -9.090909
  23203,   24.5749702,   23.9131927,    -9.090909
  23204,   25.4899654,   23.9131927,    -9.090909
  23205,   26.3919716,   23.9131927,    -9.090909
  23206,   27.2939796,   23.9131927,    -9.090909
  23207,   28.1959858,   23.9131927,    -9.090909
  23208,   29.0979939,   23.9131927,    -9.090909
  23209,   20.9161739,   24.6958313,    -9.090909
  23210,   21.8323498,   24.6958313,    -9.090909
  23211,   22.7485237,   24.6958313,    -9.090909
  23212,   23.6646996,   24.6958313,    -9.090909
  23213,   24.5808735,   24.6958313,    -9.090909
  23214,   25.4970493,   24.6958313,    -9.090909
  23215,   26.3976383,   24.6958313,    -9.090909
  23216,   27.2982292,   24.6958313,    -9.090909
  23217,   28.1988201,   24.6958313,    -9.090909
  23218,    29.099411,   24.6958313,    -9.090909
  23219,   20.9173546,   25.4784698,    -9.090909
  23220,   21.8347111,   25.4784698,    -9.090909
  23221,   22.7520657,   25.4784698,    -9.090909
  23222,   23.6694221,   25.4784698,    -9.090909
  23223,   24.5867767,   25.4784698,    -9.090909
  23224,   25.5041332,   25.4784698,    -9.090909
  23225,   26.4033051,   25.4784698,    -9.090909
  23226,   27.3024807,   25.4784698,    -9.090909
  23227,   28.2016525,   25.4784698,    -9.090909
  23228,   29.1008282,   25.4784698,    -9.090909
  23229,   20.9173546,   26.2688999,    -9.090909
  23230,   21.8347111,   26.2688999,    -9.090909
  23231,   22.7520657,   26.2688999,    -9.090909
  23232,   23.6694221,   26.2688999,    -9.090909
  23233,   24.5867767,   26.2688999,    -9.090909
  23234,   25.5041332,   26.2688999,    -9.090909
  23235,   26.4033051,   26.2688999,    -9.090909
  23236,   27.3024807,   26.2688999,    -9.090909
  23237,   28.2016525,   26.2688999,    -9.090909
  23238,   29.1008282,   26.2688999,    -9.090909
  23239,   20.9173546,     27.05933,    -9.090909
  23240,   21.8347111,     27.05933,    -9.090909
  23241,   22.7520657,     27.05933,    -9.090909
  23242,   23.6694221,     27.05933,    -9.090909
  23243,   24.5867767,     27.05933,    -9.090909
  23244,   25.5041332,     27.05933,    -9.090909
  23245,   26.4033051,     27.05933,    -9.090909
  23246,   27.3024807,     27.05933,    -9.090909
  23247,   28.2016525,     27.05933,    -9.090909
  23248,   29.1008282,     27.05933,    -9.090909
  23249,   20.9173546,   27.8497601,    -9.090909
  23250,   21.8347111,   27.8497601,    -9.090909
  23251,   22.7520657,   27.8497601,    -9.090909
  23252,   23.6694221,   27.8497601,    -9.090909
  23253,   24.5867767,   27.8497601,    -9.090909
  23254,   25.5041332,   27.8497601,    -9.090909
  23255,   26.4033051,   27.8497601,    -9.090909
  23256,   27.3024807,   27.8497601,    -9.090909
  23257,   28.2016525,   27.8497601,    -9.090909
  23258,   29.1008282,   27.8497601,    -9.090909
  23259,   20.9173546,    28.640192,    -9.090909
  23260,   21.8347111,    28.640192,    -9.090909
  23261,   22.7520657,    28.640192,    -9.090909
  23262,   23.6694221,    28.640192,    -9.090909
  23263,   24.5867767,    28.640192,    -9.090909
  23264,   25.5041332,    28.640192,    -9.090909
  23265,   26.4033051,    28.640192,    -9.090909
  23266,   27.3024807,    28.640192,    -9.090909
  23267,   28.2016525,    28.640192,    -9.090909
  23268,   29.1008282,    28.640192,    -9.090909
  23269,   20.9173546,   29.4306221,    -9.090909
  23270,   21.8347111,   29.4306221,    -9.090909
  23271,   22.7520657,   29.4306221,    -9.090909
  23272,   23.6694221,   29.4306221,    -9.090909
  23273,   24.5867767,   29.4306221,    -9.090909
  23274,   25.5041332,   29.4306221,    -9.090909
  23275,   26.4033051,   29.4306221,    -9.090909
  23276,   27.3024807,   29.4306221,    -9.090909
  23277,   28.2016525,   29.4306221,    -9.090909
  23278,   29.1008282,   29.4306221,    -9.090909
  23279,   20.9173546,   30.2210522,    -9.090909
  23280,   21.8347111,   30.2210522,    -9.090909
  23281,   22.7520657,   30.2210522,    -9.090909
  23282,   23.6694221,   30.2210522,    -9.090909
  23283,   24.5867767,   30.2210522,    -9.090909
  23284,   25.5041332,   30.2210522,    -9.090909
  23285,   26.4033051,   30.2210522,    -9.090909
  23286,   27.3024807,   30.2210522,    -9.090909
  23287,   28.2016525,   30.2210522,    -9.090909
  23288,   29.1008282,   30.2210522,    -9.090909
  23289,   20.9173546,   31.0114841,    -9.090909
  23290,   21.8347111,   31.0114841,    -9.090909
  23291,   22.7520657,   31.0114841,    -9.090909
  23292,   23.6694221,   31.0114841,    -9.090909
  23293,   24.5867767,   31.0114841,    -9.090909
  23294,   25.5041332,   31.0114841,    -9.090909
  23295,   26.4033051,   31.0114841,    -9.090909
  23296,   27.3024807,   31.0114841,    -9.090909
  23297,   28.2016525,   31.0114841,    -9.090909
  23298,   29.1008282,   31.0114841,    -9.090909
  23299,   20.9173546,   31.8019142,    -9.090909
  23300,   21.8347111,   31.8019142,    -9.090909
  23301,   22.7520657,   31.8019142,    -9.090909
  23302,   23.6694221,   31.8019142,    -9.090909
  23303,   24.5867767,   31.8019142,    -9.090909
  23304,   25.5041332,   31.8019142,    -9.090909
  23305,   26.4033051,   31.8019142,    -9.090909
  23306,   27.3024807,   31.8019142,    -9.090909
  23307,   28.2016525,   31.8019142,    -9.090909
  23308,   29.1008282,   31.8019142,    -9.090909
  23309,   20.9173546,   32.5923462,    -9.090909
  23310,   21.8347111,   32.5923462,    -9.090909
  23311,   22.7520657,   32.5923462,    -9.090909
  23312,   23.6694221,   32.5923462,    -9.090909
  23313,   24.5867767,   32.5923462,    -9.090909
  23314,   25.5041332,   32.5923462,    -9.090909
  23315,   26.4033051,   32.5923462,    -9.090909
  23316,   27.3024807,   32.5923462,    -9.090909
  23317,   28.2016525,   32.5923462,    -9.090909
  23318,   29.1008282,   32.5923462,    -9.090909
  23319,   20.9173546,   33.3827744,    -9.090909
  23320,   21.8347111,   33.3827744,    -9.090909
  23321,   22.7520657,   33.3827744,    -9.090909
  23322,   23.6694221,   33.3827744,    -9.090909
  23323,   24.5867767,   33.3827744,    -9.090909
  23324,   25.5041332,   33.3827744,    -9.090909
  23325,   26.4033051,   33.3827744,    -9.090909
  23326,   27.3024807,   33.3827744,    -9.090909
  23327,   28.2016525,   33.3827744,    -9.090909
  23328,   29.1008282,   33.3827744,    -9.090909
  23329,   20.9173546,   34.1732063,    -9.090909
  23330,   21.8347111,   34.1732063,    -9.090909
  23331,   22.7520657,   34.1732063,    -9.090909
  23332,   23.6694221,   34.1732063,    -9.090909
  23333,   24.5867767,   34.1732063,    -9.090909
  23334,   25.5041332,   34.1732063,    -9.090909
  23335,   26.4033051,   34.1732063,    -9.090909
  23336,   27.3024807,   34.1732063,    -9.090909
  23337,   28.2016525,   34.1732063,    -9.090909
  23338,   29.1008282,   34.1732063,    -9.090909
  23339,   20.9173546,   34.9636345,    -9.090909
  23340,   21.8347111,   34.9636345,    -9.090909
  23341,   22.7520657,   34.9636345,    -9.090909
  23342,   23.6694221,   34.9636345,    -9.090909
  23343,   24.5867767,   34.9636345,    -9.090909
  23344,   25.5041332,   34.9636345,    -9.090909
  23345,   26.4033051,   34.9636345,    -9.090909
  23346,   27.3024807,   34.9636345,    -9.090909
  23347,   28.2016525,   34.9636345,    -9.090909
  23348,   29.1008282,   34.9636345,    -9.090909
  23349,   20.9173546,   35.7540665,    -9.090909
  23350,   21.8347111,   35.7540665,    -9.090909
  23351,   22.7520657,   35.7540665,    -9.090909
  23352,   23.6694221,   35.7540665,    -9.090909
  23353,   24.5867767,   35.7540665,    -9.090909
  23354,   25.5041332,   35.7540665,    -9.090909
  23355,   26.4033051,   35.7540665,    -9.090909
  23356,   27.3024807,   35.7540665,    -9.090909
  23357,   28.2016525,   35.7540665,    -9.090909
  23358,   29.1008282,   35.7540665,    -9.090909
  23359,   20.9173546,   36.5444984,    -9.090909
  23360,   21.8347111,   36.5444984,    -9.090909
  23361,   22.7520657,   36.5444984,    -9.090909
  23362,   23.6694221,   36.5444984,    -9.090909
  23363,   24.5867767,   36.5444984,    -9.090909
  23364,   25.5041332,   36.5444984,    -9.090909
  23365,   26.4033051,   36.5444984,    -9.090909
  23366,   27.3024807,   36.5444984,    -9.090909
  23367,   28.2016525,   36.5444984,    -9.090909
  23368,   29.1008282,   36.5444984,    -9.090909
  23369,   20.9173546,   37.3349266,    -9.090909
  23370,   21.8347111,   37.3349266,    -9.090909
  23371,   22.7520657,   37.3349266,    -9.090909
  23372,   23.6694221,   37.3349266,    -9.090909
  23373,   24.5867767,   37.3349266,    -9.090909
  23374,   25.5041332,   37.3349266,    -9.090909
  23375,   26.4033051,   37.3349266,    -9.090909
  23376,   27.3024807,   37.3349266,    -9.090909
  23377,   28.2016525,   37.3349266,    -9.090909
  23378,   29.1008282,   37.3349266,    -9.090909
  23379,   20.9173546,   38.1253586,    -9.090909
  23380,   21.8347111,   38.1253586,    -9.090909
  23381,   22.7520657,   38.1253586,    -9.090909
  23382,   23.6694221,   38.1253586,    -9.090909
  23383,   24.5867767,   38.1253586,    -9.090909
  23384,   25.5041332,   38.1253586,    -9.090909
  23385,   26.4033051,   38.1253586,    -9.090909
  23386,   27.3024807,   38.1253586,    -9.090909
  23387,   28.2016525,   38.1253586,    -9.090909
  23388,   29.1008282,   38.1253586,    -9.090909
  23389,   20.9173546,   38.9157906,    -9.090909
  23390,   21.8347111,   38.9157906,    -9.090909
  23391,   22.7520657,   38.9157906,    -9.090909
  23392,   23.6694221,   38.9157906,    -9.090909
  23393,   24.5867767,   38.9157906,    -9.090909
  23394,   25.5041332,   38.9157906,    -9.090909
  23395,   26.4033051,   38.9157906,    -9.090909
  23396,   27.3024807,   38.9157906,    -9.090909
  23397,   28.2016525,   38.9157906,    -9.090909
  23398,   29.1008282,   38.9157906,    -9.090909
  23399,   20.9173546,   39.7062187,    -9.090909
  23400,   21.8347111,   39.7062187,    -9.090909
  23401,   22.7520657,   39.7062187,    -9.090909
  23402,   23.6694221,   39.7062187,    -9.090909
  23403,   24.5867767,   39.7062187,    -9.090909
  23404,   25.5041332,   39.7062187,    -9.090909
  23405,   26.4033051,   39.7062187,    -9.090909
  23406,   27.3024807,   39.7062187,    -9.090909
  23407,   28.2016525,   39.7062187,    -9.090909
  23408,   29.1008282,   39.7062187,    -9.090909
  23409,   20.9173546,   40.4966507,    -9.090909
  23410,   21.8347111,   40.4966507,    -9.090909
  23411,   22.7520657,   40.4966507,    -9.090909
  23412,   23.6694221,   40.4966507,    -9.090909
  23413,   24.5867767,   40.4966507,    -9.090909
  23414,   25.5041332,   40.4966507,    -9.090909
  23415,   26.4033051,   40.4966507,    -9.090909
  23416,   27.3024807,   40.4966507,    -9.090909
  23417,   28.2016525,   40.4966507,    -9.090909
  23418,   29.1008282,   40.4966507,    -9.090909
  23419,   20.9173546,   41.2870827,    -9.090909
  23420,   21.8347111,   41.2870827,    -9.090909
  23421,   22.7520657,   41.2870827,    -9.090909
  23422,   23.6694221,   41.2870827,    -9.090909
  23423,   24.5867767,   41.2870827,    -9.090909
  23424,   25.5041332,   41.2870827,    -9.090909
  23425,   26.4033051,   41.2870827,    -9.090909
  23426,   27.3024807,   41.2870827,    -9.090909
  23427,   28.2016525,   41.2870827,    -9.090909
  23428,   29.1008282,   41.2870827,    -9.090909
  23429,   20.9173546,   42.0775108,    -9.090909
  23430,   21.8347111,   42.0775108,    -9.090909
  23431,   22.7520657,   42.0775108,    -9.090909
  23432,   23.6694221,   42.0775108,    -9.090909
  23433,   24.5867767,   42.0775108,    -9.090909
  23434,   25.5041332,   42.0775108,    -9.090909
  23435,   26.4033051,   42.0775108,    -9.090909
  23436,   27.3024807,   42.0775108,    -9.090909
  23437,   28.2016525,   42.0775108,    -9.090909
  23438,   29.1008282,   42.0775108,    -9.090909
  23439,   20.9173546,   42.8679428,    -9.090909
  23440,   21.8347111,   42.8679428,    -9.090909
  23441,   22.7520657,   42.8679428,    -9.090909
  23442,   23.6694221,   42.8679428,    -9.090909
  23443,   24.5867767,   42.8679428,    -9.090909
  23444,   25.5041332,   42.8679428,    -9.090909
  23445,   26.4033051,   42.8679428,    -9.090909
  23446,   27.3024807,   42.8679428,    -9.090909
  23447,   28.2016525,   42.8679428,    -9.090909
  23448,   29.1008282,   42.8679428,    -9.090909
  23449,   20.9173546,   43.6583748,    -9.090909
  23450,   21.8347111,   43.6583748,    -9.090909
  23451,   22.7520657,   43.6583748,    -9.090909
  23452,   23.6694221,   43.6583748,    -9.090909
  23453,   24.5867767,   43.6583748,    -9.090909
  23454,   25.5041332,   43.6583748,    -9.090909
  23455,   26.4033051,   43.6583748,    -9.090909
  23456,   27.3024807,   43.6583748,    -9.090909
  23457,   28.2016525,   43.6583748,    -9.090909
  23458,   29.1008282,   43.6583748,    -9.090909
  23459,   20.9173546,   44.4488029,    -9.090909
  23460,   21.8347111,   44.4488029,    -9.090909
  23461,   22.7520657,   44.4488029,    -9.090909
  23462,   23.6694221,   44.4488029,    -9.090909
  23463,   24.5867767,   44.4488029,    -9.090909
  23464,   25.5041332,   44.4488029,    -9.090909
  23465,   26.4033051,   44.4488029,    -9.090909
  23466,   27.3024807,   44.4488029,    -9.090909
  23467,   28.2016525,   44.4488029,    -9.090909
  23468,   29.1008282,   44.4488029,    -9.090909
  23469,   20.9173546,   45.2392349,    -9.090909
  23470,   21.8347111,   45.2392349,    -9.090909
  23471,   22.7520657,   45.2392349,    -9.090909
  23472,   23.6694221,   45.2392349,    -9.090909
  23473,   24.5867767,   45.2392349,    -9.090909
  23474,   25.5041332,   45.2392349,    -9.090909
  23475,   26.4033051,   45.2392349,    -9.090909
  23476,   27.3024807,   45.2392349,    -9.090909
  23477,   28.2016525,   45.2392349,    -9.090909
  23478,   29.1008282,   45.2392349,    -9.090909
  23479,   20.9159775,   46.0326958,    -9.090909
  23480,   21.8319569,   46.0326958,    -9.090909
  23481,   22.7479324,   46.0326958,    -9.090909
  23482,   23.6639118,   46.0326958,    -9.090909
  23483,   24.5798893,   46.0326958,    -9.090909
  23484,   25.4958687,   46.0326958,    -9.090909
  23485,   26.3966942,   46.0326958,    -9.090909
  23486,   27.2975216,   46.0326958,    -9.090909
  23487,   28.1983471,   46.0326958,    -9.090909
  23488,   29.0991745,   46.0326958,    -9.090909
  23489,   20.9146004,   46.8261566,    -9.090909
  23490,   21.8292007,   46.8261566,    -9.090909
  23491,   22.7438011,   46.8261566,    -9.090909
  23492,   23.6584034,   46.8261566,    -9.090909
  23493,   24.5730019,   46.8261566,    -9.090909
  23494,   25.4876041,   46.8261566,    -9.090909
  23495,   26.3900814,   46.8261566,    -9.090909
  23496,   27.2925625,   46.8261566,    -9.090909
  23497,   28.1950417,   46.8261566,    -9.090909
  23498,   29.0975208,   46.8261566,    -9.090909
  23499,   20.9132233,   47.6196175,    -9.090909
  23500,   21.8264465,   47.6196175,    -9.090909
  23501,   22.7396679,   47.6196175,    -9.090909
  23502,   23.6528931,   47.6196175,    -9.090909
  23503,   24.5661144,   47.6196175,    -9.090909
  23504,   25.4793396,   47.6196175,    -9.090909
  23505,   26.3834705,   47.6196175,    -9.090909
  23506,   27.2876034,   47.6196175,    -9.090909
  23507,   28.1917362,   47.6196175,    -9.090909
  23508,   29.0958691,   47.6196175,    -9.090909
  23509,   20.9118443,   48.4130783,    -9.090909
  23510,   21.8236923,   48.4130783,    -9.090909
  23511,   22.7355366,   48.4130783,    -9.090909
  23512,   23.6473827,   48.4130783,    -9.090909
  23513,   24.5592289,   48.4130783,    -9.090909
  23514,   25.4710751,   48.4130783,    -9.090909
  23515,   26.3768597,   48.4130783,    -9.090909
  23516,   27.2826462,   48.4130783,    -9.090909
  23517,   28.1884289,   48.4130783,    -9.090909
  23518,   29.0942154,   48.4130783,    -9.090909
  23519,   20.9104671,   49.2065392,    -9.090909
  23520,   21.8209362,   49.2065392,    -9.090909
  23521,   22.7314053,   49.2065392,    -9.090909
  23522,   23.6418743,   49.2065392,    -9.090909
  23523,   24.5523415,   49.2065392,    -9.090909
  23524,   25.4628105,   49.2065392,    -9.090909
  23525,   26.3702469,   49.2065392,    -9.090909
  23526,   27.2776871,   49.2065392,    -9.090909
  23527,   28.1851234,   49.2065392,    -9.090909
  23528,   29.0925636,   49.2065392,    -9.090909
  23529,  -20.9084148,   20.7826385,    -9.090909
  23530,  -21.8168335,   20.7826385,    -9.090909
  23531,  -22.7252483,   20.7826385,    -9.090909
  23532,  -23.6336651,   20.7826385,    -9.090909
  23533,  -24.5420799,   20.7826385,    -9.090909
  23534,  -25.4504986,   20.7826385,    -9.090909
  23535,  -26.3589134,   20.7826385,    -9.090909
  23536,   -27.269186,   20.7826385,    -9.090909
  23537,  -28.1794567,   20.7826385,    -9.090909
  23538,  -29.0897293,   20.7826385,    -9.090909
  23539,  -20.9077415,   20.7758026,  -8.18181801
  23540,  -21.8154831,   20.7758026,  -8.18181801
  23541,  -22.7232246,   20.7758026,  -8.18181801
  23542,  -23.6309662,   20.7758026,  -8.18181801
  23543,  -24.5387077,   20.7758026,  -8.18181801
  23544,  -25.4464493,   20.7758026,  -8.18181801
  23545,  -26.3541908,   20.7758026,  -8.18181801
  23546,  -27.2656441,   20.7758026,  -8.18181801
  23547,  -28.1770954,   20.7758026,  -8.18181801
  23548,  -29.0885487,   20.7758026,  -8.18181801
  23549,  -20.9070663,   20.7689686,  -7.27272749
  23550,  -21.8141346,   20.7689686,  -7.27272749
  23551,  -22.7212009,   20.7689686,  -7.27272749
  23552,  -23.6282692,   20.7689686,  -7.27272749
  23553,  -24.5353336,   20.7689686,  -7.27272749
  23554,  -25.4424019,   20.7689686,  -7.27272749
  23555,  -26.3494682,   20.7689686,  -7.27272749
  23556,  -27.2621021,   20.7689686,  -7.27272749
  23557,  -28.1747341,   20.7689686,  -7.27272749
  23558,   -29.087368,   20.7689686,  -7.27272749
  23559,  -20.9063911,   20.7621326,  -6.36363649
  23560,  -21.8127842,   20.7621326,  -6.36363649
  23561,  -22.7191772,   20.7621326,  -6.36363649
  23562,  -23.6255703,   20.7621326,  -6.36363649
  23563,  -24.5319614,   20.7621326,  -6.36363649
  23564,  -25.4383545,   20.7621326,  -6.36363649
  23565,  -26.3447456,   20.7621326,  -6.36363649
  23566,  -27.2585602,   20.7621326,  -6.36363649
  23567,  -28.1723728,   20.7621326,  -6.36363649
  23568,  -29.0861874,   20.7621326,  -6.36363649
  23569,  -20.9057178,   20.7552967,   -5.4545455
  23570,  -21.8114357,   20.7552967,   -5.4545455
  23571,  -22.7171535,   20.7552967,   -5.4545455
  23572,  -23.6228714,   20.7552967,   -5.4545455
  23573,  -24.5285873,   20.7552967,   -5.4545455
  23574,  -25.4343071,   20.7552967,   -5.4545455
  23575,   -26.340023,   20.7552967,   -5.4545455
  23576,  -27.2550182,   20.7552967,   -5.4545455
  23577,  -28.1700115,   20.7552967,   -5.4545455
  23578,  -29.0850067,   20.7552967,   -5.4545455
  23579,  -20.9050426,   20.7484627,   -4.5454545
  23580,  -21.8100853,   20.7484627,   -4.5454545
  23581,  -22.7151279,   20.7484627,   -4.5454545
  23582,  -23.6201725,   20.7484627,   -4.5454545
  23583,  -24.5252151,   20.7484627,   -4.5454545
  23584,  -25.4302578,   20.7484627,   -4.5454545
  23585,  -26.3353004,   20.7484627,   -4.5454545
  23586,  -27.2514763,   20.7484627,   -4.5454545
  23587,  -28.1676502,   20.7484627,   -4.5454545
  23588,  -29.0838261,   20.7484627,   -4.5454545
  23589,  -20.9043694,   20.7416267,  -3.63636374
  23590,  -21.8087368,   20.7416267,  -3.63636374
  23591,  -22.7131042,   20.7416267,  -3.63636374
  23592,  -23.6174736,   20.7416267,  -3.63636374
  23593,   -24.521841,   20.7416267,  -3.63636374
  23594,  -25.4262104,   20.7416267,  -3.63636374
  23595,  -26.3305779,   20.7416267,  -3.63636374
  23596,  -27.2479343,   20.7416267,  -3.63636374
  23597,  -28.1652889,   20.7416267,  -3.63636374
  23598,  -29.0826454,   20.7416267,  -3.63636374
  23599,  -20.9036942,   20.7347908,  -2.72727275
  23600,  -21.8073864,   20.7347908,  -2.72727275
  23601,  -22.7110806,   20.7347908,  -2.72727275
  23602,  -23.6147747,   20.7347908,  -2.72727275
  23603,  -24.5184689,   20.7347908,  -2.72727275
  23604,   -25.422163,   20.7347908,  -2.72727275
  23605,  -26.3258553,   20.7347908,  -2.72727275
  23606,  -27.2443924,   20.7347908,  -2.72727275
  23607,  -28.1629276,   20.7347908,  -2.72727275
  23608,  -29.0814648,   20.7347908,  -2.72727275
  23609,   -20.903019,   20.7279568,  -1.81818187
  23610,  -21.8060379,   20.7279568,  -1.81818187
  23611,  -22.7090569,   20.7279568,  -1.81818187
  23612,  -23.6120777,   20.7279568,  -1.81818187
  23613,  -24.5150948,   20.7279568,  -1.81818187
  23614,  -25.4181156,   20.7279568,  -1.81818187
  23615,  -26.3211327,   20.7279568,  -1.81818187
  23616,  -27.2408504,   20.7279568,  -1.81818187
  23617,  -28.1605663,   20.7279568,  -1.81818187
  23618,  -29.0802841,   20.7279568,  -1.81818187
  23619,  -20.9023457,   20.7211208, -0.909090936
  23620,  -21.8046875,   20.7211208, -0.909090936
  23621,  -22.7070332,   20.7211208, -0.909090936
  23622,  -23.6093788,   20.7211208, -0.909090936
  23623,  -24.5117226,   20.7211208, -0.909090936
  23624,  -25.4140663,   20.7211208, -0.909090936
  23625,  -26.3164101,   20.7211208, -0.909090936
  23626,  -27.2373085,   20.7211208, -0.909090936
  23627,   -28.158205,   20.7211208, -0.909090936
  23628,  -29.0791035,   20.7211208, -0.909090936
  23629,  -20.9077415,   21.5652771,    -9.090909
  23630,  -21.8154831,   21.5652771,    -9.090909
  23631,  -22.7232246,   21.5652771,    -9.090909
  23632,  -23.6309662,   21.5652771,    -9.090909
  23633,  -24.5387077,   21.5652771,    -9.090909
  23634,  -25.4464493,   21.5652771,    -9.090909
  23635,  -26.3541908,   21.5652771,    -9.090909
  23636,  -27.2656441,   21.5652771,    -9.090909
  23637,  -28.1770954,   21.5652771,    -9.090909
  23638,  -29.0885487,   21.5652771,    -9.090909
  23639,  -20.9063911,   21.5516071,  -8.18181801
  23640,  -21.8127842,   21.5516071,  -8.18181801
  23641,  -22.7191753,   21.5516071,  -8.18181801
  23642,  -23.6255703,   21.5516071,  -8.18181801
  23643,  -24.5319614,   21.5516071,  -8.18181801
  23644,  -25.4383545,   21.5516071,  -8.18181801
  23645,  -26.3447456,   21.5516071,  -8.18181801
  23646,  -27.2585602,   21.5516071,  -8.18181801
  23647,  -28.1723728,   21.5516071,  -8.18181801
  23648,  -29.0861874,   21.5516071,  -8.18181801
  23649,  -20.9050426,   21.5379353,  -7.27272749
  23650,  -21.8100872,   21.5379353,  -7.27272749
  23651,  -22.7151279,   21.5379353,  -7.27272749
  23652,  -23.6201725,   21.5379353,  -7.27272749
  23653,  -24.5252151,   21.5379353,  -7.27272749
  23654,  -25.4302578,   21.5379353,  -7.27272749
  23655,  -26.3353004,   21.5379353,  -7.27272749
  23656,  -27.2514763,   21.5379353,  -7.27272749
  23657,  -28.1676502,   21.5379353,  -7.27272749
  23658,  -29.0838261,   21.5379353,  -7.27272749
  23659,  -20.9036942,   21.5242653,  -6.36363649
  23660,  -21.8073883,   21.5242653,  -6.36363649
  23661,  -22.7110806,   21.5242653,  -6.36363649
  23662,  -23.6147747,   21.5242653,  -6.36363649
  23663,  -24.5184689,   21.5242653,  -6.36363649
  23664,   -25.422163,   21.5242653,  -6.36363649
  23665,  -26.3258553,   21.5242653,  -6.36363649
  23666,  -27.2443924,   21.5242653,  -6.36363649
  23667,  -28.1629276,   21.5242653,  -6.36363649
  23668,  -29.0814648,   21.5242653,  -6.36363649
  23669,  -20.9023438,   21.5105953,   -5.4545455
  23670,  -21.8046894,   21.5105953,   -5.4545455
  23671,  -22.7070332,   21.5105953,   -5.4545455
  23672,  -23.6093769,   21.5105953,   -5.4545455
  23673,  -24.5117226,   21.5105953,   -5.4545455
  23674,  -25.4140663,   21.5105953,   -5.4545455
  23675,  -26.3164101,   21.5105953,   -5.4545455
  23676,  -27.2373085,   21.5105953,   -5.4545455
  23677,   -28.158205,   21.5105953,   -5.4545455
  23678,  -29.0791035,   21.5105953,   -5.4545455
  23679,  -20.9009953,   21.4969234,   -4.5454545
  23680,  -21.8019905,   21.4969234,   -4.5454545
  23681,  -22.7029839,   21.4969234,   -4.5454545
  23682,   -23.603981,   21.4969234,   -4.5454545
  23683,  -24.5049744,   21.4969234,   -4.5454545
  23684,  -25.4059715,   21.4969234,   -4.5454545
  23685,  -26.3069668,   21.4969234,   -4.5454545
  23686,  -27.2302246,   21.4969234,   -4.5454545
  23687,  -28.1534824,   21.4969234,   -4.5454545
  23688,  -29.0767422,   21.4969234,   -4.5454545
  23689,  -20.8996449,   21.4832535,  -3.63636374
  23690,  -21.7992916,   21.4832535,  -3.63636374
  23691,  -22.6989365,   21.4832535,  -3.63636374
  23692,  -23.5985832,   21.4832535,  -3.63636374
  23693,  -24.4982281,   21.4832535,  -3.63636374
  23694,  -25.3978748,   21.4832535,  -3.63636374
  23695,  -26.2975216,   21.4832535,  -3.63636374
  23696,  -27.2231407,   21.4832535,  -3.63636374
  23697,  -28.1487598,   21.4832535,  -3.63636374
  23698,  -29.0743809,   21.4832535,  -3.63636374
  23699,  -20.8982964,   21.4695835,  -2.72727275
  23700,  -21.7965927,   21.4695835,  -2.72727275
  23701,  -22.6948891,   21.4695835,  -2.72727275
  23702,  -23.5931854,   21.4695835,  -2.72727275
  23703,  -24.4914818,   21.4695835,  -2.72727275
  23704,    -25.38978,   21.4695835,  -2.72727275
  23705,  -26.2880764,   21.4695835,  -2.72727275
  23706,  -27.2160568,   21.4695835,  -2.72727275
  23707,  -28.1440372,   21.4695835,  -2.72727275
  23708,  -29.0720196,   21.4695835,  -2.72727275
  23709,  -20.8969479,   21.4559116,  -1.81818187
  23710,  -21.7938957,   21.4559116,  -1.81818187
  23711,  -22.6908417,   21.4559116,  -1.81818187
  23712,  -23.5877876,   21.4559116,  -1.81818187
  23713,  -24.4847355,   21.4559116,  -1.81818187
  23714,  -25.3816833,   21.4559116,  -1.81818187
  23715,  -26.2786312,   21.4559116,  -1.81818187
  23716,  -27.2089729,   21.4559116,  -1.81818187
  23717,  -28.1393147,   21.4559116,  -1.81818187
  23718,  -29.0696583,   21.4559116,  -1.81818187
  23719,  -20.8955975,   21.4422417, -0.909090936
  23720,  -21.7911968,   21.4422417, -0.909090936
  23721,  -22.6867924,   21.4422417, -0.909090936
  23722,  -23.5823917,   21.4422417, -0.909090936
  23723,  -24.4779892,   21.4422417, -0.909090936
  23724,  -25.3735886,   21.4422417, -0.909090936
  23725,   -26.269186,   21.4422417, -0.909090936
  23726,   -27.201889,   21.4422417, -0.909090936
  23727,  -28.1345921,   21.4422417, -0.909090936
  23728,   -29.067297,   21.4422417, -0.909090936
  23729,  -20.9070663,   22.3479156,    -9.090909
  23730,  -21.8141346,   22.3479156,    -9.090909
  23731,  -22.7212009,   22.3479156,    -9.090909
  23732,  -23.6282673,   22.3479156,    -9.090909
  23733,  -24.5353336,   22.3479156,    -9.090909
  23734,  -25.4424019,   22.3479156,    -9.090909
  23735,  -26.3494682,   22.3479156,    -9.090909
  23736,  -27.2621021,   22.3479156,    -9.090909
  23737,  -28.1747341,   22.3479156,    -9.090909
  23738,   -29.087368,   22.3479156,    -9.090909
  23739,  -20.9050426,   22.3274097,  -8.18181801
  23740,  -21.8100853,   22.3274097,  -8.18181801
  23741,  -22.7151279,   22.3274097,  -8.18181801
  23742,  -23.6201725,   22.3274097,  -8.18181801
  23743,  -24.5252151,   22.3274097,  -8.18181801
  23744,  -25.4302578,   22.3274097,  -8.18181801
  23745,  -26.3353004,   22.3274097,  -8.18181801
  23746,  -27.2514763,   22.3274097,  -8.18181801
  23747,  -28.1676502,   22.3274097,  -8.18181801
  23748,  -29.0838261,   22.3274097,  -8.18181801
  23749,   -20.903019,   22.3069038,  -7.27272749
  23750,  -21.8060379,   22.3069038,  -7.27272749
  23751,  -22.7090569,   22.3069038,  -7.27272749
  23752,  -23.6120758,   22.3069038,  -7.27272749
  23753,  -24.5150948,   22.3069038,  -7.27272749
  23754,  -25.4181156,   22.3069038,  -7.27272749
  23755,  -26.3211327,   22.3069038,  -7.27272749
  23756,  -27.2408504,   22.3069038,  -7.27272749
  23757,  -28.1605663,   22.3069038,  -7.27272749
  23758,  -29.0802841,   22.3069038,  -7.27272749
  23759,  -20.9009953,   22.2863979,  -6.36363649
  23760,  -21.8019905,   22.2863979,  -6.36363649
  23761,  -22.7029858,   22.2863979,  -6.36363649
  23762,   -23.603981,   22.2863979,  -6.36363649
  23763,  -24.5049744,   22.2863979,  -6.36363649
  23764,  -25.4059715,   22.2863979,  -6.36363649
  23765,  -26.3069649,   22.2863979,  -6.36363649
  23766,  -27.2302246,   22.2863979,  -6.36363649
  23767,  -28.1534824,   22.2863979,  -6.36363649
  23768,  -29.0767422,   22.2863979,  -6.36363649
  23769,  -20.8989716,    22.265892,   -5.4545455
  23770,  -21.7979431,    22.265892,   -5.4545455
  23771,  -22.6969128,    22.265892,   -5.4545455
  23772,  -23.5958843,    22.265892,   -5.4545455
  23773,  -24.4948559,    22.265892,   -5.4545455
  23774,  -25.3938274,    22.265892,   -5.4545455
  23775,  -26.2927971,    22.265892,   -5.4545455
  23776,  -27.2195988,    22.265892,   -5.4545455
  23777,  -28.1463985,    22.265892,   -5.4545455
  23778,  -29.0732002,    22.265892,   -5.4545455
  23779,   -20.896946,   22.2453861,   -4.5454545
  23780,  -21.7938938,   22.2453861,   -4.5454545
  23781,  -22.6908417,   22.2453861,   -4.5454545
  23782,  -23.5877895,   22.2453861,   -4.5454545
  23783,  -24.4847355,   22.2453861,   -4.5454545
  23784,  -25.3816833,   22.2453861,   -4.5454545
  23785,  -26.2786312,   22.2453861,   -4.5454545
  23786,  -27.2089729,   22.2453861,   -4.5454545
  23787,  -28.1393147,   22.2453861,   -4.5454545
  23788,  -29.0696583,   22.2453861,   -4.5454545
  23789,  -20.8949223,   22.2248802,  -3.63636374
  23790,  -21.7898464,   22.2248802,  -3.63636374
  23791,  -22.6847687,   22.2248802,  -3.63636374
  23792,  -23.5796928,   22.2248802,  -3.63636374
  23793,   -24.474617,   22.2248802,  -3.63636374
  23794,  -25.3695393,   22.2248802,  -3.63636374
  23795,  -26.2644634,   22.2248802,  -3.63636374
  23796,  -27.1983471,   22.2248802,  -3.63636374
  23797,  -28.1322308,   22.2248802,  -3.63636374
  23798,  -29.0661163,   22.2248802,  -3.63636374
  23799,  -20.8928986,   22.2043743,  -2.72727275
  23800,   -21.785799,   22.2043743,  -2.72727275
  23801,  -22.6786976,   22.2043743,  -2.72727275
  23802,  -23.5715981,   22.2043743,  -2.72727275
  23803,  -24.4644966,   22.2043743,  -2.72727275
  23804,  -25.3573952,   22.2043743,  -2.72727275
  23805,  -26.2502956,   22.2043743,  -2.72727275
  23806,  -27.1877213,   22.2043743,  -2.72727275
  23807,  -28.1251469,   22.2043743,  -2.72727275
  23808,  -29.0625744,   22.2043743,  -2.72727275
  23809,  -20.8908749,   22.1838684,  -1.81818187
  23810,  -21.7817516,   22.1838684,  -1.81818187
  23811,  -22.6726265,   22.1838684,  -1.81818187
  23812,  -23.5635014,   22.1838684,  -1.81818187
  23813,  -24.4543762,   22.1838684,  -1.81818187
  23814,   -25.345253,   22.1838684,  -1.81818187
  23815,  -26.2361279,   22.1838684,  -1.81818187
  23816,  -27.1770954,   22.1838684,  -1.81818187
  23817,   -28.118063,   22.1838684,  -1.81818187
  23818,  -29.0590324,   22.1838684,  -1.81818187
  23819,  -20.8888512,   22.1633625, -0.909090936
  23820,  -21.7777023,   22.1633625, -0.909090936
  23821,  -22.6665535,   22.1633625, -0.909090936
  23822,  -23.5554066,   22.1633625, -0.909090936
  23823,  -24.4442577,   22.1633625, -0.909090936
  23824,  -25.3331089,   22.1633625, -0.909090936
  23825,  -26.2219601,   22.1633625, -0.909090936
  23826,  -27.1664696,   22.1633625, -0.909090936
  23827,  -28.1109791,   22.1633625, -0.909090936
  23828,  -29.0554905,   22.1633625, -0.909090936
  23829,  -20.9063911,   23.1305542,    -9.090909
  23830,  -21.8127842,   23.1305542,    -9.090909
  23831,  -22.7191772,   23.1305542,    -9.090909
  23832,  -23.6255703,   23.1305542,    -9.090909
  23833,  -24.5319614,   23.1305542,    -9.090909
  23834,  -25.4383545,   23.1305542,    -9.090909
  23835,  -26.3447456,   23.1305542,    -9.090909
  23836,  -27.2585602,   23.1305542,    -9.090909
  23837,  -28.1723728,   23.1305542,    -9.090909
  23838,  -29.0861874,   23.1305542,    -9.090909
  23839,  -20.9036922,   23.1032124,  -8.18181801
  23840,  -21.8073883,   23.1032124,  -8.18181801
  23841,  -22.7110806,   23.1032124,  -8.18181801
  23842,  -23.6147747,   23.1032124,  -8.18181801
  23843,  -24.5184689,   23.1032124,  -8.18181801
  23844,   -25.422163,   23.1032124,  -8.18181801
  23845,  -26.3258553,   23.1032124,  -8.18181801
  23846,  -27.2443924,   23.1032124,  -8.18181801
  23847,  -28.1629276,   23.1032124,  -8.18181801
  23848,  -29.0814648,   23.1032124,  -8.18181801
  23849,  -20.9009953,   23.0758724,  -7.27272749
  23850,  -21.8019905,   23.0758724,  -7.27272749
  23851,  -22.7029858,   23.0758724,  -7.27272749
  23852,   -23.603981,   23.0758724,  -7.27272749
  23853,  -24.5049744,   23.0758724,  -7.27272749
  23854,  -25.4059715,   23.0758724,  -7.27272749
  23855,  -26.3069649,   23.0758724,  -7.27272749
  23856,  -27.2302246,   23.0758724,  -7.27272749
  23857,  -28.1534824,   23.0758724,  -7.27272749
  23858,  -29.0767422,   23.0758724,  -7.27272749
  23859,  -20.8982964,   23.0485306,  -6.36363649
  23860,  -21.7965927,   23.0485306,  -6.36363649
  23861,  -22.6948891,   23.0485306,  -6.36363649
  23862,  -23.5931873,   23.0485306,  -6.36363649
  23863,  -24.4914818,   23.0485306,  -6.36363649
  23864,    -25.38978,   23.0485306,  -6.36363649
  23865,  -26.2880745,   23.0485306,  -6.36363649
  23866,  -27.2160568,   23.0485306,  -6.36363649
  23867,  -28.1440372,   23.0485306,  -6.36363649
  23868,  -29.0720196,   23.0485306,  -6.36363649
  23869,  -20.8955975,   23.0211887,   -5.4545455
  23870,  -21.7911949,   23.0211887,   -5.4545455
  23871,  -22.6867943,   23.0211887,   -5.4545455
  23872,  -23.5823917,   23.0211887,   -5.4545455
  23873,  -24.4779892,   23.0211887,   -5.4545455
  23874,  -25.3735886,   23.0211887,   -5.4545455
  23875,  -26.2691841,   23.0211887,   -5.4545455
  23876,   -27.201889,   23.0211887,   -5.4545455
  23877,  -28.1345921,   23.0211887,   -5.4545455
  23878,   -29.067297,   23.0211887,   -5.4545455
  23879,  -20.8928986,   22.9938488,   -4.5454545
  23880,   -21.785799,   22.9938488,   -4.5454545
  23881,  -22.6786976,   22.9938488,   -4.5454545
  23882,  -23.5715981,   22.9938488,   -4.5454545
  23883,  -24.4644966,   22.9938488,   -4.5454545
  23884,  -25.3573952,   22.9938488,   -4.5454545
  23885,  -26.2502956,   22.9938488,   -4.5454545
  23886,  -27.1877213,   22.9938488,   -4.5454545
  23887,  -28.1251488,   22.9938488,   -4.5454545
  23888,  -29.0625744,   22.9938488,   -4.5454545
  23889,  -20.8901997,    22.966507,  -3.63636374
  23890,  -21.7804012,    22.966507,  -3.63636374
  23891,  -22.6706028,    22.966507,  -3.63636374
  23892,  -23.5608025,    22.966507,  -3.63636374
  23893,   -24.451004,    22.966507,  -3.63636374
  23894,  -25.3412037,    22.966507,  -3.63636374
  23895,  -26.2314053,    22.966507,  -3.63636374
  23896,  -27.1735535,    22.966507,  -3.63636374
  23897,  -28.1157036,    22.966507,  -3.63636374
  23898,  -29.0578518,    22.966507,  -3.63636374
  23899,  -20.8875008,    22.939167,  -2.72727275
  23900,  -21.7750034,    22.939167,  -2.72727275
  23901,  -22.6625061,    22.939167,  -2.72727275
  23902,  -23.5500088,    22.939167,  -2.72727275
  23903,  -24.4375114,    22.939167,  -2.72727275
  23904,  -25.3250122,    22.939167,  -2.72727275
  23905,  -26.2125149,    22.939167,  -2.72727275
  23906,  -27.1593857,    22.939167,  -2.72727275
  23907,  -28.1062584,    22.939167,  -2.72727275
  23908,  -29.0531292,    22.939167,  -2.72727275
  23909,  -20.8848038,   22.9118252,  -1.81818187
  23910,  -21.7696056,   22.9118252,  -1.81818187
  23911,  -22.6544113,   22.9118252,  -1.81818187
  23912,  -23.5392151,   22.9118252,  -1.81818187
  23913,   -24.424017,   22.9118252,  -1.81818187
  23914,  -25.3088207,   22.9118252,  -1.81818187
  23915,  -26.1936245,   22.9118252,  -1.81818187
  23916,  -27.1452179,   22.9118252,  -1.81818187
  23917,  -28.0968132,   22.9118252,  -1.81818187
  23918,  -29.0484066,   22.9118252,  -1.81818187
  23919,  -20.8821049,   22.8844833, -0.909090936
  23920,  -21.7642097,   22.8844833, -0.909090936
  23921,  -22.6463146,   22.8844833, -0.909090936
  23922,  -23.5284195,   22.8844833, -0.909090936
  23923,  -24.4105244,   22.8844833, -0.909090936
  23924,  -25.2926292,   22.8844833, -0.909090936
  23925,  -26.1747341,   22.8844833, -0.909090936
  23926,  -27.1310501,   22.8844833, -0.909090936
  23927,   -28.087368,   22.8844833, -0.909090936
  23928,   -29.043684,   22.8844833, -0.909090936
  23929,  -20.9057159,   23.9131927,    -9.090909
  23930,  -21.8114357,   23.9131927,    -9.090909
  23931,  -22.7171516,   23.9131927,    -9.090909
  23932,  -23.6228714,   23.9131927,    -9.090909
  23933,  -24.5285873,   23.9131927,    -9.090909
  23934,  -25.4343071,   23.9131927,    -9.090909
  23935,   -26.340023,   23.9131927,    -9.090909
  23936,  -27.2550182,   23.9131927,    -9.090909
  23937,  -28.1700115,   23.9131927,    -9.090909
  23938,  -29.0850067,   23.9131927,    -9.090909
  23939,  -20.9023438,    23.879015,  -8.18181801
  23940,  -21.8046894,    23.879015,  -8.18181801
  23941,  -22.7070332,    23.879015,  -8.18181801
  23942,  -23.6093769,    23.879015,  -8.18181801
  23943,  -24.5117226,    23.879015,  -8.18181801
  23944,  -25.4140663,    23.879015,  -8.18181801
  23945,  -26.3164101,    23.879015,  -8.18181801
  23946,  -27.2373085,    23.879015,  -8.18181801
  23947,   -28.158205,    23.879015,  -8.18181801
  23948,  -29.0791035,    23.879015,  -8.18181801
  23949,  -20.8989697,   23.8448391,  -7.27272749
  23950,  -21.7979431,   23.8448391,  -7.27272749
  23951,  -22.6969128,   23.8448391,  -7.27272749
  23952,  -23.5958843,   23.8448391,  -7.27272749
  23953,  -24.4948559,   23.8448391,  -7.27272749
  23954,  -25.3938274,   23.8448391,  -7.27272749
  23955,  -26.2927971,   23.8448391,  -7.27272749
  23956,  -27.2195988,   23.8448391,  -7.27272749
  23957,  -28.1463985,   23.8448391,  -7.27272749
  23958,  -29.0732002,   23.8448391,  -7.27272749
  23959,  -20.8955975,   23.8106632,  -6.36363649
  23960,  -21.7911968,   23.8106632,  -6.36363649
  23961,  -22.6867924,   23.8106632,  -6.36363649
  23962,  -23.5823917,   23.8106632,  -6.36363649
  23963,  -24.4779892,   23.8106632,  -6.36363649
  23964,  -25.3735886,   23.8106632,  -6.36363649
  23965,  -26.2691841,   23.8106632,  -6.36363649
  23966,   -27.201889,   23.8106632,  -6.36363649
  23967,  -28.1345921,   23.8106632,  -6.36363649
  23968,   -29.067297,   23.8106632,  -6.36363649
  23969,  -20.8922234,   23.7764874,   -5.4545455
  23970,  -21.7844505,   23.7764874,   -5.4545455
  23971,  -22.6766739,   23.7764874,   -5.4545455
  23972,  -23.5688992,   23.7764874,   -5.4545455
  23973,  -24.4611225,   23.7764874,   -5.4545455
  23974,  -25.3533478,   23.7764874,   -5.4545455
  23975,  -26.2455711,   23.7764874,   -5.4545455
  23976,  -27.1841793,   23.7764874,   -5.4545455
  23977,  -28.1227856,   23.7764874,   -5.4545455
  23978,  -29.0613937,   23.7764874,   -5.4545455
  23979,  -20.8888512,   23.7423096,   -4.5454545
  23980,  -21.7777023,   23.7423096,   -4.5454545
  23981,  -22.6665535,   23.7423096,   -4.5454545
  23982,  -23.5554047,   23.7423096,   -4.5454545
  23983,  -24.4442577,   23.7423096,   -4.5454545
  23984,  -25.3331089,   23.7423096,   -4.5454545
  23985,  -26.2219601,   23.7423096,   -4.5454545
  23986,  -27.1664715,   23.7423096,   -4.5454545
  23987,   -28.110981,   23.7423096,   -4.5454545
  23988,  -29.0554905,   23.7423096,   -4.5454545
  23989,  -20.8854771,   23.7081337,  -3.63636374
  23990,   -21.770956,   23.7081337,  -3.63636374
  23991,   -22.656435,   23.7081337,  -3.63636374
  23992,  -23.5419121,   23.7081337,  -3.63636374
  23993,  -24.4273911,   23.7081337,  -3.63636374
  23994,  -25.3128681,   23.7081337,  -3.63636374
