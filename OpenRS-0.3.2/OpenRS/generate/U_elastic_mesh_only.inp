  55995,   21.5253658,   18.1169376,  -5.92751598
  55996,    21.496521,   18.2050724,  -5.34573269
  55997,   21.4676781,   18.2932053,  -4.76394939
  55998,   21.4388332,     18.38134,  -4.18216562
  55999,   21.9070473,   16.9506893,  -9.47304153
  56000,   21.8822765,   17.0263767,  -8.94608307
  56001,   21.8575058,    17.102066,   -8.4191246
  56002,   21.8327351,   17.1777554,  -7.89216566
  56003,   21.8079643,   17.2534428,   -7.3652072
  56004,   21.7831936,   17.3291321,  -6.83824873
  56005,   21.7584248,   17.4048195,  -6.31128979
  56006,    21.733654,   17.4805088,  -5.78433132
  56007,   21.7088814,   17.5561981,  -5.25737286
  56008,   21.6841125,   17.6318855,  -4.73041439
  56009,   22.1183739,   16.3049698,  -9.51302719
  56010,   22.1003838,   16.3599396,  -9.02605343
  56011,   22.0823936,   16.4149113,  -8.53908062
  56012,   22.0644035,   16.4698811,  -8.05210781
  56013,   22.0464134,   16.5248508,  -7.56513453
  56014,   22.0284233,   16.5798206,  -7.07816124
  56015,   22.0104332,   16.6347904,  -6.59118795
  56016,   21.9924431,   16.6897602,  -6.10421515
  56017,   21.9744511,   16.7447319,  -5.61724186
  56018,    21.956461,   16.7997017,  -5.13026857
  56019,   22.3314762,   15.6538248,  -9.53731346
  56020,   22.3220425,   15.6826506,  -9.07462692
  56021,   22.3126087,   15.7114754,  -8.61194038
  56022,    22.303175,   15.7403011,  -8.14925385
  56023,   22.2937412,   15.7691259,  -7.68656683
  56024,   22.2843094,   15.7979517,  -7.22388029
  56025,   22.2748737,   15.8267775,  -6.76119375
  56026,     22.26544,   15.8556023,  -6.29850721
  56027,   22.2560062,    15.884428,   -5.8358202
  56028,   22.2465725,   15.9132528,  -5.37313366
  56029,   20.9704685,    10.187542,   -1.9576968
  56030,   21.8659191,    10.187542,   -1.9576968
  56031,   22.7613716,    10.187542,   -1.9576968
  56032,   23.6568222,    10.187542,  -1.95769691
  56033,   24.5522728,    10.187542,  -1.95769703
  56034,   25.4477253,    10.187542,  -1.95769703
  56035,   26.3431778,    10.187542,  -1.95769703
  56036,   27.2386284,    10.187542,  -1.95769715
  56037,   28.1340809,    10.187542,  -1.95769727
  56038,   29.0295315,    10.187542,  -1.95769739
  56039,   21.1086845,   10.6098747,  -2.94213581
  56040,    21.973423,   10.6098747,  -2.94213581
  56041,   22.8381577,   10.6098747,  -2.94213605
  56042,   23.7028942,   10.6098747,  -2.94213605
  56043,   24.5676327,   10.6098747,  -2.94213605
  56044,   25.4323673,   10.6098747,  -2.94213605
  56045,   26.2971058,   10.6098747,  -2.94213605
  56046,   27.1618404,   10.6098747,  -2.94213605
  56047,    28.026577,   10.6098747,  -2.94213605
  56048,   28.8913155,   10.6098747,  -2.94213605
  56049,   21.3145027,   11.2387571,  -3.80747604
  56050,   22.1335011,   11.2387581,  -3.80747676
  56051,   22.9525013,   11.2387581,  -3.80747676
  56052,   23.7715015,   11.2387581,  -3.80747676
  56053,   24.5904999,   11.2387581,  -3.80747676
  56054,   25.4094982,   11.2387581,  -3.80747676
  56055,   26.2284985,   11.2387581,  -3.80747676
  56056,   27.0474987,   11.2387581,  -3.80747676
  56057,   27.8664989,   11.2387581,  -3.80747676
  56058,   28.6854973,   11.2387581,  -3.80747676
  56059,   21.5751228,   12.0350952,  -4.51293707
  56060,   22.3362045,   12.0350952,  -4.51293707
  56061,     23.09729,   12.0350952,  -4.51293707
  56062,   23.8583736,   12.0350952,  -4.51293707
  56063,   24.6194572,   12.0350952,  -4.51293707
  56064,   25.3805428,   12.0350952,  -4.51293707
  56065,   26.1416264,   12.0350952,  -4.51293707
  56066,     26.90271,   12.0350952,  -4.51293707
  56067,   27.6637955,   12.0350952,  -4.51293707
  56068,   28.4248772,   12.0350952,  -4.51293707
  56069,   21.8764343,   12.9557686,  -5.03175735
  56070,   22.5705605,   12.9557676,  -5.03175735
  56071,   23.2646866,   12.9557676,  -5.03175735
  56072,   23.9588127,   12.9557676,  -5.03175735
  56073,   24.6529369,   12.9557676,  -5.03175735
  56074,    25.347065,   12.9557676,  -5.03175735
  56075,   26.0411892,   12.9557676,  -5.03175735
  56076,   26.7353172,   12.9557676,  -5.03175688
  56077,   27.4294415,   12.9557676,  -5.03175688
  56078,   28.1235676,   12.9557676,  -5.03175688
  56079,   22.2043839,   13.9578409,  -5.34825659
  56080,   22.8256321,   13.9578409,  -5.34825659
  56081,   23.4468784,   13.9578409,  -5.34825659
  56082,   24.0681286,   13.9578409,  -5.34825659
  56083,   24.6893768,   13.9578409,  -5.34825659
  56084,   25.3106251,     13.95784,  -5.34825611
  56085,   25.9318733,     13.95784,  -5.34825611
  56086,   26.5531216,     13.95784,  -5.34825611
  56087,   27.1743679,     13.95784,  -5.34825611
  56088,   27.7956161,     13.95784,  -5.34825611
  56089,   20.9877071,   10.2402163,  -2.76192713
  56090,   21.8793278,   10.2402163,  -2.76192713
  56091,   22.7709484,   10.2402163,  -2.76192713
  56092,    23.662569,   10.2402163,  -2.76192713
  56093,   24.5541897,   10.2402163,  -2.76192737
  56094,   25.4458103,   10.2402163,  -2.76192737
  56095,    26.337431,   10.2402163,  -2.76192737
  56096,   27.2290516,   10.2402163,   -2.7619276
  56097,   28.1206722,   10.2402163,   -2.7619276
  56098,   29.0122929,   10.2402163,  -2.76192784
  56099,    21.135479,   10.6917439,  -3.64792204
  56100,   21.9942608,   10.6917439,  -3.64792204
  56101,   22.8530426,   10.6917439,  -3.64792228
  56102,   23.7118263,   10.6917439,  -3.64792228
  56103,     24.57061,   10.6917439,  -3.64792228
  56104,     25.42939,   10.6917448,  -3.64792252
  56105,   26.2881737,   10.6917448,  -3.64792252
  56106,   27.1469555,   10.6917448,  -3.64792252
  56107,   28.0057392,   10.6917448,  -3.64792252
  56108,    28.864521,   10.6917448,  -3.64792252
  56109,   21.3440914,   11.3291674,  -4.42672873
  56110,   22.1565151,   11.3291683,   -4.4267292
  56111,   22.9689407,   11.3291683,   -4.4267292
  56112,   23.7813644,   11.3291683,   -4.4267292
  56113,   24.5937862,   11.3291674,   -4.4267292
  56114,   25.4062119,   11.3291674,   -4.4267292
  56115,   26.2186356,   11.3291674,   -4.4267292
  56116,   27.0310593,   11.3291674,   -4.4267292
  56117,   27.8434849,   11.3291674,   -4.4267292
  56118,   28.6559086,   11.3291674,   -4.4267292
  56119,    21.602026,      12.1173,  -5.06164312
  56120,   22.3571301,      12.1173,  -5.06164312
  56121,    23.112236,      12.1173,  -5.06164312
  56122,    23.867342,      12.1173,  -5.06164312
  56123,    24.622448,      12.1173,  -5.06164312
  56124,    25.377552,      12.1173,  -5.06164312
  56125,    26.132658,      12.1173,  -5.06164312
  56126,    26.887764,      12.1173,  -5.06164312
  56127,   27.6428699,      12.1173,  -5.06164312
  56128,    28.397974,      12.1173,  -5.06164312
  56129,   21.8965836,   13.0173349,  -5.52858162
  56130,   22.5862312,    13.017334,  -5.52858162
  56131,   23.2758808,    13.017334,  -5.52858162
  56132,   23.9655285,    13.017334,  -5.52858162
  56133,   24.6551762,    13.017334,  -5.52858162
  56134,   25.3448238,    13.017334,  -5.52858162
  56135,   26.0344715,    13.017334,  -5.52858162
  56136,   26.7241211,    13.017334,  -5.52858114
  56137,   27.4137688,    13.017334,  -5.52858114
  56138,   28.1034164,    13.017334,  -5.52858114
  56139,   22.2151146,   13.9906282,  -5.81343079
  56140,   22.8339767,   13.9906282,  -5.81343079
  56141,   23.4528408,   13.9906282,  -5.81343079
  56142,   24.0717049,   13.9906282,  -5.81343079
  56143,   24.6905689,   13.9906282,  -5.81343079
  56144,    25.309433,   13.9906273,  -5.81343079
  56145,   25.9282951,   13.9906273,  -5.81343079
  56146,   26.5471592,   13.9906273,  -5.81343079
  56147,   27.1660233,   13.9906273,  -5.81343079
  56148,   27.7848854,   13.9906273,  -5.81343079
  56149,   21.0049458,   10.2928905,  -3.56615758
  56150,   21.8927364,   10.2928905,  -3.56615758
  56151,   22.7805271,   10.2928905,  -3.56615758
  56152,   23.6683159,   10.2928905,  -3.56615758
  56153,   24.5561047,   10.2928905,  -3.56615758
  56154,   25.4438934,   10.2928905,  -3.56615782
  56155,   26.3316841,   10.2928905,  -3.56615782
  56156,   27.2194729,   10.2928905,  -3.56615782
  56157,   28.1072636,   10.2928905,  -3.56615782
  56158,   28.9950542,   10.2928905,  -3.56615806
  56159,   21.1622734,   10.7736139,  -4.35370874
  56160,   22.0151024,   10.7736139,  -4.35370874
  56161,   22.8679295,   10.7736139,  -4.35370874
  56162,   23.7207584,   10.7736139,  -4.35370874
  56163,   24.5735855,   10.7736139,  -4.35370874
  56164,   25.4264145,   10.7736139,  -4.35370922
  56165,   26.2792416,   10.7736139,  -4.35370922
  56166,   27.1320686,   10.7736139,  -4.35370922
  56167,   27.9848976,   10.7736139,  -4.35370922
  56168,   28.8377266,   10.7736139,  -4.35370922
  56169,   21.3736801,   11.4195776,  -5.04598093
  56170,   22.1795292,   11.4195786,  -5.04598141
  56171,   22.9853783,   11.4195786,  -5.04598141
  56172,   23.7912273,   11.4195776,  -5.04598141
  56173,   24.5970745,   11.4195776,  -5.04598141
  56174,   25.4029236,   11.4195776,  -5.04598141
  56175,   26.2087727,   11.4195776,  -5.04598141
  56176,   27.0146217,   11.4195776,  -5.04598141
  56177,   27.8204708,   11.4195776,  -5.04598141
  56178,   28.6263199,   11.4195776,  -5.04598141
  56179,    21.628931,   12.1995049,  -5.61034966
  56180,   22.3780556,   12.1995049,  -5.61034966
  56181,   23.1271839,   12.1995049,  -5.61034966
  56182,   23.8763103,   12.1995049,  -5.61034966
  56183,   24.6254368,   12.1995049,  -5.61034966
  56184,   25.3745632,   12.1995049,  -5.61034966
  56185,   26.1236897,   12.1995049,  -5.61034966
  56186,   26.8728161,   12.1995049,  -5.61034966
  56187,   27.6219444,   12.1995049,  -5.61034966
  56188,    28.371069,   12.1995049,  -5.61034966
  56189,   21.9167309,   13.0789003,  -6.02540588
  56190,    22.601902,   13.0788994,  -6.02540588
  56191,   23.2870731,   13.0788994,  -6.02540588
  56192,   23.9722443,   13.0789003,  -6.02540588
  56193,   24.6574135,   13.0789003,  -6.02540588
  56194,   25.3425865,   13.0789003,  -6.02540588
  56195,   26.0277557,   13.0789003,  -6.02540588
  56196,   26.7129288,   13.0789003,  -6.02540541
  56197,    27.398098,   13.0789003,  -6.02540541
  56198,   28.0832691,   13.0789003,  -6.02540541
  56199,   22.2258434,   14.0234156,  -6.27860498
  56200,   22.8423233,   14.0234156,  -6.27860498
  56201,   23.4588013,   14.0234156,  -6.27860498
  56202,   24.0752831,   14.0234156,  -6.27860498
  56203,    24.691761,   14.0234156,  -6.27860498
  56204,   25.3082409,   14.0234146,  -6.27860498
  56205,   25.9247189,   14.0234146,  -6.27860498
  56206,   26.5411987,   14.0234146,  -6.27860498
  56207,   27.1576767,   14.0234146,  -6.27860498
  56208,   27.7741566,   14.0234146,  -6.27860498
  56209,   21.0221844,   10.3455648,  -4.37038755
  56210,   21.9061432,   10.3455648,  -4.37038755
  56211,    22.790102,   10.3455648,  -4.37038755
  56212,   23.6740608,   10.3455648,  -4.37038755
  56213,   24.5580196,   10.3455648,  -4.37038755
  56214,   25.4419785,   10.3455648,  -4.37038803
  56215,   26.3259392,   10.3455648,  -4.37038803
  56216,    27.209898,   10.3455648,  -4.37038803
  56217,   28.0938568,   10.3455648,  -4.37038803
  56218,   28.9778156,   10.3455648,  -4.37038803
  56219,   21.1890659,   10.8554831,  -5.05949497
  56220,   22.0359421,   10.8554831,  -5.05949497
  56221,   22.8828144,   10.8554831,  -5.05949497
  56222,   23.7296886,   10.8554831,  -5.05949497
  56223,   24.5765629,   10.8554831,  -5.05949497
  56224,   25.4234371,    10.855484,  -5.05949545
  56225,   26.2703114,    10.855484,  -5.05949545
  56226,   27.1171837,    10.855484,  -5.05949545
  56227,   27.9640579,    10.855484,  -5.05949545
  56228,   28.8109341,    10.855484,  -5.05949545
  56229,   21.4032688,   11.5099869,  -5.66523361
  56230,   22.2025414,   11.5099878,  -5.66523409
  56231,   23.0018158,   11.5099878,  -5.66523361
  56232,   23.8010902,   11.5099878,  -5.66523361
  56233,   24.6003628,   11.5099878,  -5.66523361
  56234,   25.3996353,   11.5099878,  -5.66523361
  56235,   26.1989098,   11.5099878,  -5.66523361
  56236,   26.9981842,   11.5099878,  -5.66523361
  56237,   27.7974586,   11.5099878,  -5.66523361
  56238,   28.5967312,   11.5099878,  -5.66523361
  56239,   21.6558323,   12.2817097,  -6.15905571
  56240,   22.3989792,   12.2817097,  -6.15905571
  56241,   23.1421299,   12.2817097,  -6.15905571
  56242,   23.8852768,   12.2817097,  -6.15905571
  56243,   24.6284256,   12.2817097,  -6.15905571
  56244,   25.3715744,   12.2817097,  -6.15905571
  56245,   26.1147232,   12.2817097,  -6.15905571
  56246,   26.8578701,   12.2817097,  -6.15905571
  56247,   27.6010208,   12.2817097,  -6.15905619
  56248,   28.3441677,   12.2817097,  -6.15905619
  56249,    21.936882,   13.1404667,  -6.52223015
  56250,   22.6175728,   13.1404657,  -6.52223015
  56251,   23.2982674,   13.1404667,  -6.52223015
  56252,     23.97896,   13.1404667,  -6.52223015
  56253,   24.6596527,   13.1404667,  -6.52223015
  56254,   25.3403473,   13.1404667,  -6.52223015
  56255,     26.02104,   13.1404667,  -6.52223015
  56256,   26.7017326,   13.1404667,  -6.52223015
  56257,   27.3824272,   13.1404667,  -6.52223015
  56258,    28.063118,   13.1404667,  -6.52223015
  56259,   22.2365742,   14.0562029,  -6.74377966
  56260,   22.8506699,   14.0562029,  -6.74377966
  56261,   23.4647636,   14.0562029,  -6.74377966
  56262,   24.0788593,   14.0562029,  -6.74377966
  56263,   24.6929531,   14.0562029,  -6.74377966
  56264,   25.3070488,   14.0562029,  -6.74377918
  56265,   25.9211426,   14.0562029,  -6.74377918
  56266,   26.5352364,   14.0562029,  -6.74377918
  56267,   27.1493301,   14.0562029,  -6.74377918
  56268,   27.7634258,   14.0562029,  -6.74377918
  56269,    21.039423,   10.3982391,  -5.17461777
  56270,   21.9195518,   10.3982391,  -5.17461777
  56271,   22.7996807,   10.3982391,  -5.17461777
  56272,   23.6798077,   10.3982391,  -5.17461824
  56273,   24.5599346,   10.3982391,  -5.17461824
  56274,   25.4400635,   10.3982391,  -5.17461824
  56275,   26.3201923,   10.3982391,  -5.17461824
  56276,   27.2003193,   10.3982391,  -5.17461824
  56277,   28.0804482,   10.3982391,  -5.17461872
  56278,    28.960577,   10.3982391,  -5.17461872
  56279,   21.2158604,   10.9373531,   -5.7652812
  56280,   22.0567799,   10.9373531,   -5.7652812
  56281,   22.8976994,   10.9373531,   -5.7652812
  56282,   23.7386208,   10.9373531,   -5.7652812
  56283,   24.5795403,   10.9373531,   -5.7652812
  56284,   25.4204597,   10.9373531,  -5.76528168
  56285,   26.2613792,   10.9373531,  -5.76528168
  56286,   27.1022987,   10.9373531,  -5.76528168
  56287,   27.9432201,   10.9373531,  -5.76528168
  56288,   28.7841396,   10.9373531,  -5.76528168
  56289,   21.4328575,   11.6003971,  -6.28448582
  56290,   22.2255554,   11.6003971,  -6.28448582
  56291,   23.0182533,   11.6003971,  -6.28448582
  56292,   23.8109531,   11.6003971,  -6.28448582
  56293,    24.603651,   11.6003971,  -6.28448582
  56294,    25.396349,   11.6003971,  -6.28448582
  56295,   26.1890469,   11.6003971,  -6.28448582
  56296,   26.9817467,   11.6003971,  -6.28448582
  56297,   27.7744446,   11.6003971,  -6.28448582
  56298,   28.5671425,   11.6003971,  -6.28448582
  56299,   21.6827374,   12.3639145,  -6.70776224
  56300,   22.4199047,   12.3639145,  -6.70776224
  56301,   23.1570759,   12.3639145,  -6.70776224
  56302,   23.8942451,   12.3639145,  -6.70776224
  56303,   24.6314144,   12.3639145,  -6.70776224
  56304,   25.3685856,   12.3639145,  -6.70776224
  56305,   26.1057549,   12.3639145,  -6.70776224
  56306,   26.8429241,   12.3639145,  -6.70776224
  56307,   27.5800953,   12.3639145,  -6.70776224
  56308,   28.3172626,   12.3639145,  -6.70776224
  56309,   21.9570293,    13.202033,  -7.01905441
  56310,   22.6332436,   13.2020321,  -7.01905441
  56311,   23.3094616,   13.2020321,  -7.01905441
  56312,   23.9856758,   13.2020321,  -7.01905441
  56313,   24.6618919,   13.2020321,  -7.01905441
  56314,   25.3381081,   13.2020321,  -7.01905441
  56315,   26.0143242,   13.2020321,  -7.01905441
  56316,   26.6905403,   13.2020321,  -7.01905441
  56317,   27.3667564,   13.2020321,  -7.01905441
  56318,   28.0429707,   13.2020321,  -7.01905441
  56319,   22.2473049,   14.0889902,  -7.20895386
  56320,   22.8590145,   14.0889902,  -7.20895386
  56321,   23.4707241,   14.0889902,  -7.20895386
  56322,   24.0824356,   14.0889902,  -7.20895386
  56323,   24.6941452,   14.0889902,  -7.20895386
  56324,   25.3058567,   14.0889902,  -7.20895386
  56325,   25.9175663,   14.0889902,  -7.20895386
  56326,   26.5292759,   14.0889902,  -7.20895386
  56327,   27.1409855,   14.0889902,  -7.20895386
  56328,   27.7526951,   14.0889902,  -7.20895386
  56329,   21.0566616,   10.4509134,  -5.97884846
  56330,   21.9329586,   10.4509134,  -5.97884846
  56331,   22.8092575,   10.4509134,  -5.97884846
  56332,   23.6855545,   10.4509134,  -5.97884846
  56333,   24.5618515,   10.4509134,  -5.97884846
  56334,   25.4381485,   10.4509134,  -5.97884893
  56335,   26.3144455,   10.4509134,  -5.97884893
  56336,   27.1907425,   10.4509134,  -5.97884893
  56337,   28.0670414,   10.4509134,  -5.97884893
  56338,   28.9433384,   10.4509134,  -5.97884893
  56339,   21.2426548,   11.0192232,  -6.47106791
  56340,   22.0776215,   11.0192232,  -6.47106791
  56341,   22.9125862,   11.0192232,  -6.47106791
  56342,    23.747551,   11.0192232,  -6.47106791
  56343,   24.5825176,   11.0192232,  -6.47106791
  56344,   25.4174824,   11.0192232,  -6.47106838
  56345,    26.252449,   11.0192232,  -6.47106838
  56346,   27.0874138,   11.0192232,  -6.47106838
  56347,   27.9223785,   11.0192232,  -6.47106838
  56348,   28.7573452,   11.0192232,  -6.47106838
  56349,   21.4624462,   11.6908073,  -6.90373802
  56350,   22.2485695,   11.6908073,   -6.9037385
  56351,   23.0346928,   11.6908073,   -6.9037385
  56352,    23.820816,   11.6908073,   -6.9037385
  56353,   24.6069374,   11.6908073,   -6.9037385
  56354,   25.3930607,   11.6908073,   -6.9037385
  56355,    26.179184,   11.6908073,   -6.9037385
  56356,   26.9653072,   11.6908073,   -6.9037385
  56357,   27.7514305,   11.6908073,   -6.9037385
  56358,   28.5375538,   11.6908073,   -6.9037385
  56359,   21.7096386,   12.4461193,   -7.2564683
  56360,   22.4408302,   12.4461193,   -7.2564683
  56361,   23.1720219,   12.4461193,   -7.2564683
  56362,   23.9032135,   12.4461193,   -7.2564683
  56363,   24.6344051,   12.4461193,   -7.2564683
  56364,   25.3655949,   12.4461193,   -7.2564683
  56365,   26.0967865,   12.4461193,   -7.2564683
  56366,   26.8279781,   12.4461193,   -7.2564683
  56367,   27.5591698,   12.4461193,  -7.25646877
  56368,   28.2903614,   12.4461193,  -7.25646877
  56369,   21.9771786,   13.2635984,  -7.51587868
  56370,   22.6489162,   13.2635984,  -7.51587868
  56371,   23.3206539,   13.2635984,  -7.51587868
  56372,   23.9923935,   13.2635984,  -7.51587868
  56373,   24.6641312,   13.2635984,  -7.51587868
  56374,   25.3358688,   13.2635984,  -7.51587868
  56375,   26.0076065,   13.2635984,  -7.51587868
  56376,   26.6793461,   13.2635984,  -7.51587868
  56377,   27.3510838,   13.2635984,  -7.51587868
  56378,   28.0228214,   13.2635984,  -7.51587868
  56379,   22.2580357,   14.1217775,  -7.67412806
  56380,   22.8673611,   14.1217775,  -7.67412806
  56381,   23.4766865,   14.1217775,  -7.67412806
  56382,   24.0860119,   14.1217775,  -7.67412806
  56383,   24.6953373,   14.1217775,  -7.67412806
  56384,   25.3046627,   14.1217775,  -7.67412806
  56385,   25.9139881,   14.1217775,  -7.67412806
  56386,   26.5233135,   14.1217775,  -7.67412806
  56387,   27.1326389,   14.1217775,  -7.67412806
  56388,   27.7419643,   14.1217775,  -7.67412806
  56389,   21.0739002,   10.5035877,  -6.78307867
  56390,   21.9463673,   10.5035877,  -6.78307867
  56391,   22.8188343,   10.5035877,  -6.78307867
  56392,   23.6912994,   10.5035877,  -6.78307867
  56393,   24.5637665,   10.5035877,  -6.78307867
  56394,   25.4362335,   10.5035887,  -6.78307915
  56395,   26.3087006,   10.5035887,  -6.78307915
  56396,   27.1811657,   10.5035887,  -6.78307915
  56397,   28.0536327,   10.5035887,  -6.78307915
  56398,   28.9260998,   10.5035887,  -6.78307915
  56399,   21.2694492,   11.1010923,  -7.17685413
  56400,   22.0984592,   11.1010923,  -7.17685413
  56401,   22.9274712,   11.1010923,  -7.17685413
  56402,   23.7564831,   11.1010923,  -7.17685413
  56403,    24.585495,   11.1010923,  -7.17685413
  56404,    25.414505,   11.1010923,  -7.17685461
  56405,   26.2435169,   11.1010923,  -7.17685461
  56406,   27.0725288,   11.1010923,  -7.17685461
  56407,   27.9015408,   11.1010923,  -7.17685461
  56408,   28.7305508,   11.1010923,  -7.17685461
  56409,   21.4920349,   11.7812176,   -7.5229907
  56410,   22.2715816,   11.7812176,   -7.5229907
  56411,   23.0511303,   11.7812176,   -7.5229907
  56412,   23.8306789,   11.7812176,   -7.5229907
  56413,   24.6102257,   11.7812176,   -7.5229907
  56414,   25.3897743,   11.7812176,   -7.5229907
  56415,   26.1693211,   11.7812176,   -7.5229907
  56416,   26.9488697,   11.7812176,   -7.5229907
  56417,   27.7284184,   11.7812176,   -7.5229907
  56418,   28.5079651,   11.7812176,   -7.5229907
  56419,   21.7365437,   12.5283241,  -7.80517483
  56420,   22.4617558,   12.5283241,  -7.80517483
  56421,   23.1869678,   12.5283241,  -7.80517483
  56422,   23.9121819,   12.5283241,  -7.80517483
  56423,    24.637394,   12.5283241,  -7.80517483
  56424,    25.362606,   12.5283241,  -7.80517483
  56425,   26.0878181,   12.5283241,  -7.80517483
  56426,   26.8130322,   12.5283241,  -7.80517483
  56427,   27.5382442,   12.5283241,  -7.80517483
  56428,   28.2634563,   12.5283241,  -7.80517483
  56429,   21.9973278,   13.3251648,  -8.01270294
  56430,    22.664587,   13.3251648,  -8.01270294
  56431,   23.3318481,   13.3251648,  -8.01270294
  56432,   23.9991093,   13.3251648,  -8.01270294
  56433,   24.6663704,   13.3251648,  -8.01270294
  56434,   25.3336296,   13.3251648,  -8.01270294
  56435,   26.0008907,   13.3251648,  -8.01270294
  56436,   26.6681519,   13.3251648,  -8.01270294
  56437,    27.335413,   13.3251648,  -8.01270294
  56438,   28.0026722,   13.3251648,  -8.01270294
  56439,   22.2687664,   14.1545649,  -8.13930225
  56440,   22.8757057,   14.1545649,  -8.13930225
  56441,   23.4826469,   14.1545649,  -8.13930225
  56442,   24.0895882,   14.1545649,  -8.13930225
  56443,   24.6965294,   14.1545649,  -8.13930225
  56444,   25.3034706,   14.1545649,  -8.13930225
  56445,   25.9104118,   14.1545649,  -8.13930225
  56446,   26.5173531,   14.1545649,  -8.13930225
  56447,   27.1242943,   14.1545649,  -8.13930225
  56448,   27.7312336,   14.1545649,  -8.13930225
  56449,   21.0911407,    10.556263,  -7.58730888
  56450,   21.9597759,    10.556263,  -7.58730888
  56451,   22.8284111,    10.556263,  -7.58730888
  56452,   23.6970463,    10.556263,  -7.58730888
  56453,   24.5656815,    10.556263,  -7.58730888
  56454,   25.4343185,    10.556263,  -7.58730936
  56455,   26.3029537,    10.556263,  -7.58730936
  56456,   27.1715889,    10.556263,  -7.58730936
  56457,   28.0402241,    10.556263,  -7.58730936
  56458,   28.9088593,    10.556263,  -7.58730936
  56459,   21.2962418,   11.1829624,  -7.88264084
  56460,   22.1192989,   11.1829624,  -7.88264084
  56461,   22.9423561,   11.1829624,  -7.88264084
  56462,   23.7654133,   11.1829624,  -7.88264084
  56463,   24.5884724,   11.1829624,  -7.88264084
  56464,   25.4115276,   11.1829624,  -7.88264084
  56465,   26.2345867,   11.1829624,  -7.88264084
  56466,   27.0576439,   11.1829624,  -7.88264084
  56467,   27.8807011,   11.1829624,  -7.88264084
  56468,   28.7037582,   11.1829624,  -7.88264084
  56469,   21.5216236,   11.8716269,  -8.14224243
  56470,   22.2945957,   11.8716269,  -8.14224243
  56471,   23.0675678,   11.8716269,  -8.14224243
  56472,   23.8405418,   11.8716269,  -8.14224243
  56473,   24.6135139,   11.8716269,  -8.14224339
  56474,   25.3864861,   11.8716269,  -8.14224339
  56475,   26.1594582,   11.8716269,  -8.14224339
  56476,   26.9324322,   11.8716269,  -8.14224339
  56477,   27.7054043,   11.8716269,  -8.14224339
  56478,   28.4783764,   11.8716269,  -8.14224339
  56479,   21.7634468,   12.6105289,  -8.35388088
  56480,   22.4826794,   12.6105289,  -8.35388088
  56481,   23.2019157,   12.6105289,  -8.35388088
  56482,   23.9211483,   12.6105289,  -8.35388088
  56483,   24.6403828,   12.6105289,  -8.35388088
  56484,   25.3596172,   12.6105289,  -8.35388088
  56485,   26.0788517,   12.6105289,  -8.35388088
  56486,   26.7980843,   12.6105289,  -8.35388088
  56487,   27.5173206,   12.6105289,  -8.35388088
  56488,   28.2365532,   12.6105289,  -8.35388088
  56489,    22.017477,   13.3867302,  -8.50952721
  56490,   22.6802578,   13.3867302,  -8.50952721
  56491,   23.3430424,   13.3867302,  -8.50952721
  56492,    24.005825,   13.3867302,  -8.50952721
  56493,   24.6686096,   13.3867302,  -8.50952721
  56494,   25.3313904,   13.3867302,  -8.50952721
  56495,    25.994175,   13.3867302,  -8.50952721
  56496,   26.6569576,   13.3867302,  -8.50952721
  56497,   27.3197422,   13.3867302,  -8.50952721
  56498,    27.982523,   13.3867302,  -8.50952721
  56499,   22.2794971,   14.1873522,  -8.60447693
  56500,   22.8840523,   14.1873522,  -8.60447693
  56501,   23.4886093,   14.1873522,  -8.60447693
  56502,   24.0931644,   14.1873522,  -8.60447693
  56503,   24.6977215,   14.1873522,  -8.60447693
  56504,   25.3022785,   14.1873522,  -8.60447693
  56505,   25.9068356,   14.1873522,  -8.60447693
  56506,   26.5113907,   14.1873522,  -8.60447693
  56507,   27.1159477,   14.1873522,  -8.60447693
  56508,   27.7205029,   14.1873522,  -8.60447693
  56509,   21.1083775,   10.6089373,  -8.39153957
  56510,   21.9731827,   10.6089373,  -8.39153957
  56511,   22.8379879,   10.6089373,  -8.39153957
  56512,   23.7027931,   10.6089373,  -8.39153957
  56513,   24.5675964,   10.6089373,  -8.39153957
  56514,   25.4324017,   10.6089373,  -8.39153957
  56515,   26.2972069,   10.6089373,  -8.39153957
  56516,   27.1620121,   10.6089373,  -8.39153957
  56517,   28.0268173,   10.6089373,  -8.39153957
  56518,   28.8916225,   10.6089373,  -8.39153957
  56519,   21.3230362,   11.2648325,  -8.58842754
  56520,   22.1401405,   11.2648325,  -8.58842754
  56521,    22.957243,   11.2648325,  -8.58842754
  56522,   23.7743454,   11.2648325,  -8.58842754
  56523,   24.5914478,   11.2648325,  -8.58842754
  56524,   25.4085522,   11.2648325,  -8.58842754
  56525,   26.2256546,   11.2648325,  -8.58842754
  56526,    27.042757,   11.2648325,  -8.58842754
  56527,   27.8598595,   11.2648325,  -8.58842754
  56528,   28.6769638,   11.2648325,  -8.58842754
  56529,   21.5512123,   11.9620371,  -8.76149559
  56530,   22.3176098,   11.9620371,  -8.76149559
  56531,   23.0840054,   11.9620371,  -8.76149559
  56532,   23.8504047,   11.9620371,  -8.76149559
  56533,   24.6168022,   11.9620371,  -8.76149559
  56534,   25.3831978,   11.9620371,  -8.76149559
  56535,   26.1495953,   11.9620371,  -8.76149559
  56536,   26.9159946,   11.9620371,  -8.76149559
  56537,   27.6823902,   11.9620371,  -8.76149559
  56538,   28.4487877,   11.9620371,  -8.76149559
  56539,     21.79035,   12.6927338,  -8.90258694
  56540,   22.5036049,   12.6927338,  -8.90258694
  56541,   23.2168617,   12.6927338,  -8.90258694
  56542,   23.9301167,   12.6927338,  -8.90258694
  56543,   24.6433716,   12.6927338,  -8.90258694
  56544,   25.3566284,   12.6927338,  -8.90258789
  56545,   26.0698833,   12.6927338,  -8.90258789
  56546,   26.7831383,   12.6927338,  -8.90258789
  56547,   27.4963951,   12.6927338,  -8.90258789
  56548,     28.20965,   12.6927338,  -8.90258789
  56549,   22.0376244,   13.4482965,  -9.00635147
  56550,   22.6959286,   13.4482965,  -9.00635147
  56551,   23.3542347,   13.4482965,  -9.00635147
  56552,   24.0125408,   13.4482965,  -9.00635147
  56553,   24.6708469,   13.4482965,  -9.00635147
  56554,   25.3291531,   13.4482965,  -9.00635147
  56555,   25.9874592,   13.4482965,  -9.00635147
  56556,   26.6457653,   13.4482965,  -9.00635147
  56557,   27.3040714,   13.4482965,  -9.00635147
  56558,   27.9623756,   13.4482965,  -9.00635147
  56559,    22.290226,   14.2201395,   -9.0696516
  56560,   22.8923988,   14.2201395,   -9.0696516
  56561,   23.4945698,   14.2201395,   -9.0696516
  56562,   24.0967426,   14.2201395,   -9.0696516
  56563,   24.6989136,   14.2201395,   -9.0696516
  56564,   25.3010864,   14.2201395,   -9.0696516
  56565,   25.9032593,   14.2201395,   -9.0696516
  56566,   26.5054302,   14.2201395,   -9.0696516
  56567,   27.1076012,   14.2201395,   -9.0696516
  56568,    27.709774,   14.2201395,   -9.0696516
  56569,    21.125618,   10.6616116,  -9.19576931
  56570,   21.9865913,   10.6616116,  -9.19576931
  56571,   22.8475666,   10.6616116,  -9.19576931
  56572,   23.7085381,   10.6616116,  -9.19576931
  56573,   24.5695133,   10.6616116,  -9.19576931
  56574,   25.4304867,   10.6616116,  -9.19576931
  56575,   26.2914619,   10.6616116,  -9.19576931
  56576,   27.1524334,   10.6616116,  -9.19576931
  56577,   28.0134087,   10.6616116,  -9.19576931
  56578,    28.874382,   10.6616116,  -9.19576931
  56579,   21.3498306,   11.3467016,  -9.29421329
  56580,   22.1609783,   11.3467016,  -9.29421329
  56581,   22.9721279,   11.3467016,  -9.29421329
  56582,   23.7832775,   11.3467016,  -9.29421329
  56583,   24.5944252,   11.3467016,  -9.29421329
  56584,   25.4055748,   11.3467016,  -9.29421329
  56585,   26.2167225,   11.3467016,  -9.29421329
  56586,   27.0278721,   11.3467016,  -9.29421329
  56587,   27.8390217,   11.3467016,  -9.29421329
  56588,   28.6501694,   11.3467016,  -9.29421329
  56589,   21.5807991,   12.0524473,   -9.3807478
  56590,   22.3406219,   12.0524473,   -9.3807478
  56591,   23.1004429,   12.0524473,   -9.3807478
  56592,   23.8602676,   12.0524473,   -9.3807478
  56593,   24.6200886,   12.0524473,   -9.3807478
  56594,   25.3799114,   12.0524473,   -9.3807478
  56595,   26.1397324,   12.0524473,   -9.3807478
  56596,   26.8995571,   12.0524473,   -9.3807478
  56597,   27.6593781,   12.0524473,   -9.3807478
  56598,   28.4192009,   12.0524473,   -9.3807478
  56599,   21.8172531,   12.7749386,  -9.45129395
  56600,   22.5245304,   12.7749386,  -9.45129395
  56601,   23.2318077,   12.7749386,  -9.45129395
  56602,    23.939085,   12.7749386,  -9.45129395
  56603,   24.6463623,   12.7749386,  -9.45129395
  56604,   25.3536377,   12.7749386,  -9.45129395
  56605,    26.060915,   12.7749386,  -9.45129395
  56606,   26.7681923,   12.7749386,  -9.45129395
  56607,   27.4754696,   12.7749386,  -9.45129395
  56608,   28.1827469,   12.7749386,  -9.45129395
  56609,   22.0577736,   13.5098629,  -9.50317574
  56610,   22.7116013,   13.5098629,  -9.50317574
  56611,   23.3654289,   13.5098629,  -9.50317574
  56612,   24.0192585,   13.5098629,  -9.50317574
  56613,   24.6730862,   13.5098629,  -9.50317574
  56614,   25.3269138,   13.5098629,  -9.50317574
  56615,   25.9807415,   13.5098629,  -9.50317574
  56616,   26.6345711,   13.5098629,  -9.50317574
  56617,   27.2883987,   13.5098629,  -9.50317574
  56618,   27.9422264,   13.5098629,  -9.50317574
  56619,   22.3009567,   14.2529268,  -9.53482533
  56620,   22.9007435,   14.2529268,  -9.53482533
  56621,   23.5005322,   14.2529268,  -9.53482533
  56622,   24.1003189,   14.2529268,  -9.53482533
  56623,   24.7001057,   14.2529268,  -9.53482533
  56624,   25.2998943,   14.2529268,  -9.53482533
  56625,   25.8996811,   14.2529268,  -9.53482533
  56626,   26.4994678,   14.2529268,  -9.53482533
  56627,   27.0992565,   14.2529268,  -9.53482533
  56628,   27.6990433,   14.2529268,  -9.53482533
  56629,  -28.9018822,   19.4224148,  -9.18288708
  56630,  -28.0347977,   19.4224148,  -9.18288708
  56631,  -27.1677113,   19.4224148,  -9.18288708
  56632,  -26.3006268,   19.4224148,  -9.18288708
  56633,  -25.4335423,   19.4224148,  -9.18288708
  56634,  -24.5664577,   19.4224148,  -9.18288708
  56635,  -23.6993732,   19.4224148,  -9.18288708
  56636,  -22.8322887,   19.4224148,  -9.18288708
  56637,  -21.9652023,   19.4224148,  -9.18288708
  56638,  -21.0981178,   19.4224148,  -9.18288708
  56639,  -28.7069016,    18.826643,  -9.27052689
  56640,  -27.8831444,    18.826643,  -9.27052689
  56641,  -27.0593891,    18.826643,  -9.27052689
  56642,  -26.2356339,    18.826643,  -9.27052689
  56643,  -25.4118767,    18.826643,  -9.27052689
  56644,  -24.5881233,    18.826643,  -9.27052689
  56645,  -23.7643661,    18.826643,  -9.27052689
  56646,  -22.9406109,    18.826643,  -9.27052689
  56647,  -22.1168556,    18.826643,  -9.27052689
  56648,  -21.2930984,    18.826643,  -9.27052689
  56649,  -28.5065289,   18.2143955,  -9.34998417
  56650,  -27.7273026,   18.2143955,  -9.34998417
  56651,  -26.9480724,   18.2143955,  -9.34998417
  56652,  -26.1688423,   18.2143955,  -9.34998417
  56653,  -25.3896141,   18.2143955,  -9.34998417
  56654,  -24.6103859,   18.2143955,  -9.34998417
  56655,  -23.8311577,   18.2143955,  -9.34998417
  56656,  -23.0519276,   18.2143955,  -9.34998417
  56657,  -22.2726974,   18.2143955,  -9.34998417
  56658,  -21.4934711,   18.2143955,  -9.34998417
  56659,  -28.3015709,   17.5881348,  -9.41821671
  56660,  -27.5678883,   17.5881348,  -9.41821671
  56661,  -26.8342056,   17.5881348,  -9.41821671
  56662,  -26.1005249,   17.5881348,  -9.41821671
  56663,  -25.3668404,   17.5881348,  -9.41821671
  56664,  -24.6331596,   17.5881348,  -9.41821671
  56665,  -23.8994751,   17.5881348,  -9.41821671
  56666,  -23.1657944,   17.5881348,  -9.41821671
  56667,  -22.4321117,   17.5881348,  -9.41821671
  56668,  -21.6984291,   17.5881348,  -9.41821671
  56669,  -28.0929527,   16.9506893,  -9.47304153
  56670,  -27.4056301,   16.9506893,  -9.47304153
  56671,  -26.7183075,   16.9506893,  -9.47304153
  56672,  -26.0309849,   16.9506893,  -9.47304153
  56673,  -25.3436623,   16.9506893,  -9.47304153
  56674,  -24.6563377,   16.9506893,  -9.47304153
  56675,  -23.9690151,   16.9506893,  -9.47304153
  56676,  -23.2816925,   16.9506893,  -9.47304153
  56677,  -22.5943699,   16.9506893,  -9.47304153
  56678,  -21.9070473,   16.9506893,  -9.47304153
  56679,  -27.8816261,   16.3049698,  -9.51302719
  56680,  -27.2412643,   16.3049698,  -9.51302719
  56681,  -26.6009045,   16.3049698,  -9.51302719
  56682,  -25.9605427,   16.3049698,  -9.51302719
  56683,  -25.3201809,   16.3049698,  -9.51302719
  56684,  -24.6798191,   16.3049698,  -9.51302719
  56685,  -24.0394573,   16.3049698,  -9.51302719
  56686,  -23.3990955,   16.3049698,  -9.51302719
  56687,  -22.7587357,   16.3049698,  -9.51302719
  56688,  -22.1183739,   16.3049698,  -9.51302719
  56689,  -27.6685238,   15.6538258,  -9.53731346
  56690,  -27.0755196,   15.6538258,  -9.53731346
  56691,  -26.4825134,   15.6538258,  -9.53731346
  56692,  -25.8895092,   15.6538258,  -9.53731346
  56693,  -25.2965031,   15.6538258,  -9.53731346
  56694,  -24.7034969,   15.6538248,  -9.53731346
  56695,  -24.1104908,   15.6538248,  -9.53731346
  56696,  -23.5174866,   15.6538248,  -9.53731346
  56697,  -22.9244804,   15.6538248,  -9.53731346
  56698,  -22.3314762,   15.6538248,  -9.53731346
  56699,  -28.9173985,   19.4698296,  -8.36577415
  56700,  -28.0468655,   19.4698296,  -8.36577415
  56701,  -27.1763325,   19.4698296,  -8.36577415
  56702,  -26.3057995,   19.4698296,  -8.36577415
  56703,  -25.4352665,   19.4698296,  -8.36577415
  56704,  -24.5647335,   19.4698296,  -8.36577415
  56705,  -23.6942005,   19.4698296,  -8.36577415
  56706,  -22.8236675,   19.4698296,  -8.36577415
  56707,  -21.9531345,   19.4698296,  -8.36577415
  56708,  -21.0826015,   19.4698296,  -8.36577415
  56709,  -28.7319832,   18.9032841,  -8.54105377
  56710,  -27.9026546,   18.9032841,  -8.54105377
  56711,  -27.0733242,   18.9032841,  -8.54105377
  56712,  -26.2439938,   18.9032841,  -8.54105377
  56713,  -25.4146633,   18.9032841,  -8.54105377
  56714,  -24.5853348,   18.9032841,  -8.54105377
  56715,  -23.7560062,   18.9032841,  -8.54105377
  56716,  -22.9266758,   18.9032841,  -8.54105377
  56717,  -22.0973454,   18.9032841,  -8.54105377
  56718,  -21.2680168,   18.9032841,  -8.54105377
  56719,  -28.5357857,   18.3037891,  -8.69996929
  56720,  -27.7500553,   18.3037891,  -8.69996929
  56721,   -26.964325,   18.3037891,  -8.69996929
  56722,  -26.1785946,   18.3037891,  -8.69996929
  56723,  -25.3928661,   18.3037891,  -8.69996929
  56724,  -24.6071339,   18.3037891,  -8.69996929
  56725,  -23.8214054,   18.3037891,  -8.69996929
  56726,   -23.035675,   18.3037891,  -8.69996929
  56727,  -22.2499447,   18.3037891,  -8.69996929
  56728,  -21.4642143,   18.3037891,  -8.69996929
  56729,  -28.3304157,   17.6762676,  -8.83643246
  56730,  -27.5903225,   17.6762676,  -8.83643246
  56731,  -26.8502312,   17.6762676,  -8.83643246
  56732,  -26.1101398,   17.6762676,  -8.83643246
  56733,  -25.3700466,   17.6762676,  -8.83643246
  56734,  -24.6299534,   17.6762676,  -8.83643341
  56735,  -23.8898602,   17.6762676,  -8.83643341
  56736,  -23.1497688,   17.6762676,  -8.83643341
  56737,  -22.4096775,   17.6762676,  -8.83643341
  56738,  -21.6695843,   17.6762676,  -8.83643341
  56739,  -28.1177235,   17.0263767,  -8.94608307
  56740,  -27.4248962,   17.0263767,  -8.94608307
  56741,   -26.732069,   17.0263767,  -8.94608307
  56742,  -26.0392418,   17.0263767,  -8.94608307
  56743,  -25.3464146,   17.0263767,  -8.94608307
  56744,  -24.6535854,   17.0263767,  -8.94608307
  56745,  -23.9607582,   17.0263767,  -8.94608307
  56746,   -23.267931,   17.0263767,  -8.94608307
  56747,  -22.5751038,   17.0263767,  -8.94608307
  56748,  -21.8822765,   17.0263767,  -8.94608307
  56749,  -27.8996162,   16.3599415,  -9.02605343
  56750,  -27.2552567,   16.3599415,  -9.02605343
  56751,   -26.610899,   16.3599415,  -9.02605343
  56752,  -25.9665394,   16.3599415,  -9.02605343
  56753,  -25.3221798,   16.3599396,  -9.02605343
  56754,  -24.6778202,   16.3599396,  -9.02605343
  56755,  -24.0334606,   16.3599396,  -9.02605343
  56756,   -23.389101,   16.3599396,  -9.02605343
  56757,  -22.7447433,   16.3599396,  -9.02605343
  56758,  -22.1003838,   16.3599396,  -9.02605343
  56759,  -27.6779575,   15.6826506,  -9.07462692
  56760,  -27.0828571,   15.6826506,  -9.07462692
  56761,  -26.4877548,   15.6826506,  -9.07462692
  56762,  -25.8926525,   15.6826506,  -9.07462692
  56763,  -25.2975502,   15.6826506,  -9.07462692
  56764,  -24.7024498,   15.6826506,  -9.07462692
  56765,  -24.1073475,   15.6826506,  -9.07462692
  56766,  -23.5122452,   15.6826506,  -9.07462692
  56767,  -22.9171429,   15.6826506,  -9.07462692
  56768,  -22.3220425,   15.6826506,  -9.07462692
  56769,  -28.9329166,   19.5172443,  -7.54866171
  56770,  -28.0589352,   19.5172443,  -7.54866171
  56771,  -27.1849537,   19.5172443,  -7.54866123
  56772,  -26.3109722,   19.5172443,  -7.54866123
  56773,  -25.4369907,   19.5172443,  -7.54866123
  56774,  -24.5630093,   19.5172443,  -7.54866123
  56775,  -23.6890278,   19.5172443,  -7.54866123
  56776,  -22.8150463,   19.5172443,  -7.54866123
  56777,  -21.9410648,   19.5172443,  -7.54866076
  56778,  -21.0670834,   19.5172443,  -7.54866076
  56779,  -28.7570667,   18.9799271,  -7.81158113
  56780,   -27.922163,   18.9799271,  -7.81158113
  56781,  -27.0872593,   18.9799271,  -7.81158113
  56782,  -26.2523556,   18.9799271,  -7.81158113
  56783,  -25.4174519,   18.9799271,  -7.81158066
  56784,  -24.5825481,   18.9799271,  -7.81158066
  56785,  -23.7476444,   18.9799271,  -7.81158066
  56786,  -22.9127407,   18.9799271,  -7.81158066
  56787,   -22.077837,   18.9799271,  -7.81158066
  56788,  -21.2429333,   18.9799271,  -7.81158066
  56789,  -28.5650406,   18.3931847,  -8.04995346
  56790,    -27.77281,   18.3931847,  -8.04995346
  56791,  -26.9805775,   18.3931847,  -8.04995346
  56792,  -26.1883469,   18.3931847,  -8.04995346
  56793,  -25.3961163,   18.3931847,  -8.04995346
  56794,  -24.6038837,   18.3931847,  -8.04995346
  56795,  -23.8116531,   18.3931847,  -8.04995346
  56796,  -23.0194225,   18.3931847,  -8.04995346
  56797,    -22.22719,   18.3931847,  -8.04995346
  56798,  -21.4349594,   18.3931847,  -8.04995346
  56799,  -28.3592587,   17.7644024,  -8.25464916
  56800,  -27.6127567,   17.7644024,  -8.25464916
  56801,  -26.8662548,   17.7644024,  -8.25464916
  56802,  -26.1197529,   17.7644024,  -8.25464916
  56803,   -25.373251,   17.7644024,  -8.25464916
  56804,   -24.626749,   17.7644024,  -8.25464916
  56805,  -23.8802471,   17.7644024,  -8.25464916
  56806,  -23.1337452,   17.7644024,  -8.25464916
  56807,  -22.3872433,   17.7644024,  -8.25464916
  56808,  -21.6407413,   17.7644024,  -8.25464916
  56809,  -28.1424942,    17.102066,  -8.41912365
  56810,  -27.4441624,    17.102066,  -8.41912365
  56811,  -26.7458305,    17.102066,  -8.41912365
  56812,  -26.0474987,    17.102066,  -8.41912365
  56813,  -25.3491669,    17.102066,  -8.41912365
  56814,  -24.6508331,    17.102066,   -8.4191246
  56815,  -23.9525013,    17.102066,   -8.4191246
  56816,  -23.2541695,    17.102066,   -8.4191246
  56817,  -22.5558376,    17.102066,   -8.4191246
  56818,  -21.8575058,    17.102066,   -8.4191246
  56819,  -27.9176064,   16.4149113,  -8.53908062
  56820,   -27.269249,   16.4149113,  -8.53908062
  56821,  -26.6208935,   16.4149113,  -8.53908062
  56822,  -25.9725361,   16.4149113,  -8.53908062
  56823,  -25.3241787,   16.4149113,  -8.53908062
  56824,  -24.6758213,   16.4149113,  -8.53908062
  56825,  -24.0274639,   16.4149113,  -8.53908062
  56826,  -23.3791065,   16.4149113,  -8.53908062
  56827,   -22.730751,   16.4149113,  -8.53908062
  56828,  -22.0823936,   16.4149113,  -8.53908062
  56829,  -27.6873913,   15.7114763,  -8.61194038
  56830,  -27.0901947,   15.7114763,  -8.61194038
  56831,  -26.4929943,   15.7114763,  -8.61194038
  56832,  -25.8957977,   15.7114763,  -8.61194038
  56833,  -25.2985992,   15.7114763,  -8.61194038
  56834,  -24.7014008,   15.7114754,  -8.61194038
  56835,  -24.1042023,   15.7114754,  -8.61194038
  56836,  -23.5070057,   15.7114754,  -8.61194038
  56837,  -22.9098072,   15.7114754,  -8.61194038
  56838,  -22.3126087,   15.7114754,  -8.61194038
  56839,  -28.9484329,   19.5646591,  -6.73154879
  56840,  -28.0710049,   19.5646591,  -6.73154879
  56841,   -27.193573,   19.5646591,  -6.73154831
  56842,   -26.316143,   19.5646591,  -6.73154831
  56843,   -25.438715,   19.5646591,  -6.73154831
  56844,   -24.561285,   19.5646591,  -6.73154831
  56845,   -23.683857,   19.5646591,  -6.73154831
  56846,   -22.806427,   19.5646591,  -6.73154831
  56847,  -21.9289951,   19.5646591,  -6.73154783
  56848,  -21.0515671,   19.5646591,  -6.73154783
  56849,  -28.7821503,   19.0565681,  -7.08210802
  56850,  -27.9416714,   19.0565681,  -7.08210802
  56851,  -27.1011944,   19.0565681,  -7.08210802
  56852,  -26.2607155,   19.0565681,  -7.08210754
  56853,  -25.4202385,   19.0565681,  -7.08210754
  56854,  -24.5797615,   19.0565681,  -7.08210754
  56855,  -23.7392845,   19.0565681,  -7.08210754
  56856,  -22.8988056,   19.0565681,  -7.08210754
  56857,  -22.0583286,   19.0565681,  -7.08210754
  56858,  -21.2178497,   19.0565681,  -7.08210754
  56859,  -28.5942974,   18.4825783,  -7.39993811
  56860,  -27.7955666,   18.4825783,  -7.39993811
  56861,  -26.9968319,   18.4825783,  -7.39993811
  56862,  -26.1980991,   18.4825783,  -7.39993811
  56863,  -25.3993664,   18.4825783,  -7.39993811
  56864,  -24.6006336,   18.4825783,  -7.39993811
  56865,  -23.8019009,   18.4825783,  -7.39993811
  56866,  -23.0031681,   18.4825783,  -7.39993811
  56867,  -22.2044334,   18.4825783,  -7.39993811
  56868,  -21.4057026,   18.4825783,  -7.39993811
  56869,  -28.3881035,   17.8525372,  -7.67286587
  56870,   -27.635191,   17.8525372,  -7.67286587
  56871,  -26.8822784,   17.8525372,  -7.67286587
  56872,  -26.1293678,   17.8525372,  -7.67286587
  56873,  -25.3764553,   17.8525372,  -7.67286587
  56874,  -24.6235447,   17.8525352,  -7.67286587
  56875,  -23.8706322,   17.8525352,  -7.67286587
  56876,  -23.1177216,   17.8525352,  -7.67286587
  56877,   -22.364809,   17.8525352,  -7.67286587
  56878,  -21.6118965,   17.8525352,  -7.67286587
  56879,  -28.1672649,   17.1777554,  -7.89216518
  56880,  -27.4634285,   17.1777554,  -7.89216518
  56881,  -26.7595921,   17.1777554,  -7.89216518
  56882,  -26.0557556,   17.1777554,  -7.89216518
  56883,  -25.3519192,   17.1777554,  -7.89216518
  56884,  -24.6480808,   17.1777554,  -7.89216566
  56885,  -23.9442444,   17.1777554,  -7.89216566
  56886,  -23.2404079,   17.1777554,  -7.89216566
  56887,  -22.5365715,   17.1777554,  -7.89216566
  56888,  -21.8327351,   17.1777554,  -7.89216566
  56889,  -27.9355965,   16.4698811,  -8.05210686
  56890,  -27.2832413,   16.4698811,  -8.05210686
  56891,   -26.630888,   16.4698811,  -8.05210686
  56892,  -25.9785328,   16.4698811,  -8.05210686
  56893,  -25.3261776,   16.4698811,  -8.05210781
  56894,  -24.6738224,   16.4698811,  -8.05210781
  56895,  -24.0214672,   16.4698811,  -8.05210781
  56896,   -23.369112,   16.4698811,  -8.05210781
  56897,  -22.7167587,   16.4698811,  -8.05210781
  56898,  -22.0644035,   16.4698811,  -8.05210781
  56899,   -27.696825,   15.7403011,  -8.14925385
  56900,  -27.0975304,   15.7403011,  -8.14925385
  56901,  -26.4982357,   15.7403011,  -8.14925385
  56902,   -25.898941,   15.7403011,  -8.14925385
  56903,  -25.2996483,   15.7403011,  -8.14925385
  56904,  -24.7003536,   15.7403011,  -8.14925385
  56905,   -24.101059,   15.7403011,  -8.14925385
  56906,  -23.5017643,   15.7403011,  -8.14925385
  56907,  -22.9024696,   15.7403011,  -8.14925385
  56908,   -22.303175,   15.7403011,  -8.14925385
  56909,  -28.9639511,   19.6120739,  -5.91443586
  56910,  -28.0830746,   19.6120739,  -5.91443586
  56911,  -27.2021942,   19.6120739,  -5.91443539
  56912,  -26.3213158,   19.6120739,  -5.91443539
  56913,  -25.4404392,   19.6120739,  -5.91443539
  56914,  -24.5595608,   19.6120758,  -5.91443539
  56915,  -23.6786842,   19.6120758,  -5.91443539
  56916,  -22.7978058,   19.6120758,  -5.91443539
  56917,  -21.9169254,   19.6120758,  -5.91443491
  56918,  -21.0360489,   19.6120758,  -5.91443491
  56919,  -28.8072319,   19.1332111,  -6.35263491
  56920,  -27.9611797,   19.1332111,  -6.35263491
  56921,  -27.1151295,   19.1332111,  -6.35263491
  56922,  -26.2690773,   19.1332111,  -6.35263443
  56923,  -25.4230251,   19.1332111,  -6.35263443
  56924,  -24.5769749,   19.1332111,  -6.35263443
  56925,  -23.7309227,   19.1332111,  -6.35263443
  56926,  -22.8848705,   19.1332111,  -6.35263443
  56927,  -22.0388203,   19.1332111,  -6.35263443
  56928,  -21.1927681,   19.1332111,  -6.35263443
  56929,  -28.6235542,   18.5719738,  -6.74992228
  56930,  -27.8183212,   18.5719738,  -6.74992228
  56931,  -27.0130863,   18.5719738,  -6.74992228
  56932,  -26.2078514,   18.5719738,  -6.74992228
  56933,  -25.4026165,   18.5719738,  -6.74992228
  56934,  -24.5973835,   18.5719738,  -6.74992228
  56935,  -23.7921486,   18.5719738,  -6.74992228
  56936,  -22.9869137,   18.5719738,  -6.74992228
  56937,  -22.1816788,   18.5719738,  -6.74992228
  56938,  -21.3764458,   18.5719738,  -6.74992228
  56939,  -28.4169464,     17.94067,   -7.0910821
  56940,  -27.6576252,     17.94067,   -7.0910821
  56941,   -26.898304,     17.94067,   -7.0910821
  56942,  -26.1389828,     17.94067,   -7.0910821
  56943,  -25.3796597,     17.94067,   -7.0910821
  56944,  -24.6203403,     17.94067,   -7.0910821
  56945,  -23.8610172,     17.94067,  -7.09108257
  56946,   -23.101696,     17.94067,  -7.09108257
  56947,  -22.3423748,     17.94067,  -7.09108257
  56948,  -21.5830536,     17.94067,  -7.09108257
  56949,  -28.1920376,   17.2534447,  -7.36520672
  56950,  -27.4826965,   17.2534447,  -7.36520672
  56951,  -26.7733555,   17.2534447,  -7.36520672
  56952,  -26.0640144,   17.2534447,  -7.36520672
  56953,  -25.3546734,   17.2534447,  -7.36520672
  56954,  -24.6453285,   17.2534428,  -7.36520672
  56955,  -23.9359875,   17.2534428,  -7.36520672
  56956,  -23.2266464,   17.2534428,  -7.36520672
  56957,  -22.5173054,   17.2534428,  -7.36520672
  56958,  -21.8079643,   17.2534428,  -7.36520672
  56959,  -27.9535866,   16.5248508,  -7.56513405
  56960,  -27.2972336,   16.5248508,  -7.56513405
  56961,  -26.6408825,   16.5248508,  -7.56513405
  56962,  -25.9845295,   16.5248508,  -7.56513405
  56963,  -25.3281765,   16.5248508,  -7.56513453
  56964,  -24.6718235,   16.5248508,  -7.56513453
  56965,  -24.0154705,   16.5248508,  -7.56513453
  56966,  -23.3591175,   16.5248508,  -7.56513453
  56967,  -22.7027664,   16.5248508,  -7.56513453
  56968,  -22.0464134,   16.5248508,  -7.56513453
  56969,  -27.7062607,   15.7691269,  -7.68656683
  56970,  -27.1048698,   15.7691269,  -7.68656683
  56971,   -26.503479,   15.7691269,  -7.68656683
  56972,  -25.9020882,   15.7691269,  -7.68656683
  56973,  -25.3006973,   15.7691269,  -7.68656683
  56974,  -24.6993065,   15.7691259,  -7.68656683
  56975,  -24.0979137,   15.7691259,  -7.68656683
  56976,  -23.4965229,   15.7691259,  -7.68656683
  56977,  -22.8951321,   15.7691259,  -7.68656683
  56978,  -22.2937412,   15.7691259,  -7.68656683
  56979,  -28.9794712,   19.6594906,  -5.09732294
  56980,  -28.0951424,   19.6594906,  -5.09732294
  56981,  -27.2108173,   19.6594906,  -5.09732246
  56982,  -26.3264904,   19.6594906,  -5.09732246
  56983,  -25.4421635,   19.6594906,  -5.09732246
  56984,  -24.5578365,   19.6594906,  -5.09732246
  56985,  -23.6735096,   19.6594906,  -5.09732246
  56986,  -22.7891827,   19.6594906,  -5.09732246
  56987,  -21.9048576,   19.6594906,  -5.09732199
  56988,  -21.0205288,   19.6594906,  -5.09732199
  56989,  -28.8323154,   19.2098522,  -5.62316179
  56990,    -27.98069,   19.2098522,  -5.62316179
  56991,  -27.1290627,   19.2098522,  -5.62316132
  56992,  -26.2774372,   19.2098522,  -5.62316132
  56993,  -25.4258118,   19.2098522,  -5.62316132
  56994,  -24.5741863,   19.2098522,  -5.62316132
  56995,  -23.7225628,   19.2098522,  -5.62316132
  56996,  -22.8709373,   19.2098522,  -5.62316132
  56997,    -22.01931,   19.2098522,  -5.62316132
  56998,  -21.1676846,   19.2098522,  -5.62316132
  56999,  -28.6528091,   18.6613674,  -6.09990692
  57000,  -27.8410759,   18.6613674,  -6.09990692
  57001,  -27.0293388,   18.6613674,  -6.09990692
  57002,  -26.2176037,   18.6613674,  -6.09990692
  57003,  -25.4058685,   18.6613674,  -6.09990692
  57004,  -24.5941315,   18.6613674,  -6.09990692
  57005,  -23.7823963,   18.6613674,  -6.09990692
  57006,  -22.9706612,   18.6613674,  -6.09990692
  57007,  -22.1589241,   18.6613674,  -6.09990692
  57008,  -21.3471909,   18.6613674,  -6.09990692
  57009,  -28.4457893,   18.0288048,   -6.5092988
  57010,  -27.6800594,   18.0288048,   -6.5092988
  57011,  -26.9143276,   18.0288048,   -6.5092988
  57012,  -26.1485977,   18.0288048,   -6.5092988
  57013,  -25.3828659,   18.0288048,   -6.5092988
  57014,  -24.6171341,   18.0288048,   -6.5092988
  57015,  -23.8514023,   18.0288048,   -6.5092988
  57016,  -23.0856724,   18.0288048,   -6.5092988
  57017,  -22.3199406,   18.0288048,   -6.5092988
  57018,  -21.5542107,   18.0288048,   -6.5092988
  57019,  -28.2168064,   17.3291321,  -6.83824778
  57020,  -27.5019608,   17.3291321,  -6.83824778
  57021,  -26.7871151,   17.3291321,  -6.83824778
  57022,  -26.0722694,   17.3291321,  -6.83824778
  57023,  -25.3574238,   17.3291321,  -6.83824778
  57024,  -24.6425762,   17.3291321,  -6.83824825
  57025,  -23.9277306,   17.3291321,  -6.83824825
  57026,  -23.2128849,   17.3291321,  -6.83824825
  57027,  -22.4980392,   17.3291321,  -6.83824825
  57028,  -21.7831936,   17.3291321,  -6.83824825
  57029,  -27.9715786,   16.5798225,  -7.07816076
  57030,  -27.3112278,   16.5798225,  -7.07816076
  57031,   -26.650877,   16.5798225,  -7.07816076
  57032,  -25.9905262,   16.5798225,  -7.07816076
  57033,  -25.3301754,   16.5798206,  -7.07816124
  57034,  -24.6698265,   16.5798206,  -7.07816124
  57035,  -24.0094757,   16.5798206,  -7.07816124
  57036,  -23.3491249,   16.5798206,  -7.07816124
  57037,  -22.6887741,   16.5798206,  -7.07816124
  57038,  -22.0284233,   16.5798206,  -7.07816124
  57039,  -27.7156925,   15.7979517,  -7.22388029
  57040,  -27.1122074,   15.7979517,  -7.22388029
  57041,  -26.5087185,   15.7979517,  -7.22388029
  57042,  -25.9052315,   15.7979507,  -7.22388029
  57043,  -25.3017445,   15.7979507,  -7.22388029
  57044,  -24.6982574,   15.7979517,  -7.22388029
  57045,  -24.0947704,   15.7979517,  -7.22388029
  57046,  -23.4912834,   15.7979517,  -7.22388029
  57047,  -22.8877964,   15.7979517,  -7.22388029
  57048,  -22.2843094,   15.7979517,  -7.22388029
  57049,  -28.9949894,   19.7069054,  -4.28021002
  57050,  -28.1072121,   19.7069054,  -4.28021002
  57051,  -27.2194386,   19.7069054,  -4.28020954
  57052,  -26.3316631,   19.7069054,  -4.28020954
  57053,  -25.4438877,   19.7069054,  -4.28020954
  57054,  -24.5561123,   19.7069054,  -4.28020954
  57055,  -23.6683369,   19.7069054,  -4.28020954
  57056,  -22.7805614,   19.7069054,  -4.28020954
  57057,  -21.8927879,   19.7069054,  -4.28020906
  57058,  -21.0050106,   19.7069054,  -4.28020906
  57059,  -28.8573971,   19.2864952,  -4.89368916
  57060,  -28.0001984,   19.2864952,  -4.89368868
  57061,  -27.1429977,   19.2864952,  -4.89368868
  57062,   -26.285799,   19.2864952,  -4.89368868
  57063,  -25.4285984,   19.2864952,  -4.89368868
  57064,  -24.5713997,   19.2864952,  -4.89368868
  57065,   -23.714201,   19.2864952,  -4.89368868
  57066,  -22.8570023,   19.2864952,  -4.89368868
  57067,  -21.9998016,   19.2864952,   -4.8936882
  57068,  -21.1426029,   19.2864952,   -4.8936882
  57069,  -28.6820679,   18.7507629,  -5.44989157
  57070,  -27.8638306,   18.7507629,  -5.44989157
  57071,  -27.0455933,   18.7507629,  -5.44989157
  57072,   -26.227356,   18.7507629,  -5.44989157
  57073,  -25.4091187,   18.7507629,  -5.44989157
  57074,  -24.5908813,   18.7507629,  -5.44989157
  57075,   -23.772644,   18.7507629,  -5.44989157
  57076,  -22.9544067,   18.7507629,  -5.44989157
  57077,  -22.1361694,   18.7507629,  -5.44989109
  57078,  -21.3179321,   18.7507629,  -5.44989109
  57079,  -28.4746361,   18.1169395,  -5.92751503
  57080,  -27.7024937,   18.1169395,  -5.92751503
  57081,  -26.9303532,   18.1169395,  -5.92751503
  57082,  -26.1582127,   18.1169395,  -5.92751503
  57083,  -25.3860703,   18.1169395,  -5.92751503
  57084,  -24.6139317,   18.1169376,  -5.92751503
  57085,  -23.8417892,   18.1169376,  -5.92751551
  57086,  -23.0696487,   18.1169376,  -5.92751551
  57087,  -22.2975082,   18.1169376,  -5.92751551
  57088,  -21.5253658,   18.1169376,  -5.92751551
  57089,  -28.2415791,   17.4048214,  -6.31128931
  57090,  -27.5212269,   17.4048214,  -6.31128931
  57091,  -26.8008766,   17.4048214,  -6.31128931
  57092,  -26.0805264,   17.4048214,  -6.31128931
  57093,  -25.3601761,   17.4048214,  -6.31128931
  57094,  -24.6398239,   17.4048214,  -6.31128979
  57095,  -23.9194736,   17.4048214,  -6.31128979
  57096,  -23.1991234,   17.4048214,  -6.31128979
  57097,  -22.4787731,   17.4048214,  -6.31128979
  57098,  -21.7584229,   17.4048214,  -6.31128979
  57099,  -27.9895687,   16.6347923,  -6.59118748
  57100,  -27.3252201,   16.6347923,  -6.59118748
  57101,  -26.6608715,   16.6347923,  -6.59118748
  57102,  -25.9965229,   16.6347923,  -6.59118748
  57103,  -25.3321743,   16.6347904,  -6.59118795
  57104,  -24.6678276,   16.6347904,  -6.59118795
  57105,   -24.003479,   16.6347904,  -6.59118795
  57106,  -23.3391304,   16.6347904,  -6.59118795
  57107,  -22.6747818,   16.6347904,  -6.59118795
  57108,  -22.0104332,   16.6347904,  -6.59118795
  57109,  -27.7251263,   15.8267775,  -6.76119328
  57110,   -27.119545,   15.8267775,  -6.76119328
  57111,  -26.5139599,   15.8267775,  -6.76119328
  57112,  -25.9083767,   15.8267765,  -6.76119375
  57113,  -25.3027916,   15.8267765,  -6.76119375
  57114,  -24.6972084,   15.8267775,  -6.76119375
  57115,  -24.0916233,   15.8267775,  -6.76119375
  57116,  -23.4860401,   15.8267775,  -6.76119375
  57117,  -22.8804569,   15.8267775,  -6.76119375
  57118,  -22.2748737,   15.8267775,  -6.76119375
  57119,  -29.0105057,   19.7543201,   -3.4630971
  57120,  -28.1192818,   19.7543201,   -3.4630971
  57121,  -27.2280579,   19.7543201,  -3.46309686
  57122,   -26.336834,   19.7543201,  -3.46309686
  57123,   -25.445612,   19.7543201,  -3.46309662
  57124,   -24.554388,   19.7543201,  -3.46309662
  57125,   -23.663166,   19.7543201,  -3.46309638
  57126,  -22.7719421,   19.7543201,  -3.46309638
  57127,  -21.8807182,   19.7543201,  -3.46309614
  57128,  -20.9894943,   19.7543201,  -3.46309614
  57129,  -28.8824806,   19.3631363,  -4.16421604
  57130,  -28.0197067,   19.3631363,  -4.16421556
  57131,  -27.1569328,   19.3631363,  -4.16421556
  57132,  -26.2941589,   19.3631363,  -4.16421556
  57133,   -25.431385,   19.3631363,  -4.16421556
  57134,  -24.5686131,   19.3631363,  -4.16421556
  57135,  -23.7058411,   19.3631363,  -4.16421556
  57136,  -22.8430672,   19.3631363,  -4.16421509
  57137,  -21.9802933,   19.3631363,  -4.16421509
  57138,  -21.1175194,   19.3631363,  -4.16421509
  57139,  -28.7113247,   18.8401585,  -4.79987574
  57140,  -27.8865871,   18.8401585,  -4.79987574
  57141,  -27.0618477,   18.8401585,  -4.79987574
  57142,  -26.2371082,   18.8401585,  -4.79987574
  57143,  -25.4123688,   18.8401585,  -4.79987621
  57144,  -24.5876312,   18.8401585,  -4.79987574
  57145,  -23.7628918,   18.8401585,  -4.79987574
  57146,  -22.9381523,   18.8401585,  -4.79987574
  57147,  -22.1134129,   18.8401585,  -4.79987574
  57148,  -21.2886753,   18.8401585,  -4.79987574
  57149,  -28.5034771,   18.2050724,  -5.34573174
  57150,  -27.7249279,   18.2050724,  -5.34573174
  57151,  -26.9463768,   18.2050724,  -5.34573174
  57152,  -26.1678257,   18.2050724,  -5.34573174
  57153,  -25.3892746,   18.2050724,  -5.34573174
  57154,  -24.6107254,   18.2050724,  -5.34573174
  57155,  -23.8321743,   18.2050724,  -5.34573221
  57156,  -23.0536232,   18.2050724,  -5.34573221
  57157,  -22.2750721,   18.2050724,  -5.34573221
  57158,  -21.4965229,   18.2050724,  -5.34573221
  57159,  -28.2663498,   17.4805107,  -5.78433037
  57160,   -27.540493,   17.4805107,  -5.78433037
  57161,  -26.8146381,   17.4805107,  -5.78433037
  57162,  -26.0887833,   17.4805107,  -5.78433037
  57163,  -25.3629284,   17.4805107,  -5.78433037
  57164,  -24.6370735,   17.4805088,  -5.78433084
  57165,  -23.9112186,   17.4805088,  -5.78433084
  57166,  -23.1853638,   17.4805088,  -5.78433084
  57167,  -22.4595089,   17.4805088,  -5.78433084
  57168,   -21.733654,   17.4805088,  -5.78433084
  57169,  -28.0075588,   16.6897621,  -6.10421467
  57170,  -27.3392124,   16.6897621,  -6.10421467
  57171,   -26.670866,   16.6897621,  -6.10421467
  57172,  -26.0025196,   16.6897621,  -6.10421467
  57173,  -25.3341732,   16.6897602,  -6.10421515
  57174,  -24.6658287,   16.6897602,  -6.10421515
  57175,  -23.9974823,   16.6897602,  -6.10421515
  57176,  -23.3291359,   16.6897602,  -6.10421515
  57177,  -22.6607895,   16.6897602,  -6.10421515
  57178,  -21.9924431,   16.6897602,  -6.10421515
  57179,    -27.73456,   15.8556023,  -6.29850674
  57180,  -27.1268806,   15.8556023,  -6.29850674
  57181,  -26.5192013,   15.8556023,  -6.29850674
  57182,    -25.91152,   15.8556013,  -6.29850721
  57183,  -25.3038406,   15.8556013,  -6.29850721
  57184,  -24.6961613,   15.8556023,  -6.29850721
  57185,    -24.08848,   15.8556023,  -6.29850721
  57186,  -23.4807987,   15.8556023,  -6.29850721
  57187,  -22.8731194,   15.8556023,  -6.29850721
  57188,    -22.26544,   15.8556023,  -6.29850721
  57189,  -29.0260239,   19.8017349,  -2.64598441
  57190,  -28.1313515,   19.8017349,  -2.64598441
  57191,  -27.2366791,   19.8017349,  -2.64598417
  57192,  -26.3420067,   19.8017349,  -2.64598393
  57193,  -25.4473362,   19.8017349,   -2.6459837
  57194,  -24.5526638,   19.8017349,   -2.6459837
  57195,  -23.6579933,   19.8017349,  -2.64598346
  57196,  -22.7633209,   19.8017349,  -2.64598346
  57197,  -21.8686485,   19.8017349,  -2.64598322
  57198,  -20.9739761,   19.8017349,  -2.64598298
  57199,  -28.9075642,   19.4397793,  -3.43474269
  57200,  -28.0392151,   19.4397793,  -3.43474245
  57201,  -27.1708679,   19.4397793,  -3.43474245
  57202,  -26.3025208,   19.4397793,  -3.43474245
  57203,  -25.4341736,   19.4397793,  -3.43474221
  57204,  -24.5658264,   19.4397793,  -3.43474221
  57205,  -23.6974792,   19.4397793,  -3.43474221
  57206,  -22.8291321,   19.4397793,  -3.43474197
  57207,  -21.9607849,   19.4397793,  -3.43474197
  57208,  -21.0924358,   19.4397793,  -3.43474174
  57209,  -28.7405796,   18.9295521,  -4.14986038
  57210,  -27.9093418,   18.9295521,  -4.14986038
  57211,  -27.0781002,   18.9295521,  -4.14986086
  57212,  -26.2468605,   18.9295521,  -4.14986086
  57213,  -25.4156189,   18.9295521,  -4.14986086
  57214,  -24.5843811,   18.9295521,  -4.14986038
  57215,  -23.7531395,   18.9295521,  -4.14986038
  57216,  -22.9218998,   18.9295521,  -4.14986038
  57217,  -22.0906582,   18.9295521,  -4.14986038
  57218,  -21.2594204,   18.9295521,  -4.14986038
  57219,  -28.5323219,   18.2932072,  -4.76394796
  57220,  -27.7473621,   18.2932072,  -4.76394796
  57221,  -26.9624004,   18.2932072,  -4.76394796
  57222,  -26.1774406,   18.2932072,  -4.76394796
  57223,  -25.3924789,   18.2932072,  -4.76394796
  57224,  -24.6075211,   18.2932072,  -4.76394796
  57225,  -23.8225594,   18.2932072,  -4.76394844
  57226,  -23.0375996,   18.2932072,  -4.76394844
  57227,  -22.2526379,   18.2932072,  -4.76394844
  57228,  -21.4676781,   18.2932072,  -4.76394844
  57229,  -28.2911205,   17.5561981,   -5.2573719
  57230,  -27.5597591,   17.5561981,   -5.2573719
  57231,  -26.8283997,   17.5561981,   -5.2573719
  57232,  -26.0970402,   17.5561981,   -5.2573719
  57233,  -25.3656807,   17.5561981,   -5.2573719
  57234,  -24.6343193,   17.5561981,  -5.25737238
  57235,  -23.9029598,   17.5561981,  -5.25737238
  57236,  -23.1716003,   17.5561981,  -5.25737238
  57237,  -22.4402409,   17.5561981,  -5.25737238
  57238,  -21.7088814,   17.5561981,  -5.25737238
  57239,  -28.0255489,   16.7447319,  -5.61724138
  57240,  -27.3532047,   16.7447319,  -5.61724138
  57241,  -26.6808605,   16.7447319,  -5.61724138
  57242,  -26.0085163,   16.7447319,  -5.61724138
  57243,  -25.3361721,   16.7447319,  -5.61724186
  57244,  -24.6638279,   16.7447319,  -5.61724186
  57245,  -23.9914837,   16.7447319,  -5.61724186
  57246,  -23.3191395,   16.7447319,  -5.61724186
  57247,  -22.6467953,   16.7447319,  -5.61724186
  57248,  -21.9744511,   16.7447319,  -5.61724186
  57249,  -27.7439938,    15.884428,   -5.8358202
  57250,  -27.1342182,    15.884428,   -5.8358202
  57251,  -26.5244408,    15.884428,   -5.8358202
  57252,  -25.9146652,   15.8844271,  -5.83582067
  57253,  -25.3048897,   15.8844271,   -5.8358202
  57254,  -24.6951122,    15.884428,   -5.8358202
  57255,  -24.0853348,    15.884428,   -5.8358202
  57256,  -23.4755592,    15.884428,   -5.8358202
  57257,  -22.8657837,    15.884428,   -5.8358202
  57258,  -22.2560062,    15.884428,   -5.8358202
  57259,  -29.0415401,   19.8491497,  -1.82887149
  57260,  -28.1434193,   19.8491497,  -1.82887137
  57261,  -27.2453003,   19.8491497,  -1.82887125
  57262,  -26.3471794,   19.8491497,  -1.82887101
  57263,  -25.4490604,   19.8491497,  -1.82887089
  57264,  -24.5509396,   19.8491497,  -1.82887065
  57265,  -23.6528206,   19.8491497,  -1.82887053
  57266,  -22.7546997,   19.8491497,  -1.82887042
  57267,  -21.8565807,   19.8491497,   -1.8288703
  57268,  -20.9584599,   19.8491497,  -1.82887018
  57269,  -28.9326458,   19.5164204,  -2.70526981
  57270,  -28.0587254,   19.5164204,  -2.70526958
  57271,   -27.184803,   19.5164204,  -2.70526958
  57272,  -26.3108807,   19.5164204,  -2.70526934
  57273,  -25.4369602,   19.5164204,  -2.70526934
  57274,  -24.5630379,   19.5164223,   -2.7052691
  57275,  -23.6891193,   19.5164223,   -2.7052691
  57276,   -22.815197,   19.5164223,   -2.7052691
  57277,  -21.9412746,   19.5164223,  -2.70526886
  57278,  -21.0673542,   19.5164223,  -2.70526886
  57279,  -28.7698364,   19.0189476,  -3.49984527
  57280,  -27.9320946,   19.0189476,  -3.49984527
  57281,  -27.0943527,   19.0189476,  -3.49984527
  57282,  -26.2566128,   19.0189476,  -3.49984527
  57283,  -25.4188709,   19.0189476,  -3.49984527
  57284,  -24.5811291,   19.0189476,  -3.49984503
  57285,  -23.7433872,   19.0189476,  -3.49984503
  57286,  -22.9056473,   19.0189476,  -3.49984503
  57287,  -22.0679054,   19.0189476,  -3.49984503
  57288,  -21.2301636,   19.0189476,  -3.49984503
  57289,  -28.5611668,   18.3813419,  -4.18216467
  57290,  -27.7697964,   18.3813419,  -4.18216467
  57291,   -26.978426,   18.3813419,  -4.18216467
  57292,  -26.1870575,   18.3813419,  -4.18216467
  57293,  -25.3956852,   18.3813419,  -4.18216467
  57294,  -24.6043167,     18.38134,  -4.18216467
  57295,  -23.8129444,     18.38134,  -4.18216467
  57296,  -23.0215759,     18.38134,  -4.18216467
  57297,  -22.2302055,     18.38134,  -4.18216467
  57298,  -21.4388351,     18.38134,  -4.18216467
  57299,  -28.3158913,   17.6318874,  -4.73041344
  57300,  -27.5790253,   17.6318874,  -4.73041344
  57301,  -26.8421612,   17.6318874,  -4.73041344
  57302,  -26.1052971,   17.6318874,  -4.73041344
  57303,   -25.368433,   17.6318874,  -4.73041344
  57304,   -24.631567,   17.6318874,  -4.73041391
  57305,  -23.8947029,   17.6318874,  -4.73041391
  57306,  -23.1578388,   17.6318874,  -4.73041391
  57307,  -22.4209747,   17.6318874,  -4.73041391
  57308,  -21.6841106,   17.6318874,  -4.73041391
  57309,   -28.043539,   16.7997036,   -5.1302681
  57310,   -27.367197,   16.7997036,   -5.1302681
  57311,   -26.690855,   16.7997036,   -5.1302681
  57312,   -26.014513,   16.7997036,   -5.1302681
  57313,   -25.338171,   16.7997017,  -5.13026857
  57314,   -24.661829,   16.7997017,  -5.13026857
  57315,   -23.985487,   16.7997017,  -5.13026857
  57316,   -23.309145,   16.7997017,  -5.13026857
  57317,   -22.632803,   16.7997017,  -5.13026857
  57318,   -21.956461,   16.7997017,  -5.13026857
  57319,  -27.7534275,   15.9132538,  -5.37313366
  57320,  -27.1415558,   15.9132538,  -5.37313366
  57321,  -26.5296822,   15.9132538,  -5.37313366
  57322,  -25.9178085,   15.9132528,  -5.37313414
  57323,  -25.3059368,   15.9132528,  -5.37313366
  57324,  -24.6940651,   15.9132528,  -5.37313366
  57325,  -24.0821915,   15.9132528,  -5.37313366
  57326,  -23.4703178,   15.9132528,  -5.37313366
  57327,  -22.8584461,   15.9132528,  -5.37313366
  57328,  -22.2465725,   15.9132528,  -5.37313366
  57329,  -21.0981178,   10.5775852,   9.18288708
  57330,  -21.0826015,   10.5301704,   8.36577415
  57331,  -21.0670834,   10.4827547,   7.54866076
  57332,  -21.0515652,   10.4353399,   6.73154783
  57333,  -21.0360489,   10.3879251,   5.91443491
  57334,  -21.0205288,   10.3405104,   5.09732199
  57335,  -21.0050106,   10.2930946,   4.28020906
  57336,  -20.9894943,   10.2456799,   3.46309614
  57337,  -20.9739761,   10.1982651,   2.64598298
  57338,  -20.9584599,   10.1508503,   1.82887018
  57339,  -21.2930984,    11.173358,   9.27052689
  57340,  -21.2680168,   11.0967159,   8.54105377
  57341,  -21.2429333,   11.0200739,   7.81158066
  57342,  -21.2178497,   10.9434319,   7.08210754
  57343,  -21.1927681,   10.8667889,   6.35263443
  57344,  -21.1676846,   10.7901468,   5.62316132
  57345,  -21.1426029,   10.7135048,    4.8936882
  57346,  -21.1175194,   10.6368628,   4.16421509
  57347,  -21.0924358,   10.5602207,   3.43474174
  57348,  -21.0673542,   10.4835787,   2.70526886
  57349,  -21.4934731,   11.7856054,   9.34998417
  57350,  -21.4642143,   11.6962109,   8.69996929
  57351,  -21.4349594,   11.6068163,   8.04995346
  57352,  -21.4057026,   11.5174208,   7.39993811
  57353,  -21.3764458,   11.4280262,   6.74992228
  57354,  -21.3471889,   11.3386316,   6.09990692
  57355,  -21.3179321,   11.2492371,   5.44989109
  57356,  -21.2886772,   11.1598425,   4.79987574
  57357,  -21.2594204,   11.0704479,   4.14986038
  57358,  -21.2301636,   10.9810524,   3.49984479
  57359,  -21.6984291,   12.4118662,   9.41821671
  57360,  -21.6695843,   12.3237324,   8.83643341
  57361,  -21.6407413,   12.2355976,   8.25464916
  57362,  -21.6118965,   12.1474638,   7.67286587
  57363,  -21.5830536,     12.05933,   7.09108257
  57364,  -21.5542107,   11.9711962,    6.5092988
  57365,  -21.5253658,   11.8830614,   5.92751551
  57366,  -21.4965229,   11.7949276,   5.34573221
  57367,    -21.46768,   11.7067938,   4.76394844
  57368,  -21.4388351,     11.61866,   4.18216467
  57369,  -21.9070473,   13.0493116,   9.47304153
  57370,  -21.8822765,   12.9736223,   8.94608307
  57371,  -21.8575058,    12.897934,    8.4191246
  57372,  -21.8327351,   12.8222456,   7.89216566
  57373,  -21.8079643,   12.7465563,   7.36520672
  57374,  -21.7831936,   12.6708679,   6.83824778
  57375,  -21.7584248,   12.5951796,   6.31128931
  57376,  -21.7336521,   12.5194902,   5.78433037
  57377,  -21.7088814,   12.4438019,    5.2573719
  57378,  -21.6841106,   12.3681135,   4.73041344
  57379,  -22.1183739,   13.6950302,   9.51302719
  57380,  -22.1003838,   13.6400595,   9.02605343
  57381,  -22.0823936,   13.5850897,   8.53908062
  57382,  -22.0644035,   13.5301199,   8.05210781
  57383,  -22.0464134,   13.4751492,   7.56513453
  57384,  -22.0284233,   13.4201794,   7.07816124
  57385,  -22.0104332,   13.3652096,   6.59118795
  57386,  -21.9924412,   13.3102388,   6.10421515
  57387,  -21.9744511,   13.2552691,   5.61724186
  57388,   -21.956461,   13.2002983,   5.13026857
  57389,  -22.3314762,   14.3461752,   9.53731346
  57390,  -22.3220425,   14.3173494,   9.07462692
  57391,  -22.3126087,   14.2885246,   8.61194038
  57392,   -22.303175,   14.2596989,   8.14925385
  57393,  -22.2937412,   14.2308741,   7.68656683
  57394,  -22.2843094,   14.2020483,   7.22388029
  57395,  -22.2748737,   14.1732225,   6.76119375
  57396,    -22.26544,   14.1443977,   6.29850721
  57397,  -22.2560062,    14.115572,    5.8358202
  57398,  -22.2465725,   14.0867472,   5.37313366
  57399,  -21.9652023,   10.5775852,   9.18288708
  57400,  -21.9531345,   10.5301704,   8.36577415
  57401,  -21.9410648,   10.4827547,   7.54866076
  57402,  -21.9289951,   10.4353399,   6.73154783
  57403,  -21.9169254,   10.3879251,   5.91443491
  57404,  -21.9048576,   10.3405104,   5.09732199
  57405,   -21.892786,   10.2930946,   4.28020906
  57406,  -21.8807182,   10.2456799,   3.46309614
  57407,  -21.8686485,   10.1982651,   2.64598322
  57408,  -21.8565807,   10.1508503,    1.8288703
  57409,  -22.1168556,    11.173358,   9.27052689
  57410,  -22.0973454,   11.0967159,   8.54105377
  57411,   -22.077837,   11.0200739,   7.81158066
  57412,  -22.0583286,   10.9434319,   7.08210754
  57413,  -22.0388203,   10.8667889,   6.35263443
  57414,    -22.01931,   10.7901468,   5.62316132
  57415,  -21.9998016,   10.7135048,    4.8936882
  57416,  -21.9802933,   10.6368628,   4.16421509
  57417,  -21.9607849,   10.5602207,   3.43474197
  57418,  -21.9412746,   10.4835787,   2.70526886
  57419,  -22.2726994,   11.7856054,   9.34998417
  57420,  -22.2499447,   11.6962109,   8.69996929
  57421,    -22.22719,   11.6068163,   8.04995346
  57422,  -22.2044334,   11.5174208,   7.39993811
  57423,  -22.1816788,   11.4280262,   6.74992228
  57424,  -22.1589241,   11.3386316,   6.09990692
  57425,  -22.1361694,   11.2492371,   5.44989109
  57426,  -22.1134148,   11.1598425,   4.79987574
  57427,  -22.0906582,   11.0704479,   4.14986038
  57428,  -22.0679054,   10.9810524,   3.49984479
  57429,  -22.4321117,   12.4118662,   9.41821671
  57430,  -22.4096775,   12.3237324,   8.83643341
  57431,  -22.3872433,   12.2355976,   8.25464916
  57432,   -22.364809,   12.1474638,   7.67286587
  57433,  -22.3423748,     12.05933,   7.09108257
  57434,  -22.3199406,   11.9711962,    6.5092988
  57435,  -22.2975063,   11.8830614,   5.92751551
  57436,  -22.2750721,   11.7949276,   5.34573221
  57437,  -22.2526398,   11.7067938,   4.76394844
  57438,  -22.2302055,     11.61866,   4.18216467
  57439,  -22.5943699,   13.0493116,   9.47304153
  57440,  -22.5751038,   12.9736223,   8.94608307
  57441,  -22.5558376,    12.897934,    8.4191246
  57442,  -22.5365715,   12.8222456,   7.89216566
  57443,  -22.5173054,   12.7465563,   7.36520672
  57444,  -22.4980392,   12.6708679,   6.83824778
  57445,   -22.478775,   12.5951796,   6.31128931
  57446,   -22.459507,   12.5194902,   5.78433037
  57447,  -22.4402409,   12.4438019,    5.2573719
  57448,  -22.4209747,   12.3681135,   4.73041344
  57449,  -22.7587357,   13.6950302,   9.51302719
  57450,  -22.7447433,   13.6400595,   9.02605343
  57451,   -22.730751,   13.5850897,   8.53908062
  57452,  -22.7167587,   13.5301199,   8.05210781
  57453,  -22.7027664,   13.4751492,   7.56513453
  57454,  -22.6887741,   13.4201794,   7.07816124
  57455,  -22.6747818,   13.3652096,   6.59118795
  57456,  -22.6607876,   13.3102388,   6.10421515
  57457,  -22.6467953,   13.2552691,   5.61724186
  57458,   -22.632803,   13.2002983,   5.13026857
  57459,  -22.9244804,   14.3461752,   9.53731346
  57460,  -22.9171429,   14.3173494,   9.07462692
  57461,  -22.9098072,   14.2885246,   8.61194038
  57462,  -22.9024696,   14.2596989,   8.14925385
  57463,  -22.8951321,   14.2308741,   7.68656683
  57464,  -22.8877964,   14.2020483,   7.22388029
  57465,  -22.8804569,   14.1732225,   6.76119375
  57466,  -22.8731194,   14.1443977,   6.29850721
  57467,  -22.8657837,    14.115572,    5.8358202
  57468,  -22.8584461,   14.0867472,   5.37313366
  57469,  -22.8322887,   10.5775852,   9.18288708
  57470,  -22.8236675,   10.5301704,   8.36577415
  57471,  -22.8150463,   10.4827547,   7.54866123
  57472,  -22.8064251,   10.4353399,   6.73154831
  57473,  -22.7978058,   10.3879251,   5.91443539
  57474,  -22.7891827,   10.3405104,   5.09732246
  57475,  -22.7805614,   10.2930946,   4.28020954
  57476,  -22.7719421,   10.2456799,   3.46309638
  57477,  -22.7633209,   10.1982651,   2.64598346
  57478,  -22.7546997,   10.1508503,   1.82887042
  57479,  -22.9406109,    11.173358,   9.27052689
  57480,  -22.9266758,   11.0967159,   8.54105377
  57481,  -22.9127407,   11.0200739,   7.81158066
  57482,  -22.8988056,   10.9434319,   7.08210754
  57483,  -22.8848705,   10.8667889,   6.35263443
  57484,  -22.8709373,   10.7901468,   5.62316132
  57485,  -22.8570023,   10.7135048,   4.89368868
  57486,  -22.8430672,   10.6368628,   4.16421509
  57487,  -22.8291321,   10.5602207,   3.43474197
  57488,   -22.815197,   10.4835787,    2.7052691
  57489,  -23.0519295,   11.7856054,   9.34998417
  57490,   -23.035675,   11.6962109,   8.69996929
  57491,  -23.0194225,   11.6068163,   8.04995346
  57492,  -23.0031681,   11.5174208,   7.39993811
  57493,  -22.9869137,   11.4280262,   6.74992228
  57494,  -22.9706612,   11.3386316,   6.09990692
  57495,  -22.9544067,   11.2492371,   5.44989109
  57496,  -22.9381542,   11.1598425,   4.79987574
  57497,  -22.9218998,   11.0704479,   4.14986038
  57498,  -22.9056473,   10.9810524,   3.49984479
  57499,  -23.1657944,   12.4118662,   9.41821671
  57500,  -23.1497688,   12.3237324,   8.83643341
  57501,  -23.1337452,   12.2355976,   8.25464916
  57502,  -23.1177216,   12.1474638,   7.67286587
  57503,   -23.101696,     12.05933,   7.09108257
  57504,  -23.0856724,   11.9711962,    6.5092988
  57505,  -23.0696487,   11.8830614,   5.92751551
  57506,  -23.0536232,   11.7949276,   5.34573221
  57507,  -23.0375996,   11.7067938,   4.76394844
  57508,  -23.0215759,     11.61866,   4.18216467
  57509,  -23.2816925,   13.0493116,   9.47304153
  57510,   -23.267931,   12.9736223,   8.94608307
  57511,  -23.2541695,    12.897934,    8.4191246
  57512,  -23.2404079,   12.8222456,   7.89216566
  57513,  -23.2266464,   12.7465563,   7.36520672
  57514,  -23.2128849,   12.6708679,   6.83824778
  57515,  -23.1991253,   12.5951796,   6.31128931
  57516,  -23.1853619,   12.5194902,   5.78433037
  57517,  -23.1716003,   12.4438019,    5.2573719
  57518,  -23.1578388,   12.3681135,   4.73041344
  57519,  -23.3990955,   13.6950302,   9.51302719
  57520,   -23.389101,   13.6400595,   9.02605343
  57521,  -23.3791065,   13.5850897,   8.53908062
  57522,   -23.369112,   13.5301199,   8.05210781
  57523,  -23.3591175,   13.4751492,   7.56513453
  57524,  -23.3491249,   13.4201794,   7.07816124
  57525,  -23.3391304,   13.3652096,   6.59118795
  57526,   -23.329134,   13.3102388,   6.10421515
  57527,  -23.3191395,   13.2552691,   5.61724186
  57528,   -23.309145,   13.2002983,   5.13026857
  57529,  -23.5174866,   14.3461752,   9.53731346
  57530,  -23.5122452,   14.3173494,   9.07462692
  57531,  -23.5070057,   14.2885246,   8.61194038
  57532,  -23.5017643,   14.2596989,   8.14925385
  57533,  -23.4965229,   14.2308741,   7.68656683
  57534,  -23.4912834,   14.2020483,   7.22388029
  57535,  -23.4860401,   14.1732225,   6.76119375
  57536,  -23.4807987,   14.1443977,   6.29850721
  57537,  -23.4755592,    14.115572,    5.8358202
  57538,  -23.4703178,   14.0867472,   5.37313366
  57539,  -23.6993732,   10.5775852,   9.18288708
  57540,  -23.6942005,   10.5301704,   8.36577415
  57541,  -23.6890278,   10.4827547,   7.54866123
  57542,  -23.6838551,   10.4353399,   6.73154831
  57543,  -23.6786842,   10.3879251,   5.91443539
  57544,  -23.6735096,   10.3405104,   5.09732246
  57545,  -23.6683369,   10.2930946,   4.28020954
  57546,   -23.663166,   10.2456799,   3.46309638
  57547,  -23.6579933,   10.1982651,   2.64598346
  57548,  -23.6528206,   10.1508503,   1.82887053
  57549,  -23.7643661,    11.173358,   9.27052689
  57550,  -23.7560062,   11.0967159,   8.54105377
  57551,  -23.7476444,   11.0200739,   7.81158066
  57552,  -23.7392845,   10.9434319,   7.08210754
  57553,  -23.7309227,   10.8667889,   6.35263443
  57554,  -23.7225628,   10.7901468,   5.62316132
  57555,   -23.714201,   10.7135048,   4.89368868
  57556,  -23.7058411,   10.6368628,   4.16421556
  57557,  -23.6974792,   10.5602207,   3.43474221
  57558,  -23.6891193,   10.4835787,    2.7052691
  57559,  -23.8311577,   11.7856054,   9.34998417
  57560,  -23.8214054,   11.6962109,   8.69996929
  57561,  -23.8116531,   11.6068163,   8.04995346
  57562,  -23.8019009,   11.5174208,   7.39993811
  57563,  -23.7921486,   11.4280262,   6.74992228
  57564,  -23.7823963,   11.3386316,   6.09990692
  57565,   -23.772644,   11.2492371,   5.44989109
  57566,  -23.7628918,   11.1598425,   4.79987574
  57567,  -23.7531395,   11.0704479,   4.14986038
  57568,  -23.7433872,   10.9810524,   3.49984479
  57569,  -23.8994751,   12.4118662,   9.41821671
  57570,  -23.8898602,   12.3237324,   8.83643341
  57571,  -23.8802471,   12.2355976,   8.25464916
  57572,  -23.8706322,   12.1474638,   7.67286587
  57573,  -23.8610172,     12.05933,   7.09108257
  57574,  -23.8514023,   11.9711962,    6.5092988
  57575,  -23.8417873,   11.8830614,   5.92751551
  57576,  -23.8321743,   11.7949276,   5.34573221
  57577,  -23.8225594,   11.7067938,   4.76394844
  57578,  -23.8129444,     11.61866,   4.18216467
  57579,  -23.9690151,   13.0493116,   9.47304153
  57580,  -23.9607582,   12.9736223,   8.94608307
  57581,  -23.9525013,    12.897934,    8.4191246
  57582,  -23.9442444,   12.8222456,   7.89216566
  57583,  -23.9359875,   12.7465563,   7.36520672
  57584,  -23.9277306,   12.6708679,   6.83824778
  57585,  -23.9194756,   12.5951796,   6.31128931
  57586,  -23.9112167,   12.5194902,   5.78433037
  57587,  -23.9029598,   12.4438019,    5.2573719
  57588,  -23.8947029,   12.3681135,   4.73041344
  57589,  -24.0394573,   13.6950302,   9.51302719
  57590,  -24.0334606,   13.6400595,   9.02605343
  57591,  -24.0274639,   13.5850897,   8.53908062
  57592,  -24.0214672,   13.5301199,   8.05210781
  57593,  -24.0154705,   13.4751492,   7.56513453
  57594,  -24.0094757,   13.4201784,   7.07816076
  57595,   -24.003479,   13.3652086,   6.59118748
  57596,  -23.9974804,   13.3102379,   6.10421467
  57597,  -23.9914837,   13.2552681,   5.61724138
  57598,   -23.985487,   13.2002974,    5.1302681
  57599,  -24.1104908,   14.3461752,   9.53731346
  57600,  -24.1073475,   14.3173494,   9.07462692
  57601,  -24.1042023,   14.2885246,   8.61194038
  57602,   -24.101059,   14.2596989,   8.14925385
  57603,  -24.0979137,   14.2308741,   7.68656683
  57604,  -24.0947704,   14.2020483,   7.22388029
  57605,  -24.0916233,   14.1732225,   6.76119375
  57606,    -24.08848,   14.1443977,   6.29850721
  57607,  -24.0853348,    14.115572,    5.8358202
  57608,  -24.0821915,   14.0867472,   5.37313366
  57609,  -24.5664577,   10.5775852,   9.18288708
  57610,  -24.5647335,   10.5301704,   8.36577415
  57611,  -24.5630093,   10.4827547,   7.54866123
  57612,   -24.561285,   10.4353399,   6.73154831
  57613,  -24.5595608,   10.3879251,   5.91443539
  57614,  -24.5578365,   10.3405104,   5.09732246
  57615,  -24.5561104,   10.2930946,   4.28020954
  57616,   -24.554388,   10.2456799,   3.46309662
  57617,  -24.5526638,   10.1982651,    2.6459837
  57618,  -24.5509396,   10.1508503,   1.82887065
  57619,  -24.5881233,    11.173358,   9.27052689
  57620,  -24.5853348,   11.0967159,   8.54105377
  57621,  -24.5825481,   11.0200739,   7.81158066
  57622,  -24.5797615,   10.9434319,   7.08210754
  57623,  -24.5769749,   10.8667889,   6.35263443
  57624,  -24.5741863,   10.7901468,   5.62316132
  57625,  -24.5713997,   10.7135048,   4.89368868
  57626,  -24.5686131,   10.6368628,   4.16421556
  57627,  -24.5658264,   10.5602207,   3.43474221
  57628,  -24.5630379,   10.4835787,    2.7052691
  57629,  -24.6103859,   11.7856054,   9.34998417
  57630,  -24.6071339,   11.6962109,   8.69996929
  57631,  -24.6038837,   11.6068163,   8.04995346
  57632,  -24.6006336,   11.5174208,   7.39993811
  57633,  -24.5973835,   11.4280262,   6.74992228
  57634,  -24.5941315,   11.3386316,   6.09990692
  57635,  -24.5908813,   11.2492371,   5.44989109
  57636,  -24.5876312,   11.1598425,   4.79987574
  57637,  -24.5843811,   11.0704479,   4.14986038
  57638,  -24.5811291,   10.9810524,   3.49984479
  57639,  -24.6331596,   12.4118662,   9.41821671
  57640,  -24.6299534,   12.3237324,   8.83643341
  57641,   -24.626749,   12.2355976,   8.25464916
  57642,  -24.6235447,   12.1474638,   7.67286587
  57643,  -24.6203403,     12.05933,    7.0910821
  57644,  -24.6171341,   11.9711962,    6.5092988
  57645,  -24.6139297,   11.8830614,   5.92751503
  57646,  -24.6107254,   11.7949276,   5.34573174
  57647,  -24.6075211,   11.7067938,   4.76394796
  57648,  -24.6043167,     11.61866,   4.18216467
  57649,  -24.6563377,   13.0493116,   9.47304153
  57650,  -24.6535854,   12.9736223,   8.94608307
  57651,  -24.6508331,    12.897934,    8.4191246
  57652,  -24.6480808,   12.8222456,   7.89216566
  57653,  -24.6453285,   12.7465563,   7.36520672
  57654,  -24.6425762,   12.6708679,   6.83824778
  57655,  -24.6398258,   12.5951796,   6.31128931
  57656,  -24.6370716,   12.5194902,   5.78433037
  57657,  -24.6343193,   12.4438019,    5.2573719
  57658,   -24.631567,   12.3681135,   4.73041344
  57659,  -24.6798191,   13.6950302,   9.51302719
  57660,  -24.6778202,   13.6400595,   9.02605343
  57661,  -24.6758213,   13.5850897,   8.53908062
  57662,  -24.6738224,   13.5301199,   8.05210781
  57663,  -24.6718235,   13.4751492,   7.56513453
  57664,  -24.6698265,   13.4201784,   7.07816076
  57665,  -24.6678276,   13.3652086,   6.59118748
  57666,  -24.6658268,   13.3102379,   6.10421467
  57667,  -24.6638279,   13.2552681,   5.61724138
  57668,   -24.661829,   13.2002974,    5.1302681
  57669,  -24.7034969,   14.3461752,   9.53731346
  57670,  -24.7024498,   14.3173494,   9.07462692
  57671,  -24.7014008,   14.2885246,   8.61194038
  57672,  -24.7003536,   14.2596989,   8.14925385
  57673,  -24.6993065,   14.2308741,   7.68656683
  57674,  -24.6982574,   14.2020483,   7.22388029
  57675,  -24.6972084,   14.1732225,   6.76119375
  57676,  -24.6961613,   14.1443977,   6.29850721
  57677,  -24.6951122,    14.115572,    5.8358202
  57678,  -24.6940651,   14.0867472,   5.37313366
  57679,  -25.4335423,   10.5775852,   9.18288708
  57680,  -25.4352665,   10.5301704,   8.36577415
  57681,  -25.4369907,   10.4827547,   7.54866123
  57682,   -25.438715,   10.4353399,   6.73154831
  57683,  -25.4404392,   10.3879251,   5.91443539
  57684,  -25.4421635,   10.3405104,   5.09732246
  57685,  -25.4438877,   10.2930956,   4.28020954
  57686,   -25.445612,   10.2456808,   3.46309662
  57687,  -25.4473362,   10.1982651,    2.6459837
  57688,  -25.4490604,   10.1508503,   1.82887089
  57689,  -25.4118767,    11.173358,   9.27052689
  57690,  -25.4146633,   11.0967159,   8.54105377
  57691,  -25.4174519,   11.0200739,   7.81158066
  57692,  -25.4202385,   10.9434319,   7.08210754
  57693,  -25.4230251,   10.8667889,   6.35263443
  57694,  -25.4258118,   10.7901468,   5.62316132
  57695,  -25.4285984,   10.7135048,   4.89368868
  57696,   -25.431385,   10.6368628,   4.16421556
  57697,  -25.4341736,   10.5602207,   3.43474221
  57698,  -25.4369602,   10.4835787,   2.70526934
  57699,  -25.3896141,   11.7856054,   9.34998417
  57700,  -25.3928661,   11.6962109,   8.69996929
  57701,  -25.3961163,   11.6068163,   8.04995346
  57702,  -25.3993664,   11.5174208,   7.39993811
  57703,  -25.4026165,   11.4280262,   6.74992228
  57704,  -25.4058685,   11.3386316,   6.09990692
  57705,  -25.4091187,   11.2492371,   5.44989109
  57706,  -25.4123688,   11.1598425,   4.79987574
  57707,  -25.4156189,   11.0704479,   4.14986038
  57708,  -25.4188709,   10.9810534,   3.49984479
  57709,  -25.3668404,   12.4118662,   9.41821671
  57710,  -25.3700466,   12.3237314,   8.83643246
  57711,   -25.373251,   12.2355976,   8.25464916
  57712,  -25.3764553,   12.1474638,   7.67286587
  57713,  -25.3796597,    12.059329,    7.0910821
  57714,  -25.3828659,   11.9711952,    6.5092988
  57715,  -25.3860703,   11.8830614,   5.92751503
  57716,  -25.3892746,   11.7949276,   5.34573174
  57717,  -25.3924809,   11.7067928,   4.76394796
  57718,  -25.3956852,    11.618659,   4.18216467
  57719,  -25.3436623,   13.0493116,   9.47304153
  57720,  -25.3464146,   12.9736223,   8.94608307
  57721,  -25.3491669,    12.897934,   8.41912365
  57722,  -25.3519192,   12.8222456,   7.89216518
  57723,  -25.3546715,   12.7465563,   7.36520672
  57724,  -25.3574238,   12.6708679,   6.83824825
  57725,  -25.3601761,   12.5951796,   6.31128979
  57726,  -25.3629284,   12.5194902,   5.78433084
  57727,  -25.3656807,   12.4438019,   5.25737238
  57728,   -25.368433,   12.3681135,   4.73041391
  57729,  -25.3201809,   13.6950293,   9.51302719
  57730,  -25.3221798,   13.6400595,   9.02605343
  57731,  -25.3241787,   13.5850887,   8.53908062
  57732,  -25.3261776,   13.5301189,   8.05210686
  57733,  -25.3281784,   13.4751482,   7.56513405
  57734,  -25.3301754,   13.4201794,   7.07816124
  57735,  -25.3321743,   13.3652086,   6.59118795
  57736,  -25.3341732,   13.3102388,   6.10421515
  57737,  -25.3361721,   13.2552681,   5.61724186
  57738,   -25.338171,   13.2002983,   5.13026857
  57739,  -25.2965031,   14.3461742,   9.53731346
  57740,  -25.2975502,   14.3173494,   9.07462692
  57741,  -25.2985992,   14.2885237,   8.61194038
  57742,  -25.2996483,   14.2596989,   8.14925385
  57743,  -25.3006973,   14.2308731,   7.68656683
  57744,  -25.3017445,   14.2020493,   7.22388029
  57745,  -25.3027916,   14.1732235,   6.76119375
  57746,  -25.3038406,   14.1443987,   6.29850721
  57747,  -25.3048897,   14.1155729,    5.8358202
  57748,  -25.3059368,   14.0867472,   5.37313366
  57749,  -26.3006268,   10.5775852,   9.18288708
  57750,  -26.3057995,   10.5301704,   8.36577415
  57751,  -26.3109722,   10.4827547,   7.54866123
  57752,  -26.3161449,   10.4353399,   6.73154831
  57753,  -26.3213158,   10.3879251,   5.91443539
  57754,  -26.3264904,   10.3405104,   5.09732246
  57755,  -26.3316612,   10.2930956,   4.28020954
  57756,   -26.336834,   10.2456808,   3.46309686
  57757,  -26.3420067,   10.1982651,   2.64598393
  57758,  -26.3471794,   10.1508503,   1.82887101
  57759,  -26.2356339,    11.173358,   9.27052689
  57760,  -26.2439938,   11.0967159,   8.54105377
  57761,  -26.2523556,   11.0200739,   7.81158113
  57762,  -26.2607155,   10.9434319,   7.08210754
  57763,  -26.2690773,   10.8667889,   6.35263443
  57764,  -26.2774372,   10.7901468,   5.62316132
  57765,   -26.285799,   10.7135048,   4.89368868
  57766,  -26.2941589,   10.6368628,   4.16421556
  57767,  -26.3025208,   10.5602207,   3.43474245
  57768,  -26.3108807,   10.4835787,   2.70526934
  57769,  -26.1688423,   11.7856054,   9.34998417
  57770,  -26.1785946,   11.6962109,   8.69996929
  57771,  -26.1883469,   11.6068163,   8.04995346
  57772,  -26.1980991,   11.5174208,   7.39993811
  57773,  -26.2078514,   11.4280262,   6.74992228
  57774,  -26.2176037,   11.3386316,   6.09990692
  57775,   -26.227356,   11.2492371,   5.44989109
  57776,  -26.2371082,   11.1598425,   4.79987574
  57777,  -26.2468605,   11.0704479,   4.14986038
  57778,  -26.2566128,   10.9810534,   3.49984479
  57779,  -26.1005249,   12.4118662,   9.41821671
  57780,  -26.1101398,   12.3237314,   8.83643246
  57781,  -26.1197529,   12.2355976,   8.25464916
  57782,  -26.1293678,   12.1474638,   7.67286587
  57783,  -26.1389828,    12.059329,    7.0910821
  57784,  -26.1485977,   11.9711952,    6.5092988
  57785,  -26.1582127,   11.8830614,   5.92751503
  57786,  -26.1678257,   11.7949276,   5.34573174
  57787,  -26.1774426,   11.7067928,   4.76394796
  57788,  -26.1870575,    11.618659,   4.18216467
  57789,  -26.0309849,   13.0493116,   9.47304153
  57790,  -26.0392418,   12.9736223,   8.94608307
  57791,  -26.0474987,    12.897934,   8.41912365
  57792,  -26.0557556,   12.8222456,   7.89216518
  57793,  -26.0640125,   12.7465563,   7.36520672
  57794,  -26.0722694,   12.6708679,   6.83824825
  57795,  -26.0805264,   12.5951796,   6.31128979
  57796,  -26.0887833,   12.5194902,   5.78433084
  57797,  -26.0970402,   12.4438019,   5.25737238
  57798,  -26.1052971,   12.3681135,   4.73041391
  57799,  -25.9605427,   13.6950293,   9.51302719
  57800,  -25.9665394,   13.6400595,   9.02605343
  57801,  -25.9725361,   13.5850887,   8.53908062
  57802,  -25.9785328,   13.5301189,   8.05210686
  57803,  -25.9845314,   13.4751482,   7.56513405
  57804,  -25.9905262,   13.4201794,   7.07816124
  57805,  -25.9965229,   13.3652086,   6.59118795
  57806,  -26.0025196,   13.3102388,   6.10421515
  57807,  -26.0085163,   13.2552681,   5.61724186
  57808,   -26.014513,   13.2002983,   5.13026857
  57809,  -25.8895092,   14.3461742,   9.53731346
  57810,  -25.8926525,   14.3173494,   9.07462692
  57811,  -25.8957977,   14.2885237,   8.61194038
  57812,   -25.898941,   14.2596989,   8.14925385
  57813,  -25.9020882,   14.2308731,   7.68656683
  57814,  -25.9052315,   14.2020493,   7.22388029
  57815,  -25.9083767,   14.1732235,   6.76119375
  57816,    -25.91152,   14.1443987,   6.29850721
  57817,  -25.9146652,   14.1155729,   5.83582067
  57818,  -25.9178085,   14.0867472,   5.37313414
  57819,  -27.1677113,   10.5775852,   9.18288708
  57820,  -27.1763325,   10.5301704,   8.36577415
  57821,  -27.1849537,   10.4827547,   7.54866123
  57822,  -27.1935749,   10.4353399,   6.73154831
  57823,  -27.2021942,   10.3879251,   5.91443539
  57824,  -27.2108173,   10.3405104,   5.09732246
  57825,  -27.2194366,   10.2930956,   4.28020954
  57826,  -27.2280579,   10.2456808,   3.46309686
  57827,  -27.2366791,   10.1982651,   2.64598417
  57828,  -27.2453003,   10.1508503,   1.82887125
  57829,  -27.0593891,    11.173358,   9.27052689
  57830,  -27.0733242,   11.0967159,   8.54105377
  57831,  -27.0872593,   11.0200739,   7.81158113
  57832,  -27.1011944,   10.9434319,   7.08210802
  57833,  -27.1151295,   10.8667889,   6.35263491
  57834,  -27.1290627,   10.7901468,   5.62316132
  57835,  -27.1429977,   10.7135048,   4.89368868
  57836,  -27.1569328,   10.6368628,   4.16421556
  57837,  -27.1708679,   10.5602207,   3.43474245
  57838,   -27.184803,   10.4835787,   2.70526958
  57839,  -26.9480705,   11.7856054,   9.34998417
  57840,   -26.964325,   11.6962109,   8.69996929
  57841,  -26.9805775,   11.6068163,   8.04995346
  57842,  -26.9968319,   11.5174208,   7.39993811
  57843,  -27.0130863,   11.4280262,   6.74992228
  57844,  -27.0293388,   11.3386316,   6.09990692
  57845,  -27.0455933,   11.2492371,   5.44989109
  57846,  -27.0618458,   11.1598425,   4.79987574
  57847,  -27.0781002,   11.0704479,   4.14986038
  57848,  -27.0943527,   10.9810534,   3.49984479
  57849,  -26.8342056,   12.4118662,   9.41821671
  57850,  -26.8502312,   12.3237314,   8.83643246
  57851,  -26.8662548,   12.2355976,   8.25464916
  57852,  -26.8822784,   12.1474638,   7.67286587
  57853,   -26.898304,    12.059329,    7.0910821
  57854,  -26.9143276,   11.9711952,    6.5092988
  57855,  -26.9303513,   11.8830614,   5.92751503
  57856,  -26.9463768,   11.7949276,   5.34573174
  57857,  -26.9624023,   11.7067928,   4.76394796
  57858,   -26.978426,    11.618659,   4.18216467
  57859,  -26.7183075,   13.0493116,   9.47304153
  57860,   -26.732069,   12.9736223,   8.94608307
  57861,  -26.7458305,    12.897934,   8.41912365
  57862,  -26.7595921,   12.8222456,   7.89216518
  57863,  -26.7733536,   12.7465563,   7.36520672
  57864,  -26.7871151,   12.6708679,   6.83824825
  57865,  -26.8008766,   12.5951796,   6.31128979
  57866,  -26.8146381,   12.5194912,   5.78433084
  57867,  -26.8283997,   12.4438019,   5.25737238
  57868,  -26.8421612,   12.3681135,   4.73041391
  57869,  -26.6009045,   13.6950293,   9.51302719
  57870,   -26.610899,   13.6400595,   9.02605343
  57871,  -26.6208935,   13.5850887,   8.53908062
  57872,   -26.630888,   13.5301189,   8.05210686
  57873,  -26.6408844,   13.4751482,   7.56513405
  57874,   -26.650877,   13.4201794,   7.07816124
  57875,  -26.6608715,   13.3652086,   6.59118795
  57876,   -26.670866,   13.3102388,   6.10421515
  57877,  -26.6808605,   13.2552681,   5.61724186
  57878,   -26.690855,   13.2002983,   5.13026857
  57879,  -26.4825134,   14.3461742,   9.53731346
  57880,  -26.4877548,   14.3173494,   9.07462692
  57881,  -26.4929943,   14.2885237,   8.61194038
  57882,  -26.4982357,   14.2596989,   8.14925385
  57883,   -26.503479,   14.2308731,   7.68656683
  57884,  -26.5087185,   14.2020483,   7.22388029
  57885,  -26.5139599,   14.1732225,   6.76119328
  57886,  -26.5192013,   14.1443977,   6.29850674
  57887,  -26.5244408,    14.115572,    5.8358202
  57888,  -26.5296822,   14.0867462,   5.37313366
  57889,  -28.0347977,   10.5775852,   9.18288708
  57890,  -28.0468655,   10.5301704,   8.36577415
  57891,  -28.0589352,   10.4827547,   7.54866171
  57892,  -28.0710049,   10.4353399,   6.73154879
  57893,  -28.0830746,   10.3879251,   5.91443586
  57894,  -28.0951424,   10.3405104,   5.09732294
  57895,  -28.1072121,   10.2930956,   4.28021002
  57896,  -28.1192818,   10.2456808,    3.4630971
  57897,  -28.1313515,   10.1982651,   2.64598441
  57898,  -28.1434193,   10.1508503,   1.82887137
  57899,  -27.8831444,    11.173358,   9.27052689
  57900,  -27.9026546,   11.0967159,   8.54105377
  57901,   -27.922163,   11.0200739,   7.81158113
  57902,  -27.9416714,   10.9434319,   7.08210802
  57903,  -27.9611797,   10.8667889,   6.35263491
  57904,    -27.98069,   10.7901468,   5.62316179
  57905,  -28.0001984,   10.7135048,   4.89368868
  57906,  -28.0197067,   10.6368628,   4.16421556
  57907,  -28.0392151,   10.5602207,   3.43474245
  57908,  -28.0587254,   10.4835787,   2.70526958
  57909,  -27.7273006,   11.7856054,   9.34998417
  57910,  -27.7500553,   11.6962109,   8.69996929
  57911,    -27.77281,   11.6068163,   8.04995346
  57912,  -27.7955666,   11.5174208,   7.39993811
  57913,  -27.8183212,   11.4280262,   6.74992228
  57914,  -27.8410759,   11.3386316,   6.09990692
  57915,  -27.8638306,   11.2492371,   5.44989157
  57916,  -27.8865852,   11.1598425,   4.79987574
  57917,  -27.9093418,   11.0704479,   4.14986038
  57918,  -27.9320946,   10.9810534,   3.49984479
  57919,  -27.5678883,   12.4118662,   9.41821671
  57920,  -27.5903225,   12.3237314,   8.83643246
  57921,  -27.6127567,   12.2355976,   8.25464916
  57922,   -27.635191,   12.1474638,   7.67286587
  57923,  -27.6576252,    12.059329,    7.0910821
  57924,  -27.6800594,   11.9711952,    6.5092988
  57925,  -27.7024937,   11.8830614,   5.92751503
  57926,  -27.7249279,   11.7949276,   5.34573174
  57927,  -27.7473621,   11.7067928,   4.76394796
  57928,  -27.7697964,    11.618659,   4.18216467
  57929,  -27.4056301,   13.0493116,   9.47304153
  57930,  -27.4248962,   12.9736223,   8.94608307
  57931,  -27.4441624,    12.897934,   8.41912365
  57932,  -27.4634285,   12.8222446,   7.89216518
  57933,  -27.4826946,   12.7465563,   7.36520672
  57934,  -27.5019608,   12.6708679,   6.83824825
  57935,  -27.5212269,   12.5951796,   6.31128979
  57936,   -27.540493,   12.5194912,   5.78433084
  57937,  -27.5597591,   12.4438019,   5.25737238
  57938,  -27.5790253,   12.3681135,   4.73041391
  57939,  -27.2412643,   13.6950293,   9.51302719
  57940,  -27.2552567,   13.6400595,   9.02605343
  57941,   -27.269249,   13.5850887,   8.53908062
  57942,  -27.2832413,   13.5301189,   8.05210686
  57943,  -27.2972355,   13.4751482,   7.56513405
  57944,  -27.3112278,   13.4201794,   7.07816124
  57945,  -27.3252201,   13.3652086,   6.59118795
  57946,  -27.3392124,   13.3102388,   6.10421515
  57947,  -27.3532047,   13.2552681,   5.61724186
  57948,   -27.367197,   13.2002983,   5.13026857
  57949,  -27.0755196,   14.3461742,   9.53731346
  57950,  -27.0828571,   14.3173494,   9.07462692
  57951,  -27.0901947,   14.2885237,   8.61194038
  57952,  -27.0975304,   14.2596989,   8.14925385
  57953,  -27.1048698,   14.2308731,   7.68656683
  57954,  -27.1122074,   14.2020483,   7.22388029
  57955,   -27.119545,   14.1732225,   6.76119328
  57956,  -27.1268806,   14.1443977,   6.29850674
  57957,  -27.1342182,    14.115572,    5.8358202
  57958,  -27.1415558,   14.0867462,   5.37313366
  57959,  -28.9018822,   10.5775852,   9.18288708
  57960,  -28.9173985,   10.5301704,   8.36577415
  57961,  -28.9329166,   10.4827547,   7.54866171
  57962,  -28.9484348,   10.4353399,   6.73154879
  57963,  -28.9639511,   10.3879251,   5.91443586
  57964,  -28.9794712,   10.3405104,   5.09732294
  57965,  -28.9949875,   10.2930956,   4.28021002
  57966,  -29.0105057,   10.2456808,    3.4630971
  57967,  -29.0260239,   10.1982651,   2.64598441
  57968,  -29.0415401,   10.1508503,   1.82887149
  57969,  -28.7069016,    11.173358,   9.27052689
  57970,  -28.7319832,   11.0967159,   8.54105377
  57971,  -28.7570667,   11.0200739,   7.81158113
  57972,  -28.7821503,   10.9434319,   7.08210802
  57973,  -28.8072319,   10.8667889,   6.35263491
  57974,  -28.8323154,   10.7901468,   5.62316179
  57975,  -28.8573971,   10.7135048,   4.89368916
  57976,  -28.8824806,   10.6368628,   4.16421604
  57977,  -28.9075642,   10.5602207,   3.43474269
  57978,  -28.9326458,   10.4835787,   2.70526981
  57979,  -28.5065269,   11.7856054,   9.34998417
  57980,  -28.5357857,   11.6962109,   8.69996929
  57981,  -28.5650406,   11.6068163,   8.04995346
  57982,  -28.5942974,   11.5174208,   7.39993811
  57983,  -28.6235542,   11.4280262,   6.74992228
  57984,  -28.6528111,   11.3386316,   6.09990692
  57985,  -28.6820679,   11.2492371,   5.44989157
  57986,  -28.7113228,   11.1598425,   4.79987574
  57987,  -28.7405796,   11.0704479,   4.14986038
  57988,  -28.7698364,   10.9810534,   3.49984479
  57989,  -28.3015709,   12.4118662,   9.41821671
  57990,  -28.3304157,   12.3237314,   8.83643246
  57991,  -28.3592587,   12.2355976,   8.25464916
  57992,  -28.3881035,   12.1474638,   7.67286587
  57993,  -28.4169464,    12.059329,    7.0910821
  57994,  -28.4457893,   11.9711952,    6.5092988
