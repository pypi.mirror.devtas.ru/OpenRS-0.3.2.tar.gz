  11995,  -15.2246313,   70.3996201,          10.
  11996,  -15.8706493,   69.9011612,          10.
  11997,  -16.5003586,   69.3822632,          10.
  11998,  -17.1131134,   68.8434372,          10.
  11999,  -17.7082825,   68.2852554,          10.
  12000,  -18.2852554,   67.7082825,          10.
  12001,  -18.8434391,   67.1131134,          10.
  12002,  -19.3822613,   66.5003586,          10.
  12003,   -19.901165,   65.8706512,          10.
  12004,  -20.3996201,   65.2246323,          10.
  12005,  -20.8771114,    64.562973,          10.
  12006,  -21.3331509,   63.8863411,          10.
  12007,   -21.767271,    63.195446,          10.
  12008,  -22.1790218,   62.4909935,          10.
  12009,  -22.5679817,   61.7737007,          10.
  12010,  -22.9337521,   61.0443115,          10.
  12011,  -23.2759571,   60.3035774,          10.
  12012,   -23.594244,   59.5522499,          10.
  12013,  -23.8882866,    58.791111,          10.
  12014,  -24.1577835,   58.0209351,          10.
  12015,  -24.4024544,   57.2425194,          10.
  12016,  -24.6220512,   56.4566612,          10.
  12017,  -24.8163471,   55.6641693,          10.
  12018,  -24.9851418,   54.8658562,          10.
  12019,  -25.1282635,    54.062542,          10.
  12020,  -25.2455635,   53.2550545,          10.
  12021,  -25.3369236,   52.4442215,          10.
  12022,  -25.4022465,   51.6308784,          10.
  12023,  -25.4414673,   50.8158569,          10.
  12024,   24.5328426,   50.7867203,          10.
  12025,   24.4950237,   51.5726318,          10.
  12026,   24.4320335,   52.3569298,          10.
  12027,   24.3439369,   53.1388016,          10.
  12028,   24.2308254,   53.9174538,          10.
  12029,   24.0928154,   54.6920738,          10.
  12030,    23.930048,   55.4618759,          10.
  12031,   23.7426929,   56.2260666,          10.
  12032,   23.5309391,     56.98386,          10.
  12033,   23.2950039,   57.7344742,          10.
  12034,   23.0351334,   58.4771423,          10.
  12035,   22.7515926,   59.2110977,          10.
  12036,   22.4446735,   59.9355927,          10.
  12037,   22.1146908,   60.6498718,          10.
  12038,   21.7619839,   61.3532143,          10.
  12039,   21.3869133,   62.0448837,          10.
  12040,   20.9898682,   62.7241821,          10.
  12041,   20.5712528,   63.3904037,          10.
  12042,   20.1315002,   64.0428619,          10.
  12043,   19.6710625,   64.6808929,          10.
  12044,   19.1904087,   65.3038406,          10.
  12045,   18.6900368,   65.9110641,          10.
  12046,   18.1704597,   66.5019302,          10.
  12047,   17.6322117,   67.0758438,          10.
  12048,   17.0758438,   67.6322098,          10.
  12049,   16.5019302,   68.1704636,          10.
  12050,   15.9110603,   68.6900406,          10.
  12051,   15.3038406,   69.1904068,          10.
  12052,   14.6808949,   69.6710587,          10.
  12053,   14.0428638,   70.1315002,          10.
  12054,   13.3904018,   70.5712509,          10.
  12055,   12.7241812,   70.9898682,          10.
  12056,   12.0448856,   71.3869171,          10.
  12057,   11.3532124,   71.7619858,          10.
  12058,   10.6498737,   72.1146927,          10.
  12059,   9.93559074,   72.4446716,          10.
  12060,   9.21109962,   72.7515945,          10.
  12061,   8.47714233,   73.0351334,          10.
  12062,   7.73447466,   73.2950058,          10.
  12063,   6.98385906,   73.5309372,          10.
  12064,   6.22606707,    73.742691,          10.
  12065,   5.46187735,   73.9300461,          10.
  12066,   4.69207525,   74.0928192,          10.
  12067,   3.91745186,   74.2308273,          10.
  12068,   3.13880301,   74.3439331,          10.
  12069,   2.35692883,   74.4320297,          10.
  12070,   1.57263267,   74.4950256,          10.
  12071,  0.786720514,   74.5328445,          10.
  12072,           0.,   74.5454559,          10.
  12073, -0.786720514,   74.5328445,          10.
  12074,  -1.57263267,   74.4950256,          10.
  12075,  -2.35692883,   74.4320297,          10.
  12076,  -3.13880301,   74.3439331,          10.
  12077,  -3.91745186,   74.2308273,          10.
  12078,  -4.69207525,   74.0928192,          10.
  12079,  -5.46187735,   73.9300461,          10.
  12080,  -6.22606707,    73.742691,          10.
  12081,  -6.98385906,   73.5309372,          10.
  12082,  -7.73447466,   73.2950058,          10.
  12083,  -8.47714233,   73.0351334,          10.
  12084,  -9.21109962,   72.7515945,          10.
  12085,  -9.93559074,   72.4446716,          10.
  12086,  -10.6498737,   72.1146927,          10.
  12087,  -11.3532124,   71.7619858,          10.
  12088,  -12.0448856,   71.3869171,          10.
  12089,  -12.7241812,   70.9898682,          10.
  12090,  -13.3904018,   70.5712509,          10.
  12091,  -14.0428638,   70.1315002,          10.
  12092,  -14.6808949,   69.6710587,          10.
  12093,  -15.3038406,   69.1904068,          10.
  12094,  -15.9110603,   68.6900406,          10.
  12095,  -16.5019302,   68.1704636,          10.
  12096,  -17.0758438,   67.6322098,          10.
  12097,  -17.6322117,   67.0758438,          10.
  12098,  -18.1704597,   66.5019302,          10.
  12099,  -18.6900368,   65.9110641,          10.
  12100,  -19.1904087,   65.3038406,          10.
  12101,  -19.6710625,   64.6808929,          10.
  12102,  -20.1315002,   64.0428619,          10.
  12103,  -20.5712528,   63.3904037,          10.
  12104,  -20.9898682,   62.7241821,          10.
  12105,  -21.3869133,   62.0448837,          10.
  12106,  -21.7619839,   61.3532143,          10.
  12107,  -22.1146908,   60.6498718,          10.
  12108,  -22.4446735,   59.9355927,          10.
  12109,  -22.7515926,   59.2110977,          10.
  12110,  -23.0351334,   58.4771423,          10.
  12111,  -23.2950039,   57.7344742,          10.
  12112,  -23.5309391,     56.98386,          10.
  12113,  -23.7426929,   56.2260666,          10.
  12114,   -23.930048,   55.4618759,          10.
  12115,  -24.0928154,   54.6920738,          10.
  12116,  -24.2308254,   53.9174538,          10.
  12117,  -24.3439369,   53.1388016,          10.
  12118,  -24.4320335,   52.3569298,          10.
  12119,  -24.4950237,   51.5726318,          10.
  12120,  -24.5328426,   50.7867203,          10.
  12121,   23.6242199,   50.7575836,          10.
  12122,    23.587801,   51.5143852,          10.
  12123,   23.5271435,   52.2696342,          10.
  12124,   23.4423103,   53.0225525,          10.
  12125,   23.3333874,   53.7723618,          10.
  12126,    23.200489,   54.5182953,          10.
  12127,   23.0437508,   55.2595863,          10.
  12128,   22.8633327,    55.995472,          10.
  12129,   22.6594219,   56.7251968,          10.
  12130,   22.4322262,   57.4480133,          10.
  12131,   22.1819801,   58.1631737,          10.
  12132,   21.9089413,   58.8699455,          10.
  12133,     21.61339,   59.5676079,          10.
  12134,   21.2956276,   60.2554321,          10.
  12135,   20.9559841,    60.932724,          10.
  12136,   20.5948067,   61.5987778,          10.
  12137,   20.2124653,   62.2529144,          10.
  12138,   19.8093548,   62.8944626,          10.
  12139,   19.3858891,   63.5227585,          10.
  12140,    18.942503,   64.1371613,          10.
  12141,   18.4796524,     64.73703,          10.
  12142,   17.9978142,   65.3217621,          10.
  12143,   17.4974804,   65.8907471,          10.
  12144,    16.979166,   66.4434052,          10.
  12145,   16.4434052,   66.9791641,          10.
  12146,    15.890748,   67.4974823,          10.
  12147,   15.3217621,   67.9978104,          10.
  12148,   14.7370319,   68.4796524,          10.
  12149,   14.1371584,   68.9425049,          10.
  12150,   13.5227575,   69.3858871,          10.
  12151,   12.8944616,   69.8093567,          10.
  12152,   12.2529154,   70.2124634,          10.
  12153,   11.5987787,   70.5948029,          10.
  12154,    10.932723,    70.955986,          10.
  12155,    10.255434,   71.2956314,          10.
  12156,   9.56760597,   71.6133881,          10.
  12157,   8.86994743,   71.9089432,          10.
  12158,   8.16317368,   72.1819839,          10.
  12159,   7.44801235,   72.4322281,          10.
  12160,   6.72519732,   72.6594238,          10.
  12161,   5.99547195,   72.8633347,          10.
  12162,   5.25958586,   73.0437469,          10.
  12163,   4.51829481,   73.2004929,          10.
  12164,   3.77236104,   73.3333893,          10.
  12165,   3.02255106,   73.4423065,          10.
  12166,    2.2696352,   73.5271454,          10.
  12167,   1.51438701,   73.5877991,          10.
  12168,  0.757582724,   73.6242218,          10.
  12169,           0.,   73.6363602,          10.
  12170, -0.757582724,   73.6242218,          10.
  12171,  -1.51438701,   73.5877991,          10.
  12172,   -2.2696352,   73.5271454,          10.
  12173,  -3.02255106,   73.4423065,          10.
  12174,  -3.77236104,   73.3333893,          10.
  12175,  -4.51829481,   73.2004929,          10.
  12176,  -5.25958586,   73.0437469,          10.
  12177,  -5.99547195,   72.8633347,          10.
  12178,  -6.72519732,   72.6594238,          10.
  12179,  -7.44801235,   72.4322281,          10.
  12180,  -8.16317368,   72.1819839,          10.
  12181,  -8.86994743,   71.9089432,          10.
  12182,  -9.56760597,   71.6133881,          10.
  12183,   -10.255434,   71.2956314,          10.
  12184,   -10.932723,    70.955986,          10.
  12185,  -11.5987787,   70.5948029,          10.
  12186,  -12.2529154,   70.2124634,          10.
  12187,  -12.8944616,   69.8093567,          10.
  12188,  -13.5227575,   69.3858871,          10.
  12189,  -14.1371584,   68.9425049,          10.
  12190,  -14.7370319,   68.4796524,          10.
  12191,  -15.3217621,   67.9978104,          10.
  12192,   -15.890748,   67.4974823,          10.
  12193,  -16.4434052,   66.9791641,          10.
  12194,   -16.979166,   66.4434052,          10.
  12195,  -17.4974804,   65.8907471,          10.
  12196,  -17.9978142,   65.3217621,          10.
  12197,  -18.4796524,     64.73703,          10.
  12198,   -18.942503,   64.1371613,          10.
  12199,  -19.3858891,   63.5227585,          10.
  12200,  -19.8093548,   62.8944626,          10.
  12201,  -20.2124653,   62.2529144,          10.
  12202,  -20.5948067,   61.5987778,          10.
  12203,  -20.9559841,    60.932724,          10.
  12204,  -21.2956276,   60.2554321,          10.
  12205,    -21.61339,   59.5676079,          10.
  12206,  -21.9089413,   58.8699455,          10.
  12207,  -22.1819801,   58.1631737,          10.
  12208,  -22.4322262,   57.4480133,          10.
  12209,  -22.6594219,   56.7251968,          10.
  12210,  -22.8633327,    55.995472,          10.
  12211,  -23.0437508,   55.2595863,          10.
  12212,   -23.200489,   54.5182953,          10.
  12213,  -23.3333874,   53.7723618,          10.
  12214,  -23.4423103,   53.0225525,          10.
  12215,  -23.5271435,   52.2696342,          10.
  12216,   -23.587801,   51.5143852,          10.
  12217,  -23.6242199,   50.7575836,          10.
  12218,   22.7155952,   50.7284431,          10.
  12219,   22.6805763,   51.4561424,          10.
  12220,   22.6222534,   52.1823425,          10.
  12221,   22.5406818,   52.9062996,          10.
  12222,   22.4359493,   53.6272697,          10.
  12223,   22.3081627,   54.3445129,          10.
  12224,   22.1574516,   55.0572929,          10.
  12225,   21.9839745,   55.7648773,          10.
  12226,   21.7879066,   56.4665375,          10.
  12227,   21.5694485,   57.1615486,          10.
  12228,   21.3288269,    57.849205,          10.
  12229,   21.0662899,   58.5287971,          10.
  12230,   20.7821045,   59.1996231,          10.
  12231,   20.4765644,   59.8609924,          10.
  12232,   20.1499844,   60.5122337,          10.
  12233,   19.8026981,   61.1526718,          10.
  12234,   19.4350624,   61.7816505,          10.
  12235,   19.0474567,   62.3985214,          10.
  12236,   18.6402779,   63.0026512,          10.
  12237,   18.2139454,   63.5934219,          10.
  12238,    17.768898,   64.1702194,          10.
  12239,   17.3055897,     64.73246,          10.
  12240,   16.8244991,   65.2795639,          10.
  12241,   16.3261223,   65.8109665,          10.
  12242,   15.8109674,   66.3261185,          10.
  12243,   15.2795658,    66.824501,          10.
  12244,   14.7324638,   67.3055878,          10.
  12245,   14.1702232,    67.768898,          10.
  12246,    13.593421,   68.2139435,          10.
  12247,   13.0026512,   68.6402817,          10.
  12248,   12.3985205,   69.0474548,          10.
  12249,   11.7816496,   69.4350662,          10.
  12250,   11.1526718,   69.8026962,          10.
  12251,   10.5122337,   70.1499863,          10.
  12252,   9.86099434,   70.4765625,          10.
  12253,    9.1996212,   70.7821045,          10.
  12254,   8.52879524,   71.0662918,          10.
  12255,   7.84920597,   71.3288269,          10.
  12256,   7.16155052,   71.5694504,          10.
  12257,   6.46653605,   71.7879028,          10.
  12258,   5.76487684,   71.9839706,          10.
  12259,   5.05729389,   72.1574554,          10.
  12260,   4.34451437,   72.3081589,          10.
  12261,   3.62727046,   72.4359512,          10.
  12262,   2.90629911,   72.5406799,          10.
  12263,   2.18234158,   72.6222534,          10.
  12264,   1.45614135,   72.6805801,          10.
  12265,  0.728444934,   72.7155991,          10.
  12266,           0.,    72.727272,          10.
  12267, -0.728444934,   72.7155991,          10.
  12268,  -1.45614135,   72.6805801,          10.
  12269,  -2.18234158,   72.6222534,          10.
  12270,  -2.90629911,   72.5406799,          10.
  12271,  -3.62727046,   72.4359512,          10.
  12272,  -4.34451437,   72.3081589,          10.
  12273,  -5.05729389,   72.1574554,          10.
  12274,  -5.76487684,   71.9839706,          10.
  12275,  -6.46653605,   71.7879028,          10.
  12276,  -7.16155052,   71.5694504,          10.
  12277,  -7.84920597,   71.3288269,          10.
  12278,  -8.52879524,   71.0662918,          10.
  12279,   -9.1996212,   70.7821045,          10.
  12280,  -9.86099434,   70.4765625,          10.
  12281,  -10.5122337,   70.1499863,          10.
  12282,  -11.1526718,   69.8026962,          10.
  12283,  -11.7816496,   69.4350662,          10.
  12284,  -12.3985205,   69.0474548,          10.
  12285,  -13.0026512,   68.6402817,          10.
  12286,   -13.593421,   68.2139435,          10.
  12287,  -14.1702232,    67.768898,          10.
  12288,  -14.7324638,   67.3055878,          10.
  12289,  -15.2795658,    66.824501,          10.
  12290,  -15.8109674,   66.3261185,          10.
  12291,  -16.3261223,   65.8109665,          10.
  12292,  -16.8244991,   65.2795639,          10.
  12293,  -17.3055897,     64.73246,          10.
  12294,   -17.768898,   64.1702194,          10.
  12295,  -18.2139454,   63.5934219,          10.
  12296,  -18.6402779,   63.0026512,          10.
  12297,  -19.0474567,   62.3985214,          10.
  12298,  -19.4350624,   61.7816505,          10.
  12299,  -19.8026981,   61.1526718,          10.
  12300,  -20.1499844,   60.5122337,          10.
  12301,  -20.4765644,   59.8609924,          10.
  12302,  -20.7821045,   59.1996231,          10.
  12303,  -21.0662899,   58.5287971,          10.
  12304,  -21.3288269,    57.849205,          10.
  12305,  -21.5694485,   57.1615486,          10.
  12306,  -21.7879066,   56.4665375,          10.
  12307,  -21.9839745,   55.7648773,          10.
  12308,  -22.1574516,   55.0572929,          10.
  12309,  -22.3081627,   54.3445129,          10.
  12310,  -22.4359493,   53.6272697,          10.
  12311,  -22.5406818,   52.9062996,          10.
  12312,  -22.6222534,   52.1823425,          10.
  12313,  -22.6805763,   51.4561424,          10.
  12314,  -22.7155952,   50.7284431,          10.
  12315,   21.8069725,   50.6993065,          10.
  12316,   21.7733536,   51.3978958,          10.
  12317,   21.7173634,    52.095047,          10.
  12318,   21.6390553,   52.7900467,          10.
  12319,   21.5385113,   53.4821777,          10.
  12320,   21.4158363,   54.1707344,          10.
  12321,   21.2711544,   54.8550034,          10.
  12322,   21.1046143,   55.5342827,          10.
  12323,   20.9163895,   56.2078743,          10.
  12324,   20.7066708,   56.8750877,          10.
  12325,   20.4756756,   57.5352364,          10.
  12326,   20.2236385,    58.187645,          10.
  12327,   19.9508209,   58.8316383,          10.
  12328,   19.6575031,   59.4665527,          10.
  12329,   19.3439846,   60.0917435,          10.
  12330,   19.0105896,   60.7065659,          10.
  12331,   18.6576595,   61.3103828,          10.
  12332,   18.2855587,   61.9025803,          10.
  12333,   17.8946667,   62.4825439,          10.
  12334,   17.4853878,   63.0496826,          10.
  12335,   17.0581417,   63.6034126,          10.
  12336,   16.6133671,   64.1431656,          10.
  12337,   16.1515198,   64.6683807,          10.
  12338,   15.6730766,   65.1785278,          10.
  12339,   15.1785288,   65.6730804,          10.
  12340,   14.6683826,   66.1515198,          10.
  12341,   14.1431646,   66.6133652,          10.
  12342,   13.6034136,   67.0581436,          10.
  12343,   13.0496845,   67.4853897,          10.
  12344,   12.4825449,   67.8946686,          10.
  12345,   11.9025793,   68.2855606,          10.
  12346,   11.3103828,   68.6576614,          10.
  12347,   10.7065649,   69.0105896,          10.
  12348,   10.0917444,   69.3439865,          10.
  12349,   9.46655464,   69.6575012,          10.
  12350,   8.83163643,   69.9508209,          10.
  12351,     8.187644,   70.2236404,          10.
  12352,   7.53523779,   70.4756775,          10.
  12353,   6.87508821,   70.7066727,          10.
  12354,   6.20787477,   70.9163895,          10.
  12355,   5.53428173,   71.1046143,          10.
  12356,    4.8550024,   71.2711563,          10.
  12357,   4.17073393,   71.4158325,          10.
  12358,   3.48217964,   71.5385132,          10.
  12359,   2.79004717,   71.6390533,          10.
  12360,   2.09504795,   71.7173615,          10.
  12361,   1.39789569,   71.7733536,          10.
  12362,  0.699307144,   71.8069687,          10.
  12363,           0.,   71.8181839,          10.
  12364, -0.699307144,   71.8069687,          10.
  12365,  -1.39789569,   71.7733536,          10.
  12366,  -2.09504795,   71.7173615,          10.
  12367,  -2.79004717,   71.6390533,          10.
  12368,  -3.48217964,   71.5385132,          10.
  12369,  -4.17073393,   71.4158325,          10.
  12370,   -4.8550024,   71.2711563,          10.
  12371,  -5.53428173,   71.1046143,          10.
  12372,  -6.20787477,   70.9163895,          10.
  12373,  -6.87508821,   70.7066727,          10.
  12374,  -7.53523779,   70.4756775,          10.
  12375,    -8.187644,   70.2236404,          10.
  12376,  -8.83163643,   69.9508209,          10.
  12377,  -9.46655464,   69.6575012,          10.
  12378,  -10.0917444,   69.3439865,          10.
  12379,  -10.7065649,   69.0105896,          10.
  12380,  -11.3103828,   68.6576614,          10.
  12381,  -11.9025793,   68.2855606,          10.
  12382,  -12.4825449,   67.8946686,          10.
  12383,  -13.0496845,   67.4853897,          10.
  12384,  -13.6034136,   67.0581436,          10.
  12385,  -14.1431646,   66.6133652,          10.
  12386,  -14.6683826,   66.1515198,          10.
  12387,  -15.1785288,   65.6730804,          10.
  12388,  -15.6730766,   65.1785278,          10.
  12389,  -16.1515198,   64.6683807,          10.
  12390,  -16.6133671,   64.1431656,          10.
  12391,  -17.0581417,   63.6034126,          10.
  12392,  -17.4853878,   63.0496826,          10.
  12393,  -17.8946667,   62.4825439,          10.
  12394,  -18.2855587,   61.9025803,          10.
  12395,  -18.6576595,   61.3103828,          10.
  12396,  -19.0105896,   60.7065659,          10.
  12397,  -19.3439846,   60.0917435,          10.
  12398,  -19.6575031,   59.4665527,          10.
  12399,  -19.9508209,   58.8316383,          10.
  12400,  -20.2236385,    58.187645,          10.
  12401,  -20.4756756,   57.5352364,          10.
  12402,  -20.7066708,   56.8750877,          10.
  12403,  -20.9163895,   56.2078743,          10.
  12404,  -21.1046143,   55.5342827,          10.
  12405,  -21.2711544,   54.8550034,          10.
  12406,  -21.4158363,   54.1707344,          10.
  12407,  -21.5385113,   53.4821777,          10.
  12408,  -21.6390553,   52.7900467,          10.
  12409,  -21.7173634,    52.095047,          10.
  12410,  -21.7733536,   51.3978958,          10.
  12411,  -21.8069725,   50.6993065,          10.
  12412,   20.8983479,   50.6701698,          10.
  12413,   20.8661308,   51.3396492,          10.
  12414,   20.8124733,   52.0077553,          10.
  12415,   20.7374268,   52.6737938,          10.
  12416,   20.6410732,   53.3370895,          10.
  12417,     20.52351,   53.9969521,          10.
  12418,   20.3848572,     54.65271,          10.
  12419,    20.225256,    55.303688,          10.
  12420,   20.0448742,   55.9492149,          10.
  12421,   19.8438931,   56.5886269,          10.
  12422,   19.6225224,   57.2212677,          10.
  12423,   19.3809872,   57.8464928,          10.
  12424,   19.1195374,   58.4636536,          10.
  12425,   18.8384399,    59.072113,          10.
  12426,   18.5379848,    59.671257,          10.
  12427,   18.2184811,   60.2604561,          10.
  12428,   17.8802586,    60.839119,          10.
  12429,   17.5236607,   61.4066391,          10.
  12430,   17.1490555,   61.9624405,          10.
  12431,   16.7568302,   62.5059471,          10.
  12432,   16.3473854,   63.0366058,          10.
  12433,   15.9211426,   63.5538673,          10.
  12434,   15.4785395,   64.0571976,          10.
  12435,   15.0200319,   64.5460892,          10.
  12436,   14.5460901,   65.0200348,          10.
  12437,   14.0572004,   65.4785385,          10.
  12438,   13.5538664,   65.9211426,          10.
  12439,   13.0366049,   66.3473892,          10.
  12440,   12.5059471,   66.7568283,          10.
  12441,   11.9624395,   67.1490555,          10.
  12442,   11.4066391,   67.5236588,          10.
  12443,   10.8391171,   67.8802567,          10.
  12444,    10.260458,    68.218483,          10.
  12445,   9.67125511,   68.5379868,          10.
  12446,   9.07211494,   68.8384399,          10.
  12447,   8.46365166,   69.1195374,          10.
  12448,   7.84649181,   69.3809891,          10.
  12449,   7.22126913,   69.6225204,          10.
  12450,   6.58862638,    69.843895,          10.
  12451,   5.94921303,   70.0448761,          10.
  12452,   5.30368662,   70.2252579,          10.
  12453,   4.65271044,   70.3848572,          10.
  12454,   3.99695325,   70.5235062,          10.
  12455,   3.33708882,   70.6410751,          10.
  12456,   2.67379522,   70.7374268,          10.
  12457,   2.00775409,   70.8124695,          10.
  12458,   1.33965003,   70.8661346,          10.
  12459,  0.670169353,   70.8983459,          10.
  12460,           0.,   70.9090881,          10.
  12461, -0.670169353,   70.8983459,          10.
  12462,  -1.33965003,   70.8661346,          10.
  12463,  -2.00775409,   70.8124695,          10.
  12464,  -2.67379522,   70.7374268,          10.
  12465,  -3.33708882,   70.6410751,          10.
  12466,  -3.99695325,   70.5235062,          10.
  12467,  -4.65271044,   70.3848572,          10.
  12468,  -5.30368662,   70.2252579,          10.
  12469,  -5.94921303,   70.0448761,          10.
  12470,  -6.58862638,    69.843895,          10.
  12471,  -7.22126913,   69.6225204,          10.
  12472,  -7.84649181,   69.3809891,          10.
  12473,  -8.46365166,   69.1195374,          10.
  12474,  -9.07211494,   68.8384399,          10.
  12475,  -9.67125511,   68.5379868,          10.
  12476,   -10.260458,    68.218483,          10.
  12477,  -10.8391171,   67.8802567,          10.
  12478,  -11.4066391,   67.5236588,          10.
  12479,  -11.9624395,   67.1490555,          10.
  12480,  -12.5059471,   66.7568283,          10.
  12481,  -13.0366049,   66.3473892,          10.
  12482,  -13.5538664,   65.9211426,          10.
  12483,  -14.0572004,   65.4785385,          10.
  12484,  -14.5460901,   65.0200348,          10.
  12485,  -15.0200319,   64.5460892,          10.
  12486,  -15.4785395,   64.0571976,          10.
  12487,  -15.9211426,   63.5538673,          10.
  12488,  -16.3473854,   63.0366058,          10.
  12489,  -16.7568302,   62.5059471,          10.
  12490,  -17.1490555,   61.9624405,          10.
  12491,  -17.5236607,   61.4066391,          10.
  12492,  -17.8802586,    60.839119,          10.
  12493,  -18.2184811,   60.2604561,          10.
  12494,  -18.5379848,    59.671257,          10.
  12495,  -18.8384399,    59.072113,          10.
  12496,  -19.1195374,   58.4636536,          10.
  12497,  -19.3809872,   57.8464928,          10.
  12498,  -19.6225224,   57.2212677,          10.
  12499,  -19.8438931,   56.5886269,          10.
  12500,  -20.0448742,   55.9492149,          10.
  12501,   -20.225256,    55.303688,          10.
  12502,  -20.3848572,     54.65271,          10.
  12503,    -20.52351,   53.9969521,          10.
  12504,  -20.6410732,   53.3370895,          10.
  12505,  -20.7374268,   52.6737938,          10.
  12506,  -20.8124733,   52.0077553,          10.
  12507,  -20.8661308,   51.3396492,          10.
  12508,  -20.8983479,   50.6701698,          10.
  12509,     29.09091,   49.2105255,          10.
  12510,    28.181818,   49.2105255,          10.
  12511,    27.272728,   49.2105255,          10.
  12512,    26.363636,   49.2105255,          10.
  12513,    25.454546,   49.2105255,          10.
  12514,    24.545454,   49.2105255,          10.
  12515,    23.636364,   49.2105255,          10.
  12516,    22.727272,   49.2105255,          10.
  12517,    21.818182,   49.2105255,          10.
  12518,     20.90909,   49.2105255,          10.
  12519,     29.09091,    48.421051,          10.
  12520,    28.181818,    48.421051,          10.
  12521,    27.272728,    48.421051,          10.
  12522,    26.363636,    48.421051,          10.
  12523,    25.454546,    48.421051,          10.
  12524,    24.545454,    48.421051,          10.
  12525,    23.636364,    48.421051,          10.
  12526,    22.727272,    48.421051,          10.
  12527,    21.818182,    48.421051,          10.
  12528,     20.90909,    48.421051,          10.
  12529,     29.09091,   47.6315804,          10.
  12530,    28.181818,   47.6315804,          10.
  12531,    27.272728,   47.6315804,          10.
  12532,    26.363636,   47.6315804,          10.
  12533,    25.454546,   47.6315804,          10.
  12534,    24.545454,   47.6315804,          10.
  12535,    23.636364,   47.6315804,          10.
  12536,    22.727272,   47.6315804,          10.
  12537,    21.818182,   47.6315804,          10.
  12538,     20.90909,   47.6315804,          10.
  12539,     29.09091,   46.8421059,          10.
  12540,    28.181818,   46.8421059,          10.
  12541,    27.272728,   46.8421059,          10.
  12542,    26.363636,   46.8421059,          10.
  12543,    25.454546,   46.8421059,          10.
  12544,    24.545454,   46.8421059,          10.
  12545,    23.636364,   46.8421059,          10.
  12546,    22.727272,   46.8421059,          10.
  12547,    21.818182,   46.8421059,          10.
  12548,     20.90909,   46.8421059,          10.
  12549,     29.09091,   46.0526314,          10.
  12550,    28.181818,   46.0526314,          10.
  12551,    27.272728,   46.0526314,          10.
  12552,    26.363636,   46.0526314,          10.
  12553,    25.454546,   46.0526314,          10.
  12554,    24.545454,   46.0526314,          10.
  12555,    23.636364,   46.0526314,          10.
  12556,    22.727272,   46.0526314,          10.
  12557,    21.818182,   46.0526314,          10.
  12558,     20.90909,   46.0526314,          10.
  12559,     29.09091,   45.2631569,          10.
  12560,    28.181818,   45.2631569,          10.
  12561,    27.272728,   45.2631569,          10.
  12562,    26.363636,   45.2631569,          10.
  12563,    25.454546,   45.2631569,          10.
  12564,    24.545454,   45.2631569,          10.
  12565,    23.636364,   45.2631569,          10.
  12566,    22.727272,   45.2631569,          10.
  12567,    21.818182,   45.2631569,          10.
  12568,     20.90909,   45.2631569,          10.
  12569,     29.09091,   44.4736824,          10.
  12570,    28.181818,   44.4736824,          10.
  12571,    27.272728,   44.4736824,          10.
  12572,    26.363636,   44.4736824,          10.
  12573,    25.454546,   44.4736824,          10.
  12574,    24.545454,   44.4736824,          10.
  12575,    23.636364,   44.4736824,          10.
  12576,    22.727272,   44.4736824,          10.
  12577,    21.818182,   44.4736824,          10.
  12578,     20.90909,   44.4736824,          10.
  12579,     29.09091,   43.6842117,          10.
  12580,    28.181818,   43.6842117,          10.
  12581,    27.272728,   43.6842117,          10.
  12582,    26.363636,   43.6842117,          10.
  12583,    25.454546,   43.6842117,          10.
  12584,    24.545454,   43.6842117,          10.
  12585,    23.636364,   43.6842117,          10.
  12586,    22.727272,   43.6842117,          10.
  12587,    21.818182,   43.6842117,          10.
  12588,     20.90909,   43.6842117,          10.
  12589,     29.09091,   42.8947372,          10.
  12590,    28.181818,   42.8947372,          10.
  12591,    27.272728,   42.8947372,          10.
  12592,    26.363636,   42.8947372,          10.
  12593,    25.454546,   42.8947372,          10.
  12594,    24.545454,   42.8947372,          10.
  12595,    23.636364,   42.8947372,          10.
  12596,    22.727272,   42.8947372,          10.
  12597,    21.818182,   42.8947372,          10.
  12598,     20.90909,   42.8947372,          10.
  12599,     29.09091,   42.1052628,          10.
  12600,    28.181818,   42.1052628,          10.
  12601,    27.272728,   42.1052628,          10.
  12602,    26.363636,   42.1052628,          10.
  12603,    25.454546,   42.1052628,          10.
  12604,    24.545454,   42.1052628,          10.
  12605,    23.636364,   42.1052628,          10.
  12606,    22.727272,   42.1052628,          10.
  12607,    21.818182,   42.1052628,          10.
  12608,     20.90909,   42.1052628,          10.
  12609,     29.09091,   41.3157883,          10.
  12610,    28.181818,   41.3157883,          10.
  12611,    27.272728,   41.3157883,          10.
  12612,    26.363636,   41.3157883,          10.
  12613,    25.454546,   41.3157883,          10.
  12614,    24.545454,   41.3157883,          10.
  12615,    23.636364,   41.3157883,          10.
  12616,    22.727272,   41.3157883,          10.
  12617,    21.818182,   41.3157883,          10.
  12618,     20.90909,   41.3157883,          10.
  12619,     29.09091,   40.5263176,          10.
  12620,    28.181818,   40.5263176,          10.
  12621,    27.272728,   40.5263176,          10.
  12622,    26.363636,   40.5263176,          10.
  12623,    25.454546,   40.5263176,          10.
  12624,    24.545454,   40.5263176,          10.
  12625,    23.636364,   40.5263176,          10.
  12626,    22.727272,   40.5263176,          10.
  12627,    21.818182,   40.5263176,          10.
  12628,     20.90909,   40.5263176,          10.
  12629,     29.09091,   39.7368431,          10.
  12630,    28.181818,   39.7368431,          10.
  12631,    27.272728,   39.7368431,          10.
  12632,    26.363636,   39.7368431,          10.
  12633,    25.454546,   39.7368431,          10.
  12634,    24.545454,   39.7368431,          10.
  12635,    23.636364,   39.7368431,          10.
  12636,    22.727272,   39.7368431,          10.
  12637,    21.818182,   39.7368431,          10.
  12638,     20.90909,   39.7368431,          10.
  12639,     29.09091,   38.9473686,          10.
  12640,    28.181818,   38.9473686,          10.
  12641,    27.272728,   38.9473686,          10.
  12642,    26.363636,   38.9473686,          10.
  12643,    25.454546,   38.9473686,          10.
  12644,    24.545454,   38.9473686,          10.
  12645,    23.636364,   38.9473686,          10.
  12646,    22.727272,   38.9473686,          10.
  12647,    21.818182,   38.9473686,          10.
  12648,     20.90909,   38.9473686,          10.
  12649,     29.09091,   38.1578941,          10.
  12650,    28.181818,   38.1578941,          10.
  12651,    27.272728,   38.1578941,          10.
  12652,    26.363636,   38.1578941,          10.
  12653,    25.454546,   38.1578941,          10.
  12654,    24.545454,   38.1578941,          10.
  12655,    23.636364,   38.1578941,          10.
  12656,    22.727272,   38.1578941,          10.
  12657,    21.818182,   38.1578941,          10.
  12658,     20.90909,   38.1578941,          10.
  12659,     29.09091,   37.3684196,          10.
  12660,    28.181818,   37.3684196,          10.
  12661,    27.272728,   37.3684196,          10.
  12662,    26.363636,   37.3684196,          10.
  12663,    25.454546,   37.3684196,          10.
  12664,    24.545454,   37.3684196,          10.
  12665,    23.636364,   37.3684196,          10.
  12666,    22.727272,   37.3684196,          10.
  12667,    21.818182,   37.3684196,          10.
  12668,     20.90909,   37.3684196,          10.
  12669,     29.09091,    36.578949,          10.
  12670,    28.181818,    36.578949,          10.
  12671,    27.272728,    36.578949,          10.
  12672,    26.363636,    36.578949,          10.
  12673,    25.454546,    36.578949,          10.
  12674,    24.545454,    36.578949,          10.
  12675,    23.636364,    36.578949,          10.
  12676,    22.727272,    36.578949,          10.
  12677,    21.818182,    36.578949,          10.
  12678,     20.90909,    36.578949,          10.
  12679,     29.09091,   35.7894745,          10.
  12680,    28.181818,   35.7894745,          10.
  12681,    27.272728,   35.7894745,          10.
  12682,    26.363636,   35.7894745,          10.
  12683,    25.454546,   35.7894745,          10.
  12684,    24.545454,   35.7894745,          10.
  12685,    23.636364,   35.7894745,          10.
  12686,    22.727272,   35.7894745,          10.
  12687,    21.818182,   35.7894745,          10.
  12688,     20.90909,   35.7894745,          10.
  12689,     29.09091,          35.,          10.
  12690,    28.181818,          35.,          10.
  12691,    27.272728,          35.,          10.
  12692,    26.363636,          35.,          10.
  12693,    25.454546,          35.,          10.
  12694,    24.545454,          35.,          10.
  12695,    23.636364,          35.,          10.
  12696,    22.727272,          35.,          10.
  12697,    21.818182,          35.,          10.
  12698,     20.90909,          35.,          10.
  12699,     29.09091,   34.2105255,          10.
  12700,    28.181818,   34.2105255,          10.
  12701,    27.272728,   34.2105255,          10.
  12702,    26.363636,   34.2105255,          10.
  12703,    25.454546,   34.2105255,          10.
  12704,    24.545454,   34.2105255,          10.
  12705,    23.636364,   34.2105255,          10.
  12706,    22.727272,   34.2105255,          10.
  12707,    21.818182,   34.2105255,          10.
  12708,     20.90909,   34.2105255,          10.
  12709,     29.09091,    33.421051,          10.
  12710,    28.181818,    33.421051,          10.
  12711,    27.272728,    33.421051,          10.
  12712,    26.363636,    33.421051,          10.
  12713,    25.454546,    33.421051,          10.
  12714,    24.545454,    33.421051,          10.
  12715,    23.636364,    33.421051,          10.
  12716,    22.727272,    33.421051,          10.
  12717,    21.818182,    33.421051,          10.
  12718,     20.90909,    33.421051,          10.
  12719,     29.09091,   32.6315804,          10.
  12720,    28.181818,   32.6315804,          10.
  12721,    27.272728,   32.6315804,          10.
  12722,    26.363636,   32.6315804,          10.
  12723,    25.454546,   32.6315804,          10.
  12724,    24.545454,   32.6315804,          10.
  12725,    23.636364,   32.6315804,          10.
  12726,    22.727272,   32.6315804,          10.
  12727,    21.818182,   32.6315804,          10.
  12728,     20.90909,   32.6315804,          10.
  12729,     29.09091,   31.8421059,          10.
  12730,    28.181818,   31.8421059,          10.
  12731,    27.272728,   31.8421059,          10.
  12732,    26.363636,   31.8421059,          10.
  12733,    25.454546,   31.8421059,          10.
  12734,    24.545454,   31.8421059,          10.
  12735,    23.636364,   31.8421059,          10.
  12736,    22.727272,   31.8421059,          10.
  12737,    21.818182,   31.8421059,          10.
  12738,     20.90909,   31.8421059,          10.
  12739,     29.09091,   31.0526314,          10.
  12740,    28.181818,   31.0526314,          10.
  12741,    27.272728,   31.0526314,          10.
  12742,    26.363636,   31.0526314,          10.
  12743,    25.454546,   31.0526314,          10.
  12744,    24.545454,   31.0526314,          10.
  12745,    23.636364,   31.0526314,          10.
  12746,    22.727272,   31.0526314,          10.
  12747,    21.818182,   31.0526314,          10.
  12748,     20.90909,   31.0526314,          10.
  12749,     29.09091,   30.2631588,          10.
  12750,    28.181818,   30.2631588,          10.
  12751,    27.272728,   30.2631588,          10.
  12752,    26.363636,   30.2631588,          10.
  12753,    25.454546,   30.2631588,          10.
  12754,    24.545454,   30.2631588,          10.
  12755,    23.636364,   30.2631588,          10.
  12756,    22.727272,   30.2631588,          10.
  12757,    21.818182,   30.2631588,          10.
  12758,     20.90909,   30.2631588,          10.
  12759,     29.09091,   29.4736843,          10.
  12760,    28.181818,   29.4736843,          10.
  12761,    27.272728,   29.4736843,          10.
  12762,    26.363636,   29.4736843,          10.
  12763,    25.454546,   29.4736843,          10.
  12764,    24.545454,   29.4736843,          10.
  12765,    23.636364,   29.4736843,          10.
  12766,    22.727272,   29.4736843,          10.
  12767,    21.818182,   29.4736843,          10.
  12768,     20.90909,   29.4736843,          10.
  12769,     29.09091,   28.6842098,          10.
  12770,    28.181818,   28.6842098,          10.
  12771,    27.272728,   28.6842098,          10.
  12772,    26.363636,   28.6842098,          10.
  12773,    25.454546,   28.6842098,          10.
  12774,    24.545454,   28.6842098,          10.
  12775,    23.636364,   28.6842098,          10.
  12776,    22.727272,   28.6842098,          10.
  12777,    21.818182,   28.6842098,          10.
  12778,     20.90909,   28.6842098,          10.
  12779,     29.09091,   27.8947372,          10.
  12780,    28.181818,   27.8947372,          10.
  12781,    27.272728,   27.8947372,          10.
  12782,    26.363636,   27.8947372,          10.
  12783,    25.454546,   27.8947372,          10.
  12784,    24.545454,   27.8947372,          10.
  12785,    23.636364,   27.8947372,          10.
  12786,    22.727272,   27.8947372,          10.
  12787,    21.818182,   27.8947372,          10.
  12788,     20.90909,   27.8947372,          10.
  12789,     29.09091,   27.1052628,          10.
  12790,    28.181818,   27.1052628,          10.
  12791,    27.272728,   27.1052628,          10.
  12792,    26.363636,   27.1052628,          10.
  12793,    25.454546,   27.1052628,          10.
  12794,    24.545454,   27.1052628,          10.
  12795,    23.636364,   27.1052628,          10.
  12796,    22.727272,   27.1052628,          10.
  12797,    21.818182,   27.1052628,          10.
  12798,     20.90909,   27.1052628,          10.
  12799,     29.09091,   26.3157902,          10.
  12800,    28.181818,   26.3157902,          10.
  12801,    27.272728,   26.3157902,          10.
  12802,    26.363636,   26.3157902,          10.
  12803,    25.454546,   26.3157902,          10.
  12804,    24.545454,   26.3157902,          10.
  12805,    23.636364,   26.3157902,          10.
  12806,    22.727272,   26.3157902,          10.
  12807,    21.818182,   26.3157902,          10.
  12808,     20.90909,   26.3157902,          10.
  12809,     29.09091,   25.5263157,          10.
  12810,    28.181818,   25.5263157,          10.
  12811,    27.272728,   25.5263157,          10.
  12812,    26.363636,   25.5263157,          10.
  12813,    25.454546,   25.5263157,          10.
  12814,    24.545454,   25.5263157,          10.
  12815,    23.636364,   25.5263157,          10.
  12816,    22.727272,   25.5263157,          10.
  12817,    21.818182,   25.5263157,          10.
  12818,     20.90909,   25.5263157,          10.
  12819,     29.09091,   24.7368412,          10.
  12820,    28.181818,   24.7368412,          10.
  12821,    27.272728,   24.7368412,          10.
  12822,    26.363636,   24.7368412,          10.
  12823,    25.454546,   24.7368412,          10.
  12824,    24.545454,   24.7368412,          10.
  12825,    23.636364,   24.7368412,          10.
  12826,    22.727272,   24.7368412,          10.
  12827,    21.818182,   24.7368412,          10.
  12828,     20.90909,   24.7368412,          10.
  12829,     29.09091,   23.9473686,          10.
  12830,    28.181818,   23.9473686,          10.
  12831,    27.272728,   23.9473686,          10.
  12832,    26.363636,   23.9473686,          10.
  12833,    25.454546,   23.9473686,          10.
  12834,    24.545454,   23.9473686,          10.
  12835,    23.636364,   23.9473686,          10.
  12836,    22.727272,   23.9473686,          10.
  12837,    21.818182,   23.9473686,          10.
  12838,     20.90909,   23.9473686,          10.
  12839,     29.09091,   23.1578941,          10.
  12840,    28.181818,   23.1578941,          10.
  12841,    27.272728,   23.1578941,          10.
  12842,    26.363636,   23.1578941,          10.
  12843,    25.454546,   23.1578941,          10.
  12844,    24.545454,   23.1578941,          10.
  12845,    23.636364,   23.1578941,          10.
  12846,    22.727272,   23.1578941,          10.
  12847,    21.818182,   23.1578941,          10.
  12848,     20.90909,   23.1578941,          10.
  12849,     29.09091,   22.3684216,          10.
  12850,    28.181818,   22.3684216,          10.
  12851,    27.272728,   22.3684216,          10.
  12852,    26.363636,   22.3684216,          10.
  12853,    25.454546,   22.3684216,          10.
  12854,    24.545454,   22.3684216,          10.
  12855,    23.636364,   22.3684216,          10.
  12856,    22.727272,   22.3684216,          10.
  12857,    21.818182,   22.3684216,          10.
  12858,     20.90909,   22.3684216,          10.
  12859,     29.09091,   21.5789471,          10.
  12860,    28.181818,   21.5789471,          10.
  12861,    27.272728,   21.5789471,          10.
  12862,    26.363636,   21.5789471,          10.
  12863,    25.454546,   21.5789471,          10.
  12864,    24.545454,   21.5789471,          10.
  12865,    23.636364,   21.5789471,          10.
  12866,    22.727272,   21.5789471,          10.
  12867,    21.818182,   21.5789471,          10.
  12868,     20.90909,   21.5789471,          10.
  12869,     29.09091,   20.7894745,          10.
  12870,    28.181818,   20.7894745,          10.
  12871,    27.272728,   20.7894745,          10.
  12872,    26.363636,   20.7894745,          10.
  12873,    25.454546,   20.7894745,          10.
  12874,    24.545454,   20.7894745,          10.
  12875,    23.636364,   20.7894745,          10.
  12876,    22.727272,   20.7894745,          10.
  12877,    21.818182,   20.7894745,          10.
  12878,     20.90909,   20.7894745,          10.
  12879,          30.,   49.2065392,     9.090909
  12880,          30.,   48.4130783,     9.090909
  12881,          30.,   47.6196175,     9.090909
  12882,          30.,   46.8261566,     9.090909
  12883,          30.,   46.0326958,     9.090909
  12884,          30.,   45.2392349,     9.090909
  12885,          30.,   44.4488029,     9.090909
  12886,          30.,   43.6583748,     9.090909
  12887,          30.,   42.8679428,     9.090909
  12888,          30.,   42.0775108,     9.090909
  12889,          30.,   41.2870827,     9.090909
  12890,          30.,   40.4966507,     9.090909
  12891,          30.,   39.7062187,     9.090909
  12892,          30.,   38.9157906,     9.090909
  12893,          30.,   38.1253586,     9.090909
  12894,          30.,   37.3349266,     9.090909
  12895,          30.,   36.5444984,     9.090909
  12896,          30.,   35.7540665,     9.090909
  12897,          30.,   34.9636345,     9.090909
  12898,          30.,   34.1732063,     9.090909
  12899,          30.,   33.3827744,     9.090909
  12900,          30.,   32.5923462,     9.090909
  12901,          30.,   31.8019142,     9.090909
  12902,          30.,   31.0114841,     9.090909
  12903,          30.,   30.2210522,     9.090909
  12904,          30.,   29.4306221,     9.090909
  12905,          30.,    28.640192,     9.090909
  12906,          30.,   27.8497601,     9.090909
  12907,          30.,     27.05933,     9.090909
  12908,          30.,   26.2688999,     9.090909
  12909,          30.,   25.4784698,     9.090909
  12910,          30.,   24.6958313,     9.090909
  12911,          30.,   23.9131927,     9.090909
  12912,          30.,   23.1305542,     9.090909
  12913,          30.,   22.3479156,     9.090909
  12914,          30.,   21.5652771,     9.090909
  12915,          30.,   20.7826385,     9.090909
  12916,          30.,   49.2025528,   8.18181801
  12917,          30.,   48.4051018,   8.18181801
  12918,          30.,   47.6076546,   8.18181801
  12919,          30.,   46.8102074,   8.18181801
  12920,          30.,   46.0127602,   8.18181801
  12921,          30.,   45.2153091,   8.18181801
  12922,          30.,   44.4239235,   8.18181801
  12923,          30.,    43.632534,   8.18181801
  12924,          30.,   42.8411484,   8.18181801
  12925,          30.,   42.0497589,   8.18181801
  12926,          30.,   41.2583733,   8.18181801
  12927,          30.,   40.4669838,   8.18181801
  12928,          30.,   39.6755981,   8.18181801
  12929,          30.,   38.8842087,   8.18181801
  12930,          30.,    38.092823,   8.18181801
  12931,          30.,   37.3014336,   8.18181801
  12932,          30.,   36.5100479,   8.18181801
  12933,          30.,   35.7186584,   8.18181801
  12934,          30.,   34.9272728,   8.18181801
  12935,          30.,   34.1358833,   8.18181801
  12936,          30.,   33.3444977,   8.18181801
  12937,          30.,   32.5531082,   8.18181801
  12938,          30.,   31.7617226,   8.18181801
  12939,          30.,    30.970335,   8.18181801
  12940,          30.,   30.1789474,   8.18181801
  12941,          30.,   29.3875599,   8.18181801
  12942,          30.,   28.5961723,   8.18181801
  12943,          30.,   27.8047848,   8.18181801
  12944,          30.,   27.0133972,   8.18181801
  12945,          30.,   26.2220097,   8.18181801
  12946,          30.,   25.4306221,   8.18181801
  12947,          30.,   24.6548195,   8.18181801
  12948,          30.,    23.879015,   8.18181801
  12949,          30.,   23.1032124,   8.18181801
  12950,          30.,   22.3274097,   8.18181801
  12951,          30.,   21.5516071,   8.18181801
  12952,          30.,   20.7758026,   8.18181801
  12953,          30.,   49.1985664,   7.27272749
  12954,          30.,   48.3971291,   7.27272749
  12955,          30.,   47.5956955,   7.27272749
  12956,          30.,   46.7942581,   7.27272749
  12957,          30.,   45.9928246,   7.27272749
  12958,          30.,   45.1913872,   7.27272749
  12959,          30.,    44.399044,   7.27272749
  12960,          30.,   43.6066971,   7.27272749
  12961,          30.,   42.8143539,   7.27272749
  12962,          30.,   42.0220108,   7.27272749
  12963,          30.,   41.2296638,   7.27272749
  12964,          30.,   40.4373207,   7.27272749
  12965,          30.,   39.6449776,   7.27272749
  12966,          30.,   38.8526306,   7.27272749
  12967,          30.,   38.0602875,   7.27272749
  12968,          30.,   37.2679443,   7.27272749
  12969,          30.,   36.4755974,   7.27272749
  12970,          30.,   35.6832542,   7.27272749
  12971,          30.,   34.8909073,   7.27272749
  12972,          30.,   34.0985641,   7.27272749
  12973,          30.,    33.306221,   7.27272749
  12974,          30.,   32.5138741,   7.27272749
  12975,          30.,   31.7215309,   7.27272749
  12976,          30.,   30.9291859,   7.27272749
  12977,          30.,   30.1368427,   7.27272749
  12978,          30.,   29.3444977,   7.27272749
  12979,          30.,   28.5521526,   7.27272749
  12980,          30.,   27.7598095,   7.27272749
  12981,          30.,   26.9674644,   7.27272749
  12982,          30.,   26.1751194,   7.27272749
  12983,          30.,   25.3827744,   7.27272749
  12984,          30.,   24.6138077,   7.27272749
  12985,          30.,   23.8448391,   7.27272749
  12986,          30.,   23.0758724,   7.27272749
  12987,          30.,   22.3069038,   7.27272749
  12988,          30.,   21.5379353,   7.27272749
  12989,          30.,   20.7689686,   7.27272749
  12990,          30.,   49.1945763,   6.36363649
  12991,          30.,   48.3891563,   6.36363649
  12992,          30.,   47.5837326,   6.36363649
  12993,          30.,   46.7783089,   6.36363649
  12994,          30.,   45.9728851,   6.36363649
  12995,          30.,   45.1674652,   6.36363649
  12996,          30.,   44.3741646,   6.36363649
  12997,          30.,   43.5808601,   6.36363649
  12998,          30.,   42.7875595,   6.36363649
  12999,          30.,   41.9942589,   6.36363649
  13000,          30.,   41.2009583,   6.36363649
  13001,          30.,   40.4076538,   6.36363649
  13002,          30.,   39.6143532,   6.36363649
  13003,          30.,   38.8210526,   6.36363649
  13004,          30.,   38.0277519,   6.36363649
  13005,          30.,   37.2344513,   6.36363649
  13006,          30.,   36.4411469,   6.36363649
  13007,          30.,   35.6478462,   6.36363649
  13008,          30.,   34.8545456,   6.36363649
  13009,          30.,    34.061245,   6.36363649
  13010,          30.,   33.2679443,   6.36363649
  13011,          30.,   32.4746399,   6.36363649
  13012,          30.,   31.6813393,   6.36363649
  13013,          30.,   30.8880386,   6.36363649
  13014,          30.,   30.0947361,   6.36363649
  13015,          30.,   29.3014355,   6.36363649
  13016,          30.,   28.5081348,   6.36363649
  13017,          30.,   27.7148323,   6.36363649
  13018,          30.,   26.9215317,   6.36363649
  13019,          30.,   26.1282291,   6.36363649
  13020,          30.,   25.3349285,   6.36363649
  13021,          30.,   24.5727959,   6.36363649
  13022,          30.,   23.8106632,   6.36363649
  13023,          30.,   23.0485306,   6.36363649
  13024,          30.,   22.2863979,   6.36363649
  13025,          30.,   21.5242653,   6.36363649
  13026,          30.,   20.7621326,   6.36363649
  13027,          30.,   49.1905899,    5.4545455
  13028,          30.,   48.3811798,    5.4545455
  13029,          30.,   47.5717697,    5.4545455
  13030,          30.,   46.7623596,    5.4545455
  13031,          30.,   45.9529495,    5.4545455
  13032,          30.,   45.1435394,    5.4545455
  13033,          30.,   44.3492813,    5.4545455
  13034,          30.,   43.5550232,    5.4545455
  13035,          30.,   42.7607651,    5.4545455
  13036,          30.,    41.966507,    5.4545455
  13037,          30.,   41.1722488,    5.4545455
  13038,          30.,   40.3779907,    5.4545455
  13039,          30.,   39.5837326,    5.4545455
  13040,          30.,   38.7894745,    5.4545455
  13041,          30.,   37.9952164,    5.4545455
  13042,          30.,   37.2009583,    5.4545455
  13043,          30.,   36.4067001,    5.4545455
  13044,          30.,    35.612442,    5.4545455
  13045,          30.,   34.8181801,    5.4545455
  13046,          30.,    34.023922,    5.4545455
  13047,          30.,   33.2296638,    5.4545455
  13048,          30.,   32.4354057,    5.4545455
  13049,          30.,   31.6411476,    5.4545455
  13050,          30.,   30.8468895,    5.4545455
  13051,          30.,   30.0526314,    5.4545455
  13052,          30.,   29.2583733,    5.4545455
  13053,          30.,   28.4641151,    5.4545455
  13054,          30.,    27.669857,    5.4545455
  13055,          30.,   26.8755989,    5.4545455
  13056,          30.,   26.0813389,    5.4545455
  13057,          30.,   25.2870808,    5.4545455
  13058,          30.,   24.5317841,    5.4545455
  13059,          30.,   23.7764874,    5.4545455
  13060,          30.,   23.0211887,    5.4545455
  13061,          30.,    22.265892,    5.4545455
  13062,          30.,   21.5105953,    5.4545455
  13063,          30.,   20.7552967,    5.4545455
  13064,          30.,   49.1866035,    4.5454545
  13065,          30.,   48.3732071,    4.5454545
  13066,          30.,   47.5598068,    4.5454545
  13067,          30.,   46.7464104,    4.5454545
  13068,          30.,   45.9330139,    4.5454545
  13069,          30.,   45.1196175,    4.5454545
  13070,          30.,   44.3244019,    4.5454545
  13071,          30.,   43.5291862,    4.5454545
  13072,          30.,   42.7339706,    4.5454545
  13073,          30.,    41.938755,    4.5454545
  13074,          30.,   41.1435394,    4.5454545
  13075,          30.,   40.3483238,    4.5454545
  13076,          30.,   39.5531082,    4.5454545
  13077,          30.,   38.7578964,    4.5454545
  13078,          30.,   37.9626808,    4.5454545
  13079,          30.,   37.1674652,    4.5454545
  13080,          30.,   36.3722496,    4.5454545
  13081,          30.,    35.577034,    4.5454545
  13082,          30.,   34.7818184,    4.5454545
  13083,          30.,   33.9866028,    4.5454545
  13084,          30.,   33.1913872,    4.5454545
  13085,          30.,   32.3961716,    4.5454545
  13086,          30.,   31.6009579,    4.5454545
  13087,          30.,   30.8057423,    4.5454545
  13088,          30.,   30.0105267,    4.5454545
  13089,          30.,   29.2153111,    4.5454545
  13090,          30.,   28.4200954,    4.5454545
  13091,          30.,   27.6248798,    4.5454545
  13092,          30.,   26.8296642,    4.5454545
  13093,          30.,   26.0344505,    4.5454545
  13094,          30.,   25.2392349,    4.5454545
  13095,          30.,   24.4907722,    4.5454545
  13096,          30.,   23.7423096,    4.5454545
  13097,          30.,   22.9938488,    4.5454545
  13098,          30.,   22.2453861,    4.5454545
  13099,          30.,   21.4969234,    4.5454545
  13100,          30.,   20.7484627,    4.5454545
  13101,          30.,   49.1826172,   3.63636374
  13102,          30.,   48.3652306,   3.63636374
  13103,          30.,   47.5478477,   3.63636374
  13104,          30.,   46.7304611,   3.63636374
  13105,          30.,   45.9130783,   3.63636374
  13106,          30.,   45.0956955,   3.63636374
  13107,          30.,   44.2995224,   3.63636374
  13108,          30.,   43.5033493,   3.63636374
  13109,          30.,   42.7071762,   3.63636374
  13110,          30.,   41.9110031,   3.63636374
  13111,          30.,   41.1148338,   3.63636374
  13112,          30.,   40.3186607,   3.63636374
  13113,          30.,   39.5224876,   3.63636374
  13114,          30.,   38.7263145,   3.63636374
  13115,          30.,   37.9301453,   3.63636374
  13116,          30.,   37.1339722,   3.63636374
  13117,          30.,   36.3377991,   3.63636374
  13118,          30.,    35.541626,   3.63636374
  13119,          30.,   34.7454529,   3.63636374
  13120,          30.,   33.9492836,   3.63636374
  13121,          30.,   33.1531105,   3.63636374
  13122,          30.,   32.3569374,   3.63636374
  13123,          30.,   31.5607662,   3.63636374
  13124,          30.,   30.7645931,   3.63636374
  13125,          30.,   29.9684219,   3.63636374
  13126,          30.,   29.1722488,   3.63636374
  13127,          30.,   28.3760757,   3.63636374
  13128,          30.,   27.5799046,   3.63636374
  13129,          30.,   26.7837315,   3.63636374
  13130,          30.,   25.9875603,   3.63636374
  13131,          30.,   25.1913872,   3.63636374
  13132,          30.,   24.4497604,   3.63636374
  13133,          30.,   23.7081337,   3.63636374
  13134,          30.,    22.966507,   3.63636374
  13135,          30.,   22.2248802,   3.63636374
  13136,          30.,   21.4832535,   3.63636374
  13137,          30.,   20.7416267,   3.63636374
  13138,          30.,    49.178627,   2.72727275
  13139,          30.,   48.3572578,   2.72727275
  13140,          30.,   47.5358849,   2.72727275
  13141,          30.,   46.7145119,   2.72727275
  13142,          30.,   45.8931427,   2.72727275
  13143,          30.,   45.0717697,   2.72727275
  13144,          30.,   44.2746429,   2.72727275
  13145,          30.,   43.4775124,   2.72727275
  13146,          30.,   42.6803818,   2.72727275
  13147,          30.,    41.883255,   2.72727275
  13148,          30.,   41.0861244,   2.72727275
  13149,          30.,   40.2889938,   2.72727275
  13150,          30.,   39.4918671,   2.72727275
  13151,          30.,   38.6947365,   2.72727275
  13152,          30.,   37.8976059,   2.72727275
  13153,          30.,   37.1004791,   2.72727275
  13154,          30.,   36.3033485,   2.72727275
  13155,          30.,   35.5062218,   2.72727275
  13156,          30.,   34.7090912,   2.72727275
  13157,          30.,   33.9119606,   2.72727275
  13158,          30.,   33.1148338,   2.72727275
  13159,          30.,   32.3177032,   2.72727275
  13160,          30.,   31.5205746,   2.72727275
  13161,          30.,   30.7234459,   2.72727275
  13162,          30.,   29.9263153,   2.72727275
  13163,          30.,   29.1291866,   2.72727275
  13164,          30.,    28.332058,   2.72727275
  13165,          30.,   27.5349274,   2.72727275
  13166,          30.,   26.7377987,   2.72727275
  13167,          30.,     25.94067,   2.72727275
  13168,          30.,   25.1435413,   2.72727275
  13169,          30.,   24.4087486,   2.72727275
  13170,          30.,   23.6739578,   2.72727275
  13171,          30.,    22.939167,   2.72727275
  13172,          30.,   22.2043743,   2.72727275
  13173,          30.,   21.4695835,   2.72727275
  13174,          30.,   20.7347908,   2.72727275
  13175,          30.,   49.1746407,   1.81818187
  13176,          30.,   48.3492813,   1.81818187
  13177,          30.,    47.523922,   1.81818187
  13178,          30.,   46.6985664,   1.81818187
  13179,          30.,   45.8732071,   1.81818187
  13180,          30.,   45.0478477,   1.81818187
  13181,          30.,   44.2497597,   1.81818187
  13182,          30.,   43.4516754,   1.81818187
  13183,          30.,   42.6535873,   1.81818187
  13184,          30.,   41.8555031,   1.81818187
  13185,          30.,    41.057415,   1.81818187
  13186,          30.,   40.2593307,   1.81818187
  13187,          30.,   39.4612427,   1.81818187
  13188,          30.,   38.6631584,   1.81818187
  13189,          30.,   37.8650703,   1.81818187
  13190,          30.,   37.0669861,   1.81818187
  13191,          30.,    36.268898,   1.81818187
  13192,          30.,   35.4708138,   1.81818187
  13193,          30.,   34.6727257,   1.81818187
  13194,          30.,   33.8746414,   1.81818187
  13195,          30.,   33.0765533,   1.81818187
  13196,          30.,   32.2784691,   1.81818187
  13197,          30.,   31.4803829,   1.81818187
  13198,          30.,   30.6822968,   1.81818187
  13199,          30.,   29.8842106,   1.81818187
  13200,          30.,   29.0861244,   1.81818187
  13201,          30.,   28.2880383,   1.81818187
  13202,          30.,   27.4899521,   1.81818187
  13203,          30.,   26.6918659,   1.81818187
  13204,          30.,   25.8937798,   1.81818187
  13205,          30.,   25.0956936,   1.81818187
  13206,          30.,   24.3677368,   1.81818187
  13207,          30.,    23.639782,   1.81818187
  13208,          30.,   22.9118252,   1.81818187
  13209,          30.,   22.1838684,   1.81818187
  13210,          30.,   21.4559116,   1.81818187
  13211,          30.,   20.7279568,   1.81818187
  13212,          30.,   49.1706543,  0.909090936
  13213,          30.,   48.3413086,  0.909090936
  13214,          30.,   47.5119629,  0.909090936
  13215,          30.,   46.6826172,  0.909090936
  13216,          30.,   45.8532677,  0.909090936
  13217,          30.,    45.023922,  0.909090936
  13218,          30.,   44.2248802,  0.909090936
  13219,          30.,   43.4258385,  0.909090936
  13220,          30.,   42.6267929,  0.909090936
  13221,          30.,   41.8277512,  0.909090936
  13222,          30.,   41.0287094,  0.909090936
  13223,          30.,   40.2296638,  0.909090936
  13224,          30.,   39.4306221,  0.909090936
  13225,          30.,   38.6315804,  0.909090936
  13226,          30.,   37.8325348,  0.909090936
  13227,          30.,    37.033493,  0.909090936
  13228,          30.,   36.2344513,  0.909090936
  13229,          30.,   35.4354057,  0.909090936
  13230,          30.,    34.636364,  0.909090936
  13231,          30.,   33.8373222,  0.909090936
  13232,          30.,   33.0382767,  0.909090936
  13233,          30.,   32.2392349,  0.909090936
  13234,          30.,   31.4401913,  0.909090936
  13235,          30.,   30.6411476,  0.909090936
  13236,          30.,   29.8421059,  0.909090936
  13237,          30.,   29.0430622,  0.909090936
  13238,          30.,   28.2440186,  0.909090936
  13239,          30.,   27.4449768,  0.909090936
  13240,          30.,   26.6459332,  0.909090936
  13241,          30.,   25.8468895,  0.909090936
  13242,          30.,   25.0478477,  0.909090936
  13243,          30.,    24.326725,  0.909090936
  13244,          30.,   23.6056042,  0.909090936
  13245,          30.,   22.8844833,  0.909090936
  13246,          30.,   22.1633625,  0.909090936
  13247,          30.,   21.4422417,  0.909090936
  13248,          30.,   20.7211208,  0.909090936
  13249,          20.,   49.2065392,     9.090909
  13250,          20.,   48.4130783,     9.090909
  13251,          20.,   47.6196175,     9.090909
  13252,          20.,   46.8261566,     9.090909
  13253,          20.,   46.0326958,     9.090909
  13254,          20.,   45.2392349,     9.090909
  13255,          20.,   44.4488029,     9.090909
  13256,          20.,   43.6583748,     9.090909
  13257,          20.,   42.8679428,     9.090909
  13258,          20.,   42.0775108,     9.090909
  13259,          20.,   41.2870827,     9.090909
  13260,          20.,   40.4966507,     9.090909
  13261,          20.,   39.7062187,     9.090909
  13262,          20.,   38.9157906,     9.090909
  13263,          20.,   38.1253586,     9.090909
  13264,          20.,   37.3349266,     9.090909
  13265,          20.,   36.5444984,     9.090909
  13266,          20.,   35.7540665,     9.090909
  13267,          20.,   34.9636345,     9.090909
  13268,          20.,   34.1732063,     9.090909
  13269,          20.,   33.3827744,     9.090909
  13270,          20.,   32.5923462,     9.090909
  13271,          20.,   31.8019142,     9.090909
  13272,          20.,   31.0114841,     9.090909
  13273,          20.,   30.2210522,     9.090909
  13274,          20.,   29.4306221,     9.090909
  13275,          20.,    28.640192,     9.090909
  13276,          20.,   27.8497601,     9.090909
  13277,          20.,     27.05933,     9.090909
  13278,          20.,   26.2688999,     9.090909
  13279,          20.,   25.4784698,     9.090909
  13280,          20.,   24.6958313,     9.090909
  13281,          20.,   23.9131927,     9.090909
  13282,          20.,   23.1305542,     9.090909
  13283,          20.,   22.3479156,     9.090909
  13284,          20.,   21.5652771,     9.090909
  13285,          20.,   20.7826385,     9.090909
  13286,          20.,   49.2025528,   8.18181801
  13287,          20.,   48.4051018,   8.18181801
  13288,          20.,   47.6076546,   8.18181801
  13289,          20.,   46.8102074,   8.18181801
  13290,          20.,   46.0127602,   8.18181801
  13291,          20.,   45.2153091,   8.18181801
  13292,          20.,   44.4239235,   8.18181801
  13293,          20.,    43.632534,   8.18181801
  13294,          20.,   42.8411484,   8.18181801
  13295,          20.,   42.0497589,   8.18181801
  13296,          20.,   41.2583733,   8.18181801
  13297,          20.,   40.4669838,   8.18181801
  13298,          20.,   39.6755981,   8.18181801
  13299,          20.,   38.8842087,   8.18181801
  13300,          20.,    38.092823,   8.18181801
  13301,          20.,   37.3014336,   8.18181801
  13302,          20.,   36.5100479,   8.18181801
  13303,          20.,   35.7186584,   8.18181801
  13304,          20.,   34.9272728,   8.18181801
  13305,          20.,   34.1358833,   8.18181801
  13306,          20.,   33.3444977,   8.18181801
  13307,          20.,   32.5531082,   8.18181801
  13308,          20.,   31.7617226,   8.18181801
  13309,          20.,    30.970335,   8.18181801
  13310,          20.,   30.1789474,   8.18181801
  13311,          20.,   29.3875599,   8.18181801
  13312,          20.,   28.5961723,   8.18181801
  13313,          20.,   27.8047848,   8.18181801
  13314,          20.,   27.0133972,   8.18181801
  13315,          20.,   26.2220097,   8.18181801
  13316,          20.,   25.4306221,   8.18181801
  13317,          20.,   24.6548195,   8.18181801
  13318,          20.,    23.879015,   8.18181801
  13319,          20.,   23.1032124,   8.18181801
  13320,          20.,   22.3274097,   8.18181801
  13321,          20.,   21.5516071,   8.18181801
  13322,          20.,   20.7758026,   8.18181801
  13323,          20.,   49.1985664,   7.27272749
  13324,          20.,   48.3971291,   7.27272749
  13325,          20.,   47.5956955,   7.27272749
  13326,          20.,   46.7942581,   7.27272749
  13327,          20.,   45.9928246,   7.27272749
  13328,          20.,   45.1913872,   7.27272749
  13329,          20.,    44.399044,   7.27272749
  13330,          20.,   43.6066971,   7.27272749
  13331,          20.,   42.8143539,   7.27272749
  13332,          20.,   42.0220108,   7.27272749
  13333,          20.,   41.2296638,   7.27272749
  13334,          20.,   40.4373207,   7.27272749
  13335,          20.,   39.6449776,   7.27272749
  13336,          20.,   38.8526306,   7.27272749
  13337,          20.,   38.0602875,   7.27272749
  13338,          20.,   37.2679443,   7.27272749
  13339,          20.,   36.4755974,   7.27272749
  13340,          20.,   35.6832542,   7.27272749
  13341,          20.,   34.8909073,   7.27272749
  13342,          20.,   34.0985641,   7.27272749
  13343,          20.,    33.306221,   7.27272749
  13344,          20.,   32.5138741,   7.27272749
  13345,          20.,   31.7215309,   7.27272749
  13346,          20.,   30.9291859,   7.27272749
  13347,          20.,   30.1368427,   7.27272749
  13348,          20.,   29.3444977,   7.27272749
  13349,          20.,   28.5521526,   7.27272749
  13350,          20.,   27.7598095,   7.27272749
  13351,          20.,   26.9674644,   7.27272749
  13352,          20.,   26.1751194,   7.27272749
  13353,          20.,   25.3827744,   7.27272749
  13354,          20.,   24.6138077,   7.27272749
  13355,          20.,   23.8448391,   7.27272749
  13356,          20.,   23.0758724,   7.27272749
  13357,          20.,   22.3069038,   7.27272749
  13358,          20.,   21.5379353,   7.27272749
  13359,          20.,   20.7689686,   7.27272749
  13360,          20.,   49.1945763,   6.36363649
  13361,          20.,   48.3891563,   6.36363649
  13362,          20.,   47.5837326,   6.36363649
  13363,          20.,   46.7783089,   6.36363649
  13364,          20.,   45.9728851,   6.36363649
  13365,          20.,   45.1674652,   6.36363649
  13366,          20.,   44.3741646,   6.36363649
  13367,          20.,   43.5808601,   6.36363649
  13368,          20.,   42.7875595,   6.36363649
  13369,          20.,   41.9942589,   6.36363649
  13370,          20.,   41.2009583,   6.36363649
  13371,          20.,   40.4076538,   6.36363649
  13372,          20.,   39.6143532,   6.36363649
  13373,          20.,   38.8210526,   6.36363649
  13374,          20.,   38.0277519,   6.36363649
  13375,          20.,   37.2344513,   6.36363649
  13376,          20.,   36.4411469,   6.36363649
  13377,          20.,   35.6478462,   6.36363649
  13378,          20.,   34.8545456,   6.36363649
  13379,          20.,    34.061245,   6.36363649
  13380,          20.,   33.2679443,   6.36363649
  13381,          20.,   32.4746399,   6.36363649
  13382,          20.,   31.6813393,   6.36363649
  13383,          20.,   30.8880386,   6.36363649
  13384,          20.,   30.0947361,   6.36363649
  13385,          20.,   29.3014355,   6.36363649
  13386,          20.,   28.5081348,   6.36363649
  13387,          20.,   27.7148323,   6.36363649
  13388,          20.,   26.9215317,   6.36363649
  13389,          20.,   26.1282291,   6.36363649
  13390,          20.,   25.3349285,   6.36363649
  13391,          20.,   24.5727959,   6.36363649
  13392,          20.,   23.8106632,   6.36363649
  13393,          20.,   23.0485306,   6.36363649
  13394,          20.,   22.2863979,   6.36363649
  13395,          20.,   21.5242653,   6.36363649
  13396,          20.,   20.7621326,   6.36363649
  13397,          20.,   49.1905899,    5.4545455
  13398,          20.,   48.3811798,    5.4545455
  13399,          20.,   47.5717697,    5.4545455
  13400,          20.,   46.7623596,    5.4545455
  13401,          20.,   45.9529495,    5.4545455
  13402,          20.,   45.1435394,    5.4545455
  13403,          20.,   44.3492813,    5.4545455
  13404,          20.,   43.5550232,    5.4545455
  13405,          20.,   42.7607651,    5.4545455
  13406,          20.,    41.966507,    5.4545455
  13407,          20.,   41.1722488,    5.4545455
  13408,          20.,   40.3779907,    5.4545455
  13409,          20.,   39.5837326,    5.4545455
  13410,          20.,   38.7894745,    5.4545455
  13411,          20.,   37.9952164,    5.4545455
  13412,          20.,   37.2009583,    5.4545455
  13413,          20.,   36.4067001,    5.4545455
  13414,          20.,    35.612442,    5.4545455
  13415,          20.,   34.8181801,    5.4545455
  13416,          20.,    34.023922,    5.4545455
  13417,          20.,   33.2296638,    5.4545455
  13418,          20.,   32.4354057,    5.4545455
  13419,          20.,   31.6411476,    5.4545455
  13420,          20.,   30.8468895,    5.4545455
  13421,          20.,   30.0526314,    5.4545455
  13422,          20.,   29.2583733,    5.4545455
  13423,          20.,   28.4641151,    5.4545455
  13424,          20.,    27.669857,    5.4545455
  13425,          20.,   26.8755989,    5.4545455
  13426,          20.,   26.0813389,    5.4545455
  13427,          20.,   25.2870808,    5.4545455
  13428,          20.,   24.5317841,    5.4545455
  13429,          20.,   23.7764874,    5.4545455
  13430,          20.,   23.0211887,    5.4545455
  13431,          20.,    22.265892,    5.4545455
  13432,          20.,   21.5105953,    5.4545455
  13433,          20.,   20.7552967,    5.4545455
  13434,          20.,   49.1866035,    4.5454545
  13435,          20.,   48.3732071,    4.5454545
  13436,          20.,   47.5598068,    4.5454545
  13437,          20.,   46.7464104,    4.5454545
  13438,          20.,   45.9330139,    4.5454545
  13439,          20.,   45.1196175,    4.5454545
  13440,          20.,   44.3244019,    4.5454545
  13441,          20.,   43.5291862,    4.5454545
  13442,          20.,   42.7339706,    4.5454545
  13443,          20.,    41.938755,    4.5454545
  13444,          20.,   41.1435394,    4.5454545
  13445,          20.,   40.3483238,    4.5454545
  13446,          20.,   39.5531082,    4.5454545
  13447,          20.,   38.7578964,    4.5454545
  13448,          20.,   37.9626808,    4.5454545
  13449,          20.,   37.1674652,    4.5454545
  13450,          20.,   36.3722496,    4.5454545
  13451,          20.,    35.577034,    4.5454545
  13452,          20.,   34.7818184,    4.5454545
  13453,          20.,   33.9866028,    4.5454545
  13454,          20.,   33.1913872,    4.5454545
  13455,          20.,   32.3961716,    4.5454545
  13456,          20.,   31.6009579,    4.5454545
  13457,          20.,   30.8057423,    4.5454545
  13458,          20.,   30.0105267,    4.5454545
  13459,          20.,   29.2153111,    4.5454545
  13460,          20.,   28.4200954,    4.5454545
  13461,          20.,   27.6248798,    4.5454545
  13462,          20.,   26.8296642,    4.5454545
  13463,          20.,   26.0344505,    4.5454545
  13464,          20.,   25.2392349,    4.5454545
  13465,          20.,   24.4907722,    4.5454545
  13466,          20.,   23.7423096,    4.5454545
  13467,          20.,   22.9938488,    4.5454545
  13468,          20.,   22.2453861,    4.5454545
  13469,          20.,   21.4969234,    4.5454545
  13470,          20.,   20.7484627,    4.5454545
  13471,          20.,   49.1826172,   3.63636374
  13472,          20.,   48.3652306,   3.63636374
  13473,          20.,   47.5478477,   3.63636374
  13474,          20.,   46.7304611,   3.63636374
  13475,          20.,   45.9130783,   3.63636374
  13476,          20.,   45.0956955,   3.63636374
  13477,          20.,   44.2995224,   3.63636374
  13478,          20.,   43.5033493,   3.63636374
  13479,          20.,   42.7071762,   3.63636374
  13480,          20.,   41.9110031,   3.63636374
  13481,          20.,   41.1148338,   3.63636374
  13482,          20.,   40.3186607,   3.63636374
  13483,          20.,   39.5224876,   3.63636374
  13484,          20.,   38.7263145,   3.63636374
  13485,          20.,   37.9301453,   3.63636374
  13486,          20.,   37.1339722,   3.63636374
  13487,          20.,   36.3377991,   3.63636374
  13488,          20.,    35.541626,   3.63636374
  13489,          20.,   34.7454529,   3.63636374
  13490,          20.,   33.9492836,   3.63636374
  13491,          20.,   33.1531105,   3.63636374
  13492,          20.,   32.3569374,   3.63636374
  13493,          20.,   31.5607662,   3.63636374
  13494,          20.,   30.7645931,   3.63636374
  13495,          20.,   29.9684219,   3.63636374
  13496,          20.,   29.1722488,   3.63636374
  13497,          20.,   28.3760757,   3.63636374
  13498,          20.,   27.5799046,   3.63636374
  13499,          20.,   26.7837315,   3.63636374
  13500,          20.,   25.9875603,   3.63636374
  13501,          20.,   25.1913872,   3.63636374
  13502,          20.,   24.4497604,   3.63636374
  13503,          20.,   23.7081337,   3.63636374
  13504,          20.,    22.966507,   3.63636374
  13505,          20.,   22.2248802,   3.63636374
  13506,          20.,   21.4832535,   3.63636374
  13507,          20.,   20.7416267,   3.63636374
  13508,          20.,    49.178627,   2.72727275
  13509,          20.,   48.3572578,   2.72727275
  13510,          20.,   47.5358849,   2.72727275
  13511,          20.,   46.7145119,   2.72727275
  13512,          20.,   45.8931427,   2.72727275
  13513,          20.,   45.0717697,   2.72727275
  13514,          20.,   44.2746429,   2.72727275
  13515,          20.,   43.4775124,   2.72727275
  13516,          20.,   42.6803818,   2.72727275
  13517,          20.,    41.883255,   2.72727275
  13518,          20.,   41.0861244,   2.72727275
  13519,          20.,   40.2889938,   2.72727275
  13520,          20.,   39.4918671,   2.72727275
  13521,          20.,   38.6947365,   2.72727275
  13522,          20.,   37.8976059,   2.72727275
  13523,          20.,   37.1004791,   2.72727275
  13524,          20.,   36.3033485,   2.72727275
  13525,          20.,   35.5062218,   2.72727275
  13526,          20.,   34.7090912,   2.72727275
  13527,          20.,   33.9119606,   2.72727275
  13528,          20.,   33.1148338,   2.72727275
  13529,          20.,   32.3177032,   2.72727275
  13530,          20.,   31.5205746,   2.72727275
  13531,          20.,   30.7234459,   2.72727275
  13532,          20.,   29.9263153,   2.72727275
  13533,          20.,   29.1291866,   2.72727275
  13534,          20.,    28.332058,   2.72727275
  13535,          20.,   27.5349274,   2.72727275
  13536,          20.,   26.7377987,   2.72727275
  13537,          20.,     25.94067,   2.72727275
  13538,          20.,   25.1435413,   2.72727275
  13539,          20.,   24.4087486,   2.72727275
  13540,          20.,   23.6739578,   2.72727275
  13541,          20.,    22.939167,   2.72727275
  13542,          20.,   22.2043743,   2.72727275
  13543,          20.,   21.4695835,   2.72727275
  13544,          20.,   20.7347908,   2.72727275
  13545,          20.,   49.1746407,   1.81818187
  13546,          20.,   48.3492813,   1.81818187
  13547,          20.,    47.523922,   1.81818187
  13548,          20.,   46.6985664,   1.81818187
  13549,          20.,   45.8732071,   1.81818187
  13550,          20.,   45.0478477,   1.81818187
  13551,          20.,   44.2497597,   1.81818187
  13552,          20.,   43.4516754,   1.81818187
  13553,          20.,   42.6535873,   1.81818187
  13554,          20.,   41.8555031,   1.81818187
  13555,          20.,    41.057415,   1.81818187
  13556,          20.,   40.2593307,   1.81818187
  13557,          20.,   39.4612427,   1.81818187
  13558,          20.,   38.6631584,   1.81818187
  13559,          20.,   37.8650703,   1.81818187
  13560,          20.,   37.0669861,   1.81818187
  13561,          20.,    36.268898,   1.81818187
  13562,          20.,   35.4708138,   1.81818187
  13563,          20.,   34.6727257,   1.81818187
  13564,          20.,   33.8746414,   1.81818187
  13565,          20.,   33.0765533,   1.81818187
  13566,          20.,   32.2784691,   1.81818187
  13567,          20.,   31.4803829,   1.81818187
  13568,          20.,   30.6822968,   1.81818187
  13569,          20.,   29.8842106,   1.81818187
  13570,          20.,   29.0861244,   1.81818187
  13571,          20.,   28.2880383,   1.81818187
  13572,          20.,   27.4899521,   1.81818187
  13573,          20.,   26.6918659,   1.81818187
  13574,          20.,   25.8937798,   1.81818187
  13575,          20.,   25.0956936,   1.81818187
  13576,          20.,   24.3677368,   1.81818187
  13577,          20.,    23.639782,   1.81818187
  13578,          20.,   22.9118252,   1.81818187
  13579,          20.,   22.1838684,   1.81818187
  13580,          20.,   21.4559116,   1.81818187
  13581,          20.,   20.7279568,   1.81818187
  13582,          20.,   49.1706543,  0.909090936
  13583,          20.,   48.3413086,  0.909090936
  13584,          20.,   47.5119629,  0.909090936
  13585,          20.,   46.6826172,  0.909090936
  13586,          20.,   45.8532677,  0.909090936
  13587,          20.,    45.023922,  0.909090936
  13588,          20.,   44.2248802,  0.909090936
  13589,          20.,   43.4258385,  0.909090936
  13590,          20.,   42.6267929,  0.909090936
  13591,          20.,   41.8277512,  0.909090936
  13592,          20.,   41.0287094,  0.909090936
  13593,          20.,   40.2296638,  0.909090936
  13594,          20.,   39.4306221,  0.909090936
  13595,          20.,   38.6315804,  0.909090936
  13596,          20.,   37.8325348,  0.909090936
  13597,          20.,    37.033493,  0.909090936
  13598,          20.,   36.2344513,  0.909090936
  13599,          20.,   35.4354057,  0.909090936
  13600,          20.,    34.636364,  0.909090936
  13601,          20.,   33.8373222,  0.909090936
  13602,          20.,   33.0382767,  0.909090936
  13603,          20.,   32.2392349,  0.909090936
  13604,          20.,   31.4401913,  0.909090936
  13605,          20.,   30.6411476,  0.909090936
  13606,          20.,   29.8421059,  0.909090936
  13607,          20.,   29.0430622,  0.909090936
  13608,          20.,   28.2440186,  0.909090936
  13609,          20.,   27.4449768,  0.909090936
  13610,          20.,   26.6459332,  0.909090936
  13611,          20.,   25.8468895,  0.909090936
  13612,          20.,   25.0478477,  0.909090936
  13613,          20.,    24.326725,  0.909090936
  13614,          20.,   23.6056042,  0.909090936
  13615,          20.,   22.8844833,  0.909090936
  13616,          20.,   22.1633625,  0.909090936
  13617,          20.,   21.4422417,  0.909090936
  13618,          20.,   20.7211208,  0.909090936
  13619,     29.09091,          20.,     9.090909
  13620,    28.181818,          20.,     9.090909
  13621,    27.272728,          20.,     9.090909
  13622,    26.363636,          20.,     9.090909
  13623,    25.454546,          20.,     9.090909
  13624,    24.545454,          20.,     9.090909
  13625,    23.636364,          20.,     9.090909
  13626,    22.727272,          20.,     9.090909
  13627,    21.818182,          20.,     9.090909
  13628,     20.90909,          20.,     9.090909
  13629,     29.09091,          20.,   8.18181801
  13630,    28.181818,          20.,   8.18181801
  13631,    27.272728,          20.,   8.18181801
  13632,    26.363636,          20.,   8.18181801
  13633,    25.454546,          20.,   8.18181801
  13634,    24.545454,          20.,   8.18181801
  13635,    23.636364,          20.,   8.18181801
  13636,    22.727272,          20.,   8.18181801
  13637,    21.818182,          20.,   8.18181801
  13638,     20.90909,          20.,   8.18181801
  13639,     29.09091,          20.,   7.27272749
  13640,    28.181818,          20.,   7.27272749
  13641,    27.272728,          20.,   7.27272749
  13642,    26.363636,          20.,   7.27272749
  13643,    25.454546,          20.,   7.27272749
  13644,    24.545454,          20.,   7.27272749
  13645,    23.636364,          20.,   7.27272749
  13646,    22.727272,          20.,   7.27272749
  13647,    21.818182,          20.,   7.27272749
  13648,     20.90909,          20.,   7.27272749
  13649,     29.09091,          20.,   6.36363649
  13650,    28.181818,          20.,   6.36363649
  13651,    27.272728,          20.,   6.36363649
  13652,    26.363636,          20.,   6.36363649
  13653,    25.454546,          20.,   6.36363649
  13654,    24.545454,          20.,   6.36363649
  13655,    23.636364,          20.,   6.36363649
  13656,    22.727272,          20.,   6.36363649
  13657,    21.818182,          20.,   6.36363649
  13658,     20.90909,          20.,   6.36363649
  13659,     29.09091,          20.,    5.4545455
  13660,    28.181818,          20.,    5.4545455
  13661,    27.272728,          20.,    5.4545455
  13662,    26.363636,          20.,    5.4545455
  13663,    25.454546,          20.,    5.4545455
  13664,    24.545454,          20.,    5.4545455
  13665,    23.636364,          20.,    5.4545455
  13666,    22.727272,          20.,    5.4545455
  13667,    21.818182,          20.,    5.4545455
  13668,     20.90909,          20.,    5.4545455
  13669,     29.09091,          20.,    4.5454545
  13670,    28.181818,          20.,    4.5454545
  13671,    27.272728,          20.,    4.5454545
  13672,    26.363636,          20.,    4.5454545
  13673,    25.454546,          20.,    4.5454545
  13674,    24.545454,          20.,    4.5454545
  13675,    23.636364,          20.,    4.5454545
  13676,    22.727272,          20.,    4.5454545
  13677,    21.818182,          20.,    4.5454545
  13678,     20.90909,          20.,    4.5454545
  13679,     29.09091,          20.,   3.63636374
  13680,    28.181818,          20.,   3.63636374
  13681,    27.272728,          20.,   3.63636374
  13682,    26.363636,          20.,   3.63636374
  13683,    25.454546,          20.,   3.63636374
  13684,    24.545454,          20.,   3.63636374
  13685,    23.636364,          20.,   3.63636374
  13686,    22.727272,          20.,   3.63636374
  13687,    21.818182,          20.,   3.63636374
  13688,     20.90909,          20.,   3.63636374
  13689,     29.09091,          20.,   2.72727275
  13690,    28.181818,          20.,   2.72727275
  13691,    27.272728,          20.,   2.72727275
  13692,    26.363636,          20.,   2.72727275
  13693,    25.454546,          20.,   2.72727275
  13694,    24.545454,          20.,   2.72727275
  13695,    23.636364,          20.,   2.72727275
  13696,    22.727272,          20.,   2.72727275
  13697,    21.818182,          20.,   2.72727275
  13698,     20.90909,          20.,   2.72727275
  13699,     29.09091,          20.,   1.81818187
  13700,    28.181818,          20.,   1.81818187
  13701,    27.272728,          20.,   1.81818187
  13702,    26.363636,          20.,   1.81818187
  13703,    25.454546,          20.,   1.81818187
  13704,    24.545454,          20.,   1.81818187
  13705,    23.636364,          20.,   1.81818187
  13706,    22.727272,          20.,   1.81818187
  13707,    21.818182,          20.,   1.81818187
  13708,     20.90909,          20.,   1.81818187
  13709,     29.09091,          20.,  0.909090936
  13710,    28.181818,          20.,  0.909090936
  13711,    27.272728,          20.,  0.909090936
  13712,    26.363636,          20.,  0.909090936
  13713,    25.454546,          20.,  0.909090936
  13714,    24.545454,          20.,  0.909090936
  13715,    23.636364,          20.,  0.909090936
  13716,    22.727272,          20.,  0.909090936
  13717,    21.818182,          20.,  0.909090936
  13718,     20.90909,          20.,  0.909090936
  13719,    22.545454,          15.,   9.54545498
  13720,     23.09091,          15.,   9.54545498
  13721,    23.636364,          15.,   9.54545498
  13722,    24.181818,          15.,   9.54545498
  13723,    24.727272,          15.,   9.54545498
  13724,    25.272728,          15.,   9.54545498
  13725,    25.818182,          15.,   9.54545498
  13726,    26.363636,          15.,   9.54545498
  13727,     26.90909,          15.,   9.54545498
  13728,    27.454546,          15.,   9.54545498
  13729,    22.545454,          15.,     9.090909
  13730,     23.09091,          15.,     9.090909
  13731,    23.636364,          15.,     9.090909
  13732,    24.181818,          15.,     9.090909
  13733,    24.727272,          15.,     9.090909
  13734,    25.272728,          15.,     9.090909
  13735,    25.818182,          15.,     9.090909
  13736,    26.363636,          15.,     9.090909
  13737,     26.90909,          15.,     9.090909
  13738,    27.454546,          15.,     9.090909
  13739,    22.545454,          15.,   8.63636398
  13740,     23.09091,          15.,   8.63636398
  13741,    23.636364,          15.,   8.63636398
  13742,    24.181818,          15.,   8.63636398
  13743,    24.727272,          15.,   8.63636398
  13744,    25.272728,          15.,   8.63636398
  13745,    25.818182,          15.,   8.63636398
  13746,    26.363636,          15.,   8.63636398
  13747,     26.90909,          15.,   8.63636398
  13748,    27.454546,          15.,   8.63636398
  13749,    22.545454,          15.,   8.18181801
  13750,     23.09091,          15.,   8.18181801
  13751,    23.636364,          15.,   8.18181801
  13752,    24.181818,          15.,   8.18181801
  13753,    24.727272,          15.,   8.18181801
  13754,    25.272728,          15.,   8.18181801
  13755,    25.818182,          15.,   8.18181801
  13756,    26.363636,          15.,   8.18181801
  13757,     26.90909,          15.,   8.18181801
  13758,    27.454546,          15.,   8.18181801
  13759,    22.545454,          15.,   7.72727251
  13760,     23.09091,          15.,   7.72727251
  13761,    23.636364,          15.,   7.72727251
  13762,    24.181818,          15.,   7.72727251
  13763,    24.727272,          15.,   7.72727251
  13764,    25.272728,          15.,   7.72727251
  13765,    25.818182,          15.,   7.72727251
  13766,    26.363636,          15.,   7.72727251
  13767,     26.90909,          15.,   7.72727251
  13768,    27.454546,          15.,   7.72727251
  13769,    22.545454,          15.,   7.27272749
  13770,     23.09091,          15.,   7.27272749
  13771,    23.636364,          15.,   7.27272749
  13772,    24.181818,          15.,   7.27272749
  13773,    24.727272,          15.,   7.27272749
  13774,    25.272728,          15.,   7.27272749
  13775,    25.818182,          15.,   7.27272749
  13776,    26.363636,          15.,   7.27272749
  13777,     26.90909,          15.,   7.27272749
  13778,    27.454546,          15.,   7.27272749
  13779,    22.545454,          15.,   6.81818199
  13780,     23.09091,          15.,   6.81818199
  13781,    23.636364,          15.,   6.81818199
  13782,    24.181818,          15.,   6.81818199
  13783,    24.727272,          15.,   6.81818199
  13784,    25.272728,          15.,   6.81818199
  13785,    25.818182,          15.,   6.81818199
  13786,    26.363636,          15.,   6.81818199
  13787,     26.90909,          15.,   6.81818199
  13788,    27.454546,          15.,   6.81818199
  13789,    22.545454,          15.,   6.36363649
  13790,     23.09091,          15.,   6.36363649
  13791,    23.636364,          15.,   6.36363649
  13792,    24.181818,          15.,   6.36363649
  13793,    24.727272,          15.,   6.36363649
  13794,    25.272728,          15.,   6.36363649
  13795,    25.818182,          15.,   6.36363649
  13796,    26.363636,          15.,   6.36363649
  13797,     26.90909,          15.,   6.36363649
  13798,    27.454546,          15.,   6.36363649
  13799,    22.545454,          15.,     5.909091
  13800,     23.09091,          15.,     5.909091
  13801,    23.636364,          15.,     5.909091
  13802,    24.181818,          15.,     5.909091
  13803,    24.727272,          15.,     5.909091
  13804,    25.272728,          15.,     5.909091
  13805,    25.818182,          15.,     5.909091
  13806,    26.363636,          15.,     5.909091
  13807,     26.90909,          15.,     5.909091
  13808,    27.454546,          15.,     5.909091
  13809,    22.545454,          15.,    5.4545455
  13810,     23.09091,          15.,    5.4545455
  13811,    23.636364,          15.,    5.4545455
  13812,    24.181818,          15.,    5.4545455
  13813,    24.727272,          15.,    5.4545455
  13814,    25.272728,          15.,    5.4545455
  13815,    25.818182,          15.,    5.4545455
  13816,    26.363636,          15.,    5.4545455
  13817,     26.90909,          15.,    5.4545455
  13818,    27.454546,          15.,    5.4545455
  13819,     21.70117,   15.7470732,   9.53482533
  13820,    21.688055,   15.7798605,    9.0696516
  13821,   21.6749401,   15.8126478,   8.60447693
  13822,   21.6618252,   15.8454351,   8.13930225
  13823,   21.6487103,   15.8782225,   7.67412806
  13824,   21.6355953,   15.9110098,   7.20895386
  13825,   21.6224804,   15.9437971,   6.74377966
  13826,   21.6093655,   15.9765844,   6.27860498
  13827,   21.5962505,   16.0093727,   5.81343079
  13828,   21.5831356,     16.04216,   5.34825659
  13829,   21.4039459,   16.4901371,   9.50317574
  13830,   21.3793182,   16.5517025,   9.00635147
  13831,   21.3546925,   16.6132698,   8.50952721
  13832,   21.3300667,   16.6748352,   8.01270294
  13833,    21.305439,   16.7364006,   7.51587868
  13834,   21.2808132,   16.7979679,   7.01905441
  13835,   21.2561874,   16.8595333,   6.52223015
  13836,   21.2315598,   16.9210987,   6.02540588
  13837,    21.206934,    16.982666,   5.52858162
  13838,   21.1823082,   17.0442314,   5.03175735
  13839,   21.1099758,   17.2250614,   9.45129395
  13840,   21.0770931,   17.3072662,   8.90258694
  13841,   21.0442123,   17.3894711,   8.35388088
  13842,   21.0113297,   17.4716759,   7.80517483
  13843,    20.978447,   17.5538807,    7.2564683
  13844,   20.9455662,   17.6360855,   6.70776224
  13845,   20.9126835,   17.7182903,   6.15905571
  13846,   20.8798027,   17.8004951,   5.61034966
  13847,     20.84692,      17.8827,   5.06164312
  13848,   20.8140373,   17.9649048,   4.51293707
  13849,   20.8209782,   17.9475536,    9.3807478
  13850,   20.7848148,    18.037962,   8.76149559
  13851,   20.7486515,   18.1283722,   8.14224243
  13852,   20.7124863,   18.2187824,    7.5229907
  13853,   20.6763229,   18.3091927,   6.90373802
  13854,   20.6401596,   18.3996029,   6.28448582
  13855,   20.6039944,   18.4900131,   5.66523361
  13856,    20.567831,   18.5804234,   5.04598093
  13857,   20.5316658,   18.6708336,   4.42672873
  13858,   20.4955025,   18.7612419,   3.80747628
  13859,    20.538681,   18.6532974,   9.29421329
  13860,   20.5059319,   18.7351685,   8.58842754
  13861,   20.4731846,   18.8170376,   7.88264084
  13862,   20.4404373,   18.8989067,   7.17685413
  13863,   20.4076881,   18.9807777,   6.47106791
  13864,   20.3749409,   19.0626469,    5.7652812
  13865,   20.3421936,    19.144516,   5.05949497
  13866,   20.3094444,    19.226387,   4.35370874
  13867,   20.2766972,   19.3082561,   3.64792204
  13868,   20.2439499,   19.3901253,   2.94213581
  13869,   20.2646446,   19.3383884,   9.19576931
  13870,   20.2435741,   19.3910637,   8.39153957
  13871,   20.2225056,    19.443737,   7.58730888
  13872,   20.2014351,   19.4964123,   6.78307867
  13873,   20.1803665,   19.5490856,   5.97884846
  13874,    20.159296,   19.6017609,   5.17461777
  13875,   20.1382256,   19.6544342,   4.37038755
  13876,    20.117157,   19.7071095,   3.56615734
  13877,   20.0960865,   19.7597847,   2.76192689
  13878,    20.075016,    19.812458,   1.95769656
  13879,     28.29883,   15.7470732,   9.53482533
  13880,    28.311945,   15.7798605,    9.0696516
  13881,   28.3250599,   15.8126478,   8.60447693
  13882,   28.3381748,   15.8454351,   8.13930225
  13883,   28.3512897,   15.8782225,   7.67412806
  13884,   28.3644047,   15.9110098,   7.20895386
  13885,   28.3775196,   15.9437971,   6.74377918
  13886,   28.3906345,   15.9765854,   6.27860498
  13887,   28.4037495,   16.0093727,   5.81343079
  13888,   28.4168644,     16.04216,   5.34825611
  13889,   28.5960541,   16.4901371,   9.50317574
  13890,   28.6206818,   16.5517044,   9.00635147
  13891,   28.6453075,   16.6132698,   8.50952721
  13892,   28.6699333,   16.6748352,   8.01270294
  13893,    28.694561,   16.7364025,   7.51587868
  13894,   28.7191868,   16.7979679,   7.01905441
  13895,   28.7438126,   16.8595333,   6.52223015
  13896,   28.7684402,   16.9211006,   6.02540541
  13897,    28.793066,    16.982666,   5.52858114
  13898,   28.8176918,   17.0442314,   5.03175688
  13899,   28.8900242,   17.2250614,   9.45129395
  13900,   28.9229069,   17.3072662,   8.90258789
  13901,   28.9557877,   17.3894711,   8.35388088
  13902,   28.9886703,   17.4716759,   7.80517483
  13903,    29.021553,   17.5538807,   7.25646877
  13904,   29.0544338,   17.6360855,   6.70776224
  13905,   29.0873165,   17.7182903,   6.15905619
  13906,   29.1201973,   17.8004951,   5.61034966
  13907,     29.15308,      17.8827,    5.0616436
  13908,   29.1859627,   17.9649048,   4.51293707
  13909,   29.1790218,   17.9475536,    9.3807478
  13910,   29.2151852,    18.037962,   8.76149559
  13911,   29.2513485,   18.1283722,   8.14224339
  13912,   29.2875137,   18.2187824,    7.5229907
  13913,   29.3236771,   18.3091927,    6.9037385
  13914,   29.3598404,   18.3996029,   6.28448582
  13915,   29.3960056,   18.4900131,   5.66523361
  13916,    29.432169,   18.5804234,   5.04598141
  13917,   29.4683323,   18.6708317,    4.4267292
  13918,   29.5044975,   18.7612419,   3.80747676
  13919,    29.461319,   18.6532974,   9.29421329
  13920,   29.4940681,   18.7351685,   8.58842754
  13921,   29.5268154,   18.8170376,   7.88264084
  13922,   29.5595627,   18.8989067,   7.17685461
  13923,   29.5923119,   18.9807777,   6.47106838
  13924,   29.6250591,   19.0626469,   5.76528168
  13925,   29.6578064,    19.144516,   5.05949545
  13926,   29.6905537,   19.2263851,   4.35370922
  13927,   29.7233028,   19.3082561,   3.64792275
  13928,   29.7560501,   19.3901253,   2.94213629
  13929,   29.7353554,   19.3383884,   9.19576931
  13930,   29.7564259,   19.3910637,   8.39153957
  13931,   29.7774944,    19.443737,   7.58730936
  13932,   29.7985649,   19.4964123,   6.78307915
  13933,   29.8196335,   19.5490856,   5.97884893
  13934,    29.840704,   19.6017609,   5.17461872
  13935,   29.8617744,   19.6544342,   4.37038803
  13936,    29.882843,   19.7071095,   3.56615806
  13937,   29.9039135,   19.7597828,   2.76192784
  13938,    29.924984,    19.812458,   1.95769751
  13939,   22.3116875,   15.7142859,          10.
  13940,     22.90909,   15.7142859,          10.
  13941,   23.5064926,   15.7142859,          10.
  13942,   24.1038952,   15.7142859,          10.
  13943,   24.7012978,   15.7142859,          10.
  13944,   25.2987022,   15.7142859,          10.
  13945,   25.8961048,   15.7142859,          10.
  13946,   26.4935074,   15.7142859,          10.
  13947,     27.09091,   15.7142859,          10.
  13948,   27.6883125,   15.7142859,          10.
  13949,   22.0779228,   16.4285717,          10.
  13950,    22.727272,   16.4285717,          10.
  13951,   23.3766232,   16.4285717,          10.
  13952,   24.0259743,   16.4285717,          10.
  13953,   24.6753254,   16.4285717,          10.
  13954,   25.3246746,   16.4285717,          10.
  13955,   25.9740257,   16.4285717,          10.
  13956,   26.6233768,   16.4285717,          10.
  13957,    27.272728,   16.4285717,          10.
  13958,   27.9220772,   16.4285717,          10.
  13959,   21.8441563,   17.1428566,          10.
  13960,    22.545454,   17.1428566,          10.
  13961,   23.2467537,   17.1428566,          10.
  13962,   23.9480515,   17.1428566,          10.
  13963,   24.6493511,   17.1428566,          10.
  13964,   25.3506489,   17.1428566,          10.
  13965,   26.0519485,   17.1428566,          10.
  13966,   26.7532463,   17.1428566,          10.
  13967,    27.454546,   17.1428566,          10.
  13968,   28.1558437,   17.1428566,          10.
  13969,   21.6103897,   17.8571434,          10.
  13970,    22.363636,   17.8571434,          10.
  13971,   23.1168823,   17.8571434,          10.
  13972,   23.8701305,   17.8571434,          10.
  13973,   24.6233768,   17.8571434,          10.
  13974,   25.3766232,   17.8571434,          10.
  13975,   26.1298695,   17.8571434,          10.
  13976,   26.8831177,   17.8571434,          10.
  13977,    27.636364,   17.8571434,          10.
  13978,   28.3896103,   17.8571434,          10.
  13979,   21.3766232,   18.5714283,          10.
  13980,    22.181818,   18.5714283,          10.
  13981,   22.9870129,   18.5714283,          10.
  13982,   23.7922077,   18.5714283,          10.
  13983,   24.5974026,   18.5714283,          10.
  13984,   25.4025974,   18.5714283,          10.
  13985,   26.2077923,   18.5714283,          10.
  13986,   27.0129871,   18.5714283,          10.
  13987,    27.818182,   18.5714283,          10.
  13988,   28.6233768,   18.5714283,          10.
  13989,   21.1428566,   19.2857151,          10.
  13990,          22.,   19.2857151,          10.
  13991,   22.8571434,   19.2857151,          10.
  13992,   23.7142849,   19.2857151,          10.
  13993,   24.5714283,   19.2857151,          10.
  13994,   25.4285717,   19.2857151,          10.
