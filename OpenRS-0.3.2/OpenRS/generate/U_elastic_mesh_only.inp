   1995,          20.,           0.,   7.27272749
   1996,          20.,           0.,   6.36363649
   1997,          20.,           0.,    5.4545455
   1998,          20.,           0.,    4.5454545
   1999,          20.,           0.,   3.63636374
   2000,          20.,           0.,   2.72727275
   2001,          20.,           0.,   1.81818187
   2002,          20.,           0.,  0.909090936
   2003,     29.09091,           0.,          10.
   2004,    28.181818,           0.,          10.
   2005,    27.272728,           0.,          10.
   2006,    26.363636,           0.,          10.
   2007,    25.454546,           0.,          10.
   2008,    24.545454,           0.,          10.
   2009,    23.636364,           0.,          10.
   2010,    22.727272,           0.,          10.
   2011,    21.818182,           0.,          10.
   2012,     20.90909,           0.,          10.
   2013,          30.,           0.,  0.909090936
   2014,          30.,           0.,   1.81818187
   2015,          30.,           0.,   2.72727275
   2016,          30.,           0.,   3.63636374
   2017,          30.,           0.,    4.5454545
   2018,          30.,           0.,    5.4545455
   2019,          30.,           0.,   6.36363649
   2020,          30.,           0.,   7.27272749
   2021,          30.,           0.,   8.18181801
   2022,          30.,           0.,     9.090909
   2023,          30.,   9.16666698,          10.
   2024,          30.,   8.33333302,          10.
   2025,          30.,          7.5,          10.
   2026,          30.,   6.66666651,          10.
   2027,          30.,   5.83333349,          10.
   2028,          30.,           5.,          10.
   2029,          30.,   4.16666651,          10.
   2030,          30.,   3.33333325,          10.
   2031,          30.,          2.5,          10.
   2032,          30.,   1.66666663,          10.
   2033,          30.,  0.833333313,          10.
   2034,          30.,  0.833333313,           0.
   2035,          30.,   1.66666663,           0.
   2036,          30.,          2.5,           0.
   2037,          30.,   3.33333325,           0.
   2038,          30.,   4.16666651,           0.
   2039,          30.,           5.,           0.
   2040,          30.,   5.83333349,           0.
   2041,          30.,   6.66666651,           0.
   2042,          30.,          7.5,           0.
   2043,          30.,   8.33333302,           0.
   2044,          30.,   9.16666698,           0.
   2045,          20.,  0.833333313,          10.
   2046,          20.,   1.66666663,          10.
   2047,          20.,          2.5,          10.
   2048,          20.,   3.33333325,          10.
   2049,          20.,   4.16666651,          10.
   2050,          20.,           5.,          10.
   2051,          20.,   5.83333349,          10.
   2052,          20.,   6.66666651,          10.
   2053,          20.,          7.5,          10.
   2054,          20.,   8.33333302,          10.
   2055,          20.,   9.16666698,          10.
   2056,          20.,   9.16666698,           0.
   2057,          20.,   8.33333302,           0.
   2058,          20.,          7.5,           0.
   2059,          20.,   6.66666651,           0.
   2060,          20.,   5.83333349,           0.
   2061,          20.,           5.,           0.
   2062,          20.,   4.16666651,           0.
   2063,          20.,   3.33333325,           0.
   2064,          20.,          2.5,           0.
   2065,          20.,   1.66666663,           0.
   2066,          20.,  0.833333313,           0.
   2067,   21.6231689,   14.0579214,   4.91044664
   2068,    21.258131,   13.1453266,   4.64329481
   2069,   20.9169693,   12.2924232,   4.20345449
   2070,   20.6122093,   11.5305252,    3.6003809
   2071,   20.3566628,   10.8916578,   2.84982944
   2072,    20.162775,   10.4069376,   1.97579706
   2073,   20.0413742,   10.1034355,   1.01175892
   2074,        20.25,       10.625,          10.
   2075,         20.5,        11.25,          10.
   2076,        20.75,       11.875,          10.
   2077,          21.,         12.5,          10.
   2078,        21.25,       13.125,          10.
   2079,         21.5,        13.75,          10.
   2080,        21.75,       14.375,          10.
   2081,   29.9586258,   10.1034355,   1.01175678
   2082,    29.837225,   10.4069366,   1.97579563
   2083,   29.6433372,   10.8916578,    2.8498292
   2084,   29.3877907,   11.5305252,   3.60038161
   2085,   29.0830307,   12.2924242,   4.20345545
   2086,    28.741869,   13.1453285,   4.64329576
   2087,   28.3768311,   14.0579233,   4.91044712
   2088,        28.25,       14.375,          10.
   2089,         28.5,        13.75,          10.
   2090,        28.75,       13.125,          10.
   2091,          29.,         12.5,          10.
   2092,        29.25,       11.875,          10.
   2093,         29.5,        11.25,          10.
   2094,        29.75,       10.625,          10.
   2095,          30.,   9.16666698,         -10.
   2096,          30.,   8.33333302,         -10.
   2097,          30.,          7.5,         -10.
   2098,          30.,   6.66666651,         -10.
   2099,          30.,   5.83333349,         -10.
   2100,          30.,           5.,         -10.
   2101,          30.,   4.16666651,         -10.
   2102,          30.,   3.33333325,         -10.
   2103,          30.,          2.5,         -10.
   2104,          30.,   1.66666663,         -10.
   2105,          30.,  0.833333313,         -10.
   2106,     29.09091,           0.,         -10.
   2107,    28.181818,           0.,         -10.
   2108,    27.272728,           0.,         -10.
   2109,    26.363636,           0.,         -10.
   2110,    25.454546,           0.,         -10.
   2111,    24.545454,           0.,         -10.
   2112,    23.636364,           0.,         -10.
   2113,    22.727272,           0.,         -10.
   2114,    21.818182,           0.,         -10.
   2115,     20.90909,           0.,         -10.
   2116,          20.,  0.833333313,         -10.
   2117,          20.,   1.66666663,         -10.
   2118,          20.,          2.5,         -10.
   2119,          20.,   3.33333325,         -10.
   2120,          20.,   4.16666651,         -10.
   2121,          20.,           5.,         -10.
   2122,          20.,   5.83333349,         -10.
   2123,          20.,   6.66666651,         -10.
   2124,          20.,          7.5,         -10.
   2125,          20.,   8.33333302,         -10.
   2126,          20.,   9.16666698,         -10.
   2127,          20.,           0.,    -9.090909
   2128,          20.,           0.,  -8.18181801
   2129,          20.,           0.,  -7.27272749
   2130,          20.,           0.,  -6.36363649
   2131,          20.,           0.,   -5.4545455
   2132,          20.,           0.,   -4.5454545
   2133,          20.,           0.,  -3.63636374
   2134,          20.,           0.,  -2.72727275
   2135,          20.,           0.,  -1.81818187
   2136,          20.,           0., -0.909090936
   2137,          30.,           0., -0.909090936
   2138,          30.,           0.,  -1.81818187
   2139,          30.,           0.,  -2.72727275
   2140,          30.,           0.,  -3.63636374
   2141,          30.,           0.,   -4.5454545
   2142,          30.,           0.,   -5.4545455
   2143,          30.,           0.,  -6.36363649
   2144,          30.,           0.,  -7.27272749
   2145,          30.,           0.,  -8.18181801
   2146,          30.,           0.,    -9.090909
   2147,    -20.90909,           0.,         -10.
   2148,   -21.818182,           0.,         -10.
   2149,   -22.727272,           0.,         -10.
   2150,   -23.636364,           0.,         -10.
   2151,   -24.545454,           0.,         -10.
   2152,   -25.454546,           0.,         -10.
   2153,   -26.363636,           0.,         -10.
   2154,   -27.272728,           0.,         -10.
   2155,   -28.181818,           0.,         -10.
   2156,    -29.09091,           0.,         -10.
   2157,         -20.,   9.16666698,         -10.
   2158,         -20.,   8.33333302,         -10.
   2159,         -20.,          7.5,         -10.
   2160,         -20.,   6.66666651,         -10.
   2161,         -20.,   5.83333349,         -10.
   2162,         -20.,           5.,         -10.
   2163,         -20.,   4.16666651,         -10.
   2164,         -20.,   3.33333325,         -10.
   2165,         -20.,          2.5,         -10.
   2166,         -20.,   1.66666663,         -10.
   2167,         -20.,  0.833333313,         -10.
   2168,    -29.09091,          10.,         -10.
   2169,   -28.181818,          10.,         -10.
   2170,   -27.272728,          10.,         -10.
   2171,   -26.363636,          10.,         -10.
   2172,   -25.454546,          10.,         -10.
   2173,   -24.545454,          10.,         -10.
   2174,   -23.636364,          10.,         -10.
   2175,   -22.727272,          10.,         -10.
   2176,   -21.818182,          10.,         -10.
   2177,    -20.90909,          10.,         -10.
   2178,         -30.,  0.833333313,         -10.
   2179,         -30.,   1.66666663,         -10.
   2180,         -30.,          2.5,         -10.
   2181,         -30.,   3.33333325,         -10.
   2182,         -30.,   4.16666651,         -10.
   2183,         -30.,           5.,         -10.
   2184,         -30.,   5.83333349,         -10.
   2185,         -30.,   6.66666651,         -10.
   2186,         -30.,          7.5,         -10.
   2187,         -30.,   8.33333302,         -10.
   2188,         -30.,   9.16666698,         -10.
   2189,         -30.,          10., -0.909090936
   2190,         -30.,          10.,  -1.81818187
   2191,         -30.,          10.,  -2.72727275
   2192,         -30.,          10.,  -3.63636374
   2193,         -30.,          10.,   -4.5454545
   2194,         -30.,          10.,   -5.4545455
   2195,         -30.,          10.,  -6.36363649
   2196,         -30.,          10.,  -7.27272749
   2197,         -30.,          10.,  -8.18181801
   2198,         -30.,          10.,    -9.090909
   2199,         -30.,           0.,    -9.090909
   2200,         -30.,           0.,  -8.18181801
   2201,         -30.,           0.,  -7.27272749
   2202,         -30.,           0.,  -6.36363649
   2203,         -30.,           0.,   -5.4545455
   2204,         -30.,           0.,   -4.5454545
   2205,         -30.,           0.,  -3.63636374
   2206,         -30.,           0.,  -2.72727275
   2207,         -30.,           0.,  -1.81818187
   2208,         -30.,           0., -0.909090936
   2209,         -20.,          10.,    -9.090909
   2210,         -20.,          10.,  -8.18181801
   2211,         -20.,          10.,  -7.27272749
   2212,         -20.,          10.,  -6.36363649
   2213,         -20.,          10.,   -5.4545455
   2214,         -20.,          10.,   -4.5454545
   2215,         -20.,          10.,  -3.63636374
   2216,         -20.,          10.,  -2.72727275
   2217,         -20.,          10.,  -1.81818187
   2218,         -20.,          10., -0.909090936
   2219,         -20.,           0., -0.909090936
   2220,         -20.,           0.,  -1.81818187
   2221,         -20.,           0.,  -2.72727275
   2222,         -20.,           0.,  -3.63636374
   2223,         -20.,           0.,   -4.5454545
   2224,         -20.,           0.,   -5.4545455
   2225,         -20.,           0.,  -6.36363649
   2226,         -20.,           0.,  -7.27272749
   2227,         -20.,           0.,  -8.18181801
   2228,         -20.,           0.,    -9.090909
   2229,       -21.75,       14.375,         -10.
   2230,        -21.5,        13.75,         -10.
   2231,       -21.25,       13.125,         -10.
   2232,         -21.,         12.5,         -10.
   2233,       -20.75,       11.875,         -10.
   2234,        -20.5,        11.25,         -10.
   2235,       -20.25,       10.625,         -10.
   2236,       -29.75,       10.625,         -10.
   2237,        -29.5,        11.25,         -10.
   2238,       -29.25,       11.875,         -10.
   2239,         -29.,         12.5,         -10.
   2240,       -28.75,       13.125,         -10.
   2241,        -28.5,        13.75,         -10.
   2242,       -28.25,       14.375,         -10.
   2243,  -20.0413742,   10.1034355,  -1.01175892
   2244,   -20.162775,   10.4069376,  -1.97579706
   2245,  -20.3566628,   10.8916578,  -2.84982944
   2246,  -20.6122093,   11.5305252,   -3.6003809
   2247,  -20.9169693,   12.2924232,  -4.20345449
   2248,   -21.258131,   13.1453266,  -4.64329481
   2249,  -21.6231689,   14.0579214,  -4.91044664
   2250,  -28.3768311,   14.0579233,  -4.91044712
   2251,   -28.741869,   13.1453285,  -4.64329576
   2252,  -29.0830307,   12.2924242,  -4.20345545
   2253,  -29.3877907,   11.5305252,  -3.60038161
   2254,  -29.6433372,   10.8916578,   -2.8498292
   2255,   -29.837225,   10.4069366,  -1.97579563
   2256,  -29.9586258,   10.1034355,  -1.01175678
   2257,   20.9220772,   20.7142849,           0.
   2258,   21.8441563,   20.7142849,           0.
   2259,   22.7662334,   20.7142849,           0.
   2260,   23.6883125,   20.7142849,           0.
   2261,   24.6103897,   20.7142849,           0.
   2262,   25.5324669,   20.7142849,           0.
   2263,   26.4259739,   20.7142849,           0.
   2264,   27.3194809,   20.7142849,           0.
   2265,   28.2129879,   20.7142849,           0.
   2266,    29.106493,   20.7142849,           0.
   2267,   20.9350643,   21.4285717,           0.
   2268,   21.8701305,   21.4285717,           0.
   2269,   22.8051949,   21.4285717,           0.
   2270,   23.7402592,   21.4285717,           0.
   2271,   24.6753254,   21.4285717,           0.
   2272,   25.6103897,   21.4285717,           0.
   2273,   26.4883118,   21.4285717,           0.
   2274,   27.3662338,   21.4285717,           0.
   2275,   28.2441559,   21.4285717,           0.
   2276,   29.1220779,   21.4285717,           0.
   2277,   20.9480515,   22.1428566,           0.
   2278,   21.8961048,   22.1428566,           0.
   2279,   22.8441563,   22.1428566,           0.
   2280,   23.7922077,   22.1428566,           0.
   2281,   24.7402592,   22.1428566,           0.
   2282,   25.6883125,   22.1428566,           0.
   2283,   26.5506496,   22.1428566,           0.
   2284,   27.4129868,   22.1428566,           0.
   2285,   28.2753239,   22.1428566,           0.
   2286,   29.1376629,   22.1428566,           0.
   2287,   20.9610386,   22.8571434,           0.
   2288,   21.9220772,   22.8571434,           0.
   2289,   22.8831177,   22.8571434,           0.
   2290,   23.8441563,   22.8571434,           0.
   2291,   24.8051949,   22.8571434,           0.
   2292,   25.7662334,   22.8571434,           0.
   2293,   26.6129875,   22.8571434,           0.
   2294,   27.4597397,   22.8571434,           0.
   2295,   28.3064938,   22.8571434,           0.
   2296,   29.1532459,   22.8571434,           0.
   2297,   20.9740257,   23.5714283,           0.
   2298,   21.9480515,   23.5714283,           0.
   2299,   22.9220772,   23.5714283,           0.
   2300,   23.8961048,   23.5714283,           0.
   2301,   24.8701305,   23.5714283,           0.
   2302,   25.8441563,   23.5714283,           0.
   2303,   26.6753254,   23.5714283,           0.
   2304,   27.5064926,   23.5714283,           0.
   2305,   28.3376617,   23.5714283,           0.
   2306,   29.1688309,   23.5714283,           0.
   2307,   20.9870129,   24.2857151,           0.
   2308,   21.9740257,   24.2857151,           0.
   2309,   22.9610386,   24.2857151,           0.
   2310,   23.9480515,   24.2857151,           0.
   2311,   24.9350643,   24.2857151,           0.
   2312,   25.9220772,   24.2857151,           0.
   2313,   26.7376633,   24.2857151,           0.
   2314,   27.5532475,   24.2857151,           0.
   2315,   28.3688316,   24.2857151,           0.
   2316,   29.1844158,   24.2857151,           0.
   2317,          25.,   25.7999992,           0.
   2318,          25.,   26.6000004,           0.
   2319,          25.,   27.3999996,           0.
   2320,          25.,   28.2000008,           0.
   2321,          25.,          29.,           0.
   2322,          25.,   29.7999992,           0.
   2323,          25.,   30.6000004,           0.
   2324,          25.,   31.3999996,           0.
   2325,          25.,   32.2000008,           0.
   2326,          25.,          33.,           0.
   2327,          25.,   33.7999992,           0.
   2328,          25.,   34.5999985,           0.
   2329,          25.,   35.4000015,           0.
   2330,          25.,   36.2000008,           0.
   2331,          25.,          37.,           0.
   2332,          25.,   37.7999992,           0.
   2333,          25.,   38.5999985,           0.
   2334,          25.,   39.4000015,           0.
   2335,          25.,   40.2000008,           0.
   2336,          25.,          41.,           0.
   2337,          25.,   41.7999992,           0.
   2338,          25.,   42.5999985,           0.
   2339,          25.,   43.4000015,           0.
   2340,          25.,   44.2000008,           0.
   2341,          24.,   25.7999992,           0.
   2342,          24.,   26.6000004,           0.
   2343,          24.,   27.3999996,           0.
   2344,          24.,   28.2000008,           0.
   2345,          24.,          29.,           0.
   2346,          24.,   29.7999992,           0.
   2347,          24.,   30.6000004,           0.
   2348,          24.,   31.3999996,           0.
   2349,          24.,   32.2000008,           0.
   2350,          24.,          33.,           0.
   2351,          24.,   33.7999992,           0.
   2352,          24.,   34.5999985,           0.
   2353,          24.,   35.4000015,           0.
   2354,          24.,   36.2000008,           0.
   2355,          24.,          37.,           0.
   2356,          24.,   37.7999992,           0.
   2357,          24.,   38.5999985,           0.
   2358,          24.,   39.4000015,           0.
   2359,          24.,   40.2000008,           0.
   2360,          24.,          41.,           0.
   2361,          24.,   41.7999992,           0.
   2362,          24.,   42.5999985,           0.
   2363,          24.,   43.4000015,           0.
   2364,          24.,   44.2000008,           0.
   2365,          23.,   25.7999992,           0.
   2366,          23.,   26.6000004,           0.
   2367,          23.,   27.3999996,           0.
   2368,          23.,   28.2000008,           0.
   2369,          23.,          29.,           0.
   2370,          23.,   29.7999992,           0.
   2371,          23.,   30.6000004,           0.
   2372,          23.,   31.3999996,           0.
   2373,          23.,   32.2000008,           0.
   2374,          23.,          33.,           0.
   2375,          23.,   33.7999992,           0.
   2376,          23.,   34.5999985,           0.
   2377,          23.,   35.4000015,           0.
   2378,          23.,   36.2000008,           0.
   2379,          23.,          37.,           0.
   2380,          23.,   37.7999992,           0.
   2381,          23.,   38.5999985,           0.
   2382,          23.,   39.4000015,           0.
   2383,          23.,   40.2000008,           0.
   2384,          23.,          41.,           0.
   2385,          23.,   41.7999992,           0.
   2386,          23.,   42.5999985,           0.
   2387,          23.,   43.4000015,           0.
   2388,          23.,   44.2000008,           0.
   2389,          22.,   25.7999992,           0.
   2390,          22.,   26.6000004,           0.
   2391,          22.,   27.3999996,           0.
   2392,          22.,   28.2000008,           0.
   2393,          22.,          29.,           0.
   2394,          22.,   29.7999992,           0.
   2395,          22.,   30.6000004,           0.
   2396,          22.,   31.3999996,           0.
   2397,          22.,   32.2000008,           0.
   2398,          22.,          33.,           0.
   2399,          22.,   33.7999992,           0.
   2400,          22.,   34.5999985,           0.
   2401,          22.,   35.4000015,           0.
   2402,          22.,   36.2000008,           0.
   2403,          22.,          37.,           0.
   2404,          22.,   37.7999992,           0.
   2405,          22.,   38.5999985,           0.
   2406,          22.,   39.4000015,           0.
   2407,          22.,   40.2000008,           0.
   2408,          22.,          41.,           0.
   2409,          22.,   41.7999992,           0.
   2410,          22.,   42.5999985,           0.
   2411,          22.,   43.4000015,           0.
   2412,          22.,   44.2000008,           0.
   2413,          21.,   25.7999992,           0.
   2414,          21.,   26.6000004,           0.
   2415,          21.,   27.3999996,           0.
   2416,          21.,   28.2000008,           0.
   2417,          21.,          29.,           0.
   2418,          21.,   29.7999992,           0.
   2419,          21.,   30.6000004,           0.
   2420,          21.,   31.3999996,           0.
   2421,          21.,   32.2000008,           0.
   2422,          21.,          33.,           0.
   2423,          21.,   33.7999992,           0.
   2424,          21.,   34.5999985,           0.
   2425,          21.,   35.4000015,           0.
   2426,          21.,   36.2000008,           0.
   2427,          21.,          37.,           0.
   2428,          21.,   37.7999992,           0.
   2429,          21.,   38.5999985,           0.
   2430,          21.,   39.4000015,           0.
   2431,          21.,   40.2000008,           0.
   2432,          21.,          41.,           0.
   2433,          21.,   41.7999992,           0.
   2434,          21.,   42.5999985,           0.
   2435,          21.,   43.4000015,           0.
   2436,          21.,   44.2000008,           0.
   2437,   26.7999992,   44.2000008,           0.
   2438,   26.7999992,   43.4000015,           0.
   2439,   26.7999992,   42.5999985,           0.
   2440,   26.7999992,   41.7999992,           0.
   2441,   26.7999992,          41.,           0.
   2442,   26.7999992,   40.2000008,           0.
   2443,   26.7999992,   39.4000015,           0.
   2444,   26.7999992,   38.5999985,           0.
   2445,   26.7999992,   37.7999992,           0.
   2446,   26.7999992,          37.,           0.
   2447,   26.7999992,   36.2000008,           0.
   2448,   26.7999992,   35.4000015,           0.
   2449,   26.7999992,   34.5999985,           0.
   2450,   26.7999992,   33.7999992,           0.
   2451,   26.7999992,          33.,           0.
   2452,   26.7999992,   32.2000008,           0.
   2453,   26.7999992,   31.3999996,           0.
   2454,   26.7999992,   30.6000004,           0.
   2455,   26.7999992,   29.7999992,           0.
   2456,   26.7999992,          29.,           0.
   2457,   26.7999992,   28.2000008,           0.
   2458,   26.7999992,   27.3999996,           0.
   2459,   26.7999992,   26.6000004,           0.
   2460,   26.7999992,   25.7999992,           0.
   2461,   27.6000004,   44.2000008,           0.
   2462,   27.6000004,   43.4000015,           0.
   2463,   27.6000004,   42.5999985,           0.
   2464,   27.6000004,   41.7999992,           0.
   2465,   27.6000004,          41.,           0.
   2466,   27.6000004,   40.2000008,           0.
   2467,   27.6000004,   39.4000015,           0.
   2468,   27.6000004,   38.5999985,           0.
   2469,   27.6000004,   37.7999992,           0.
   2470,   27.6000004,          37.,           0.
   2471,   27.6000004,   36.2000008,           0.
   2472,   27.6000004,   35.4000015,           0.
   2473,   27.6000004,   34.5999985,           0.
   2474,   27.6000004,   33.7999992,           0.
   2475,   27.6000004,          33.,           0.
   2476,   27.6000004,   32.2000008,           0.
   2477,   27.6000004,   31.3999996,           0.
   2478,   27.6000004,   30.6000004,           0.
   2479,   27.6000004,   29.7999992,           0.
   2480,   27.6000004,          29.,           0.
   2481,   27.6000004,   28.2000008,           0.
   2482,   27.6000004,   27.3999996,           0.
   2483,   27.6000004,   26.6000004,           0.
   2484,   27.6000004,   25.7999992,           0.
   2485,   28.3999996,   44.2000008,           0.
   2486,   28.3999996,   43.4000015,           0.
   2487,   28.3999996,   42.5999985,           0.
   2488,   28.3999996,   41.7999992,           0.
   2489,   28.3999996,          41.,           0.
   2490,   28.3999996,   40.2000008,           0.
   2491,   28.3999996,   39.4000015,           0.
   2492,   28.3999996,   38.5999985,           0.
   2493,   28.3999996,   37.7999992,           0.
   2494,   28.3999996,          37.,           0.
   2495,   28.3999996,   36.2000008,           0.
   2496,   28.3999996,   35.4000015,           0.
   2497,   28.3999996,   34.5999985,           0.
   2498,   28.3999996,   33.7999992,           0.
   2499,   28.3999996,          33.,           0.
   2500,   28.3999996,   32.2000008,           0.
   2501,   28.3999996,   31.3999996,           0.
   2502,   28.3999996,   30.6000004,           0.
   2503,   28.3999996,   29.7999992,           0.
   2504,   28.3999996,          29.,           0.
   2505,   28.3999996,   28.2000008,           0.
   2506,   28.3999996,   27.3999996,           0.
   2507,   28.3999996,   26.6000004,           0.
   2508,   28.3999996,   25.7999992,           0.
   2509,   29.2000008,   44.2000008,           0.
   2510,   29.2000008,   43.4000015,           0.
   2511,   29.2000008,   42.5999985,           0.
   2512,   29.2000008,   41.7999992,           0.
   2513,   29.2000008,          41.,           0.
   2514,   29.2000008,   40.2000008,           0.
   2515,   29.2000008,   39.4000015,           0.
   2516,   29.2000008,   38.5999985,           0.
   2517,   29.2000008,   37.7999992,           0.
   2518,   29.2000008,          37.,           0.
   2519,   29.2000008,   36.2000008,           0.
   2520,   29.2000008,   35.4000015,           0.
   2521,   29.2000008,   34.5999985,           0.
   2522,   29.2000008,   33.7999992,           0.
   2523,   29.2000008,          33.,           0.
   2524,   29.2000008,   32.2000008,           0.
   2525,   29.2000008,   31.3999996,           0.
   2526,   29.2000008,   30.6000004,           0.
   2527,   29.2000008,   29.7999992,           0.
   2528,   29.2000008,          29.,           0.
   2529,   29.2000008,   28.2000008,           0.
   2530,   29.2000008,   27.3999996,           0.
   2531,   29.2000008,   26.6000004,           0.
   2532,   29.2000008,   25.7999992,           0.
   2533,    20.984848,   45.8333321,           0.
   2534,    21.969696,   45.8333321,           0.
   2535,    22.954546,   45.8333321,           0.
   2536,    23.939394,   45.8333321,           0.
   2537,    24.924242,   45.8333321,           0.
   2538,     25.90909,   45.8333321,           0.
   2539,    26.727272,   45.8333321,           0.
   2540,    27.545454,   45.8333321,           0.
   2541,    28.363636,   45.8333321,           0.
   2542,    29.181818,   45.8333321,           0.
   2543,    20.969696,   46.6666679,           0.
   2544,    21.939394,   46.6666679,           0.
   2545,     22.90909,   46.6666679,           0.
   2546,    23.878788,   46.6666679,           0.
   2547,    24.848484,   46.6666679,           0.
   2548,    25.818182,   46.6666679,           0.
   2549,   26.6545448,   46.6666679,           0.
   2550,   27.4909096,   46.6666679,           0.
   2551,   28.3272724,   46.6666679,           0.
   2552,   29.1636372,   46.6666679,           0.
   2553,    20.954546,         47.5,           0.
   2554,     21.90909,         47.5,           0.
   2555,    22.863636,         47.5,           0.
   2556,    23.818182,         47.5,           0.
   2557,    24.772728,         47.5,           0.
   2558,    25.727272,         47.5,           0.
   2559,   26.5818176,         47.5,           0.
   2560,   27.4363632,         47.5,           0.
   2561,   28.2909088,         47.5,           0.
   2562,   29.1454544,         47.5,           0.
   2563,    20.939394,   48.3333321,           0.
   2564,    21.878788,   48.3333321,           0.
   2565,    22.818182,   48.3333321,           0.
   2566,    23.757576,   48.3333321,           0.
   2567,     24.69697,   48.3333321,           0.
   2568,    25.636364,   48.3333321,           0.
   2569,   26.5090904,   48.3333321,           0.
   2570,   27.3818188,   48.3333321,           0.
   2571,   28.2545452,   48.3333321,           0.
   2572,   29.1272736,   48.3333321,           0.
   2573,    20.924242,   49.1666679,           0.
   2574,    21.848484,   49.1666679,           0.
   2575,    22.772728,   49.1666679,           0.
   2576,     23.69697,   49.1666679,           0.
   2577,    24.621212,   49.1666679,           0.
   2578,    25.545454,   49.1666679,           0.
   2579,   26.4363632,   49.1666679,           0.
   2580,   27.3272724,   49.1666679,           0.
   2581,   28.2181816,   49.1666679,           0.
   2582,   29.1090908,   49.1666679,           0.
   2583,     20.90909,   20.7894745,         -10.
   2584,    21.818182,   20.7894745,         -10.
   2585,    22.727272,   20.7894745,         -10.
   2586,    23.636364,   20.7894745,         -10.
   2587,    24.545454,   20.7894745,         -10.
   2588,    25.454546,   20.7894745,         -10.
   2589,    26.363636,   20.7894745,         -10.
   2590,    27.272728,   20.7894745,         -10.
   2591,    28.181818,   20.7894745,         -10.
   2592,     29.09091,   20.7894745,         -10.
   2593,     20.90909,   21.5789471,         -10.
   2594,    21.818182,   21.5789471,         -10.
   2595,    22.727272,   21.5789471,         -10.
   2596,    23.636364,   21.5789471,         -10.
   2597,    24.545454,   21.5789471,         -10.
   2598,    25.454546,   21.5789471,         -10.
   2599,    26.363636,   21.5789471,         -10.
   2600,    27.272728,   21.5789471,         -10.
   2601,    28.181818,   21.5789471,         -10.
   2602,     29.09091,   21.5789471,         -10.
   2603,     20.90909,   22.3684216,         -10.
   2604,    21.818182,   22.3684216,         -10.
   2605,    22.727272,   22.3684216,         -10.
   2606,    23.636364,   22.3684216,         -10.
   2607,    24.545454,   22.3684216,         -10.
   2608,    25.454546,   22.3684216,         -10.
   2609,    26.363636,   22.3684216,         -10.
   2610,    27.272728,   22.3684216,         -10.
   2611,    28.181818,   22.3684216,         -10.
   2612,     29.09091,   22.3684216,         -10.
   2613,     20.90909,   23.1578941,         -10.
   2614,    21.818182,   23.1578941,         -10.
   2615,    22.727272,   23.1578941,         -10.
   2616,    23.636364,   23.1578941,         -10.
   2617,    24.545454,   23.1578941,         -10.
   2618,    25.454546,   23.1578941,         -10.
   2619,    26.363636,   23.1578941,         -10.
   2620,    27.272728,   23.1578941,         -10.
   2621,    28.181818,   23.1578941,         -10.
   2622,     29.09091,   23.1578941,         -10.
   2623,     20.90909,   23.9473686,         -10.
   2624,    21.818182,   23.9473686,         -10.
   2625,    22.727272,   23.9473686,         -10.
   2626,    23.636364,   23.9473686,         -10.
   2627,    24.545454,   23.9473686,         -10.
   2628,    25.454546,   23.9473686,         -10.
   2629,    26.363636,   23.9473686,         -10.
   2630,    27.272728,   23.9473686,         -10.
   2631,    28.181818,   23.9473686,         -10.
   2632,     29.09091,   23.9473686,         -10.
   2633,     20.90909,   24.7368412,         -10.
   2634,    21.818182,   24.7368412,         -10.
   2635,    22.727272,   24.7368412,         -10.
   2636,    23.636364,   24.7368412,         -10.
   2637,    24.545454,   24.7368412,         -10.
   2638,    25.454546,   24.7368412,         -10.
   2639,    26.363636,   24.7368412,         -10.
   2640,    27.272728,   24.7368412,         -10.
   2641,    28.181818,   24.7368412,         -10.
   2642,     29.09091,   24.7368412,         -10.
   2643,     20.90909,   25.5263157,         -10.
   2644,    21.818182,   25.5263157,         -10.
   2645,    22.727272,   25.5263157,         -10.
   2646,    23.636364,   25.5263157,         -10.
   2647,    24.545454,   25.5263157,         -10.
   2648,    25.454546,   25.5263157,         -10.
   2649,    26.363636,   25.5263157,         -10.
   2650,    27.272728,   25.5263157,         -10.
   2651,    28.181818,   25.5263157,         -10.
   2652,     29.09091,   25.5263157,         -10.
   2653,     20.90909,   26.3157902,         -10.
   2654,    21.818182,   26.3157902,         -10.
   2655,    22.727272,   26.3157902,         -10.
   2656,    23.636364,   26.3157902,         -10.
   2657,    24.545454,   26.3157902,         -10.
   2658,    25.454546,   26.3157902,         -10.
   2659,    26.363636,   26.3157902,         -10.
   2660,    27.272728,   26.3157902,         -10.
   2661,    28.181818,   26.3157902,         -10.
   2662,     29.09091,   26.3157902,         -10.
   2663,     20.90909,   27.1052628,         -10.
   2664,    21.818182,   27.1052628,         -10.
   2665,    22.727272,   27.1052628,         -10.
   2666,    23.636364,   27.1052628,         -10.
   2667,    24.545454,   27.1052628,         -10.
   2668,    25.454546,   27.1052628,         -10.
   2669,    26.363636,   27.1052628,         -10.
   2670,    27.272728,   27.1052628,         -10.
   2671,    28.181818,   27.1052628,         -10.
   2672,     29.09091,   27.1052628,         -10.
   2673,     20.90909,   27.8947372,         -10.
   2674,    21.818182,   27.8947372,         -10.
   2675,    22.727272,   27.8947372,         -10.
   2676,    23.636364,   27.8947372,         -10.
   2677,    24.545454,   27.8947372,         -10.
   2678,    25.454546,   27.8947372,         -10.
   2679,    26.363636,   27.8947372,         -10.
   2680,    27.272728,   27.8947372,         -10.
   2681,    28.181818,   27.8947372,         -10.
   2682,     29.09091,   27.8947372,         -10.
   2683,     20.90909,   28.6842098,         -10.
   2684,    21.818182,   28.6842098,         -10.
   2685,    22.727272,   28.6842098,         -10.
   2686,    23.636364,   28.6842098,         -10.
   2687,    24.545454,   28.6842098,         -10.
   2688,    25.454546,   28.6842098,         -10.
   2689,    26.363636,   28.6842098,         -10.
   2690,    27.272728,   28.6842098,         -10.
   2691,    28.181818,   28.6842098,         -10.
   2692,     29.09091,   28.6842098,         -10.
   2693,     20.90909,   29.4736843,         -10.
   2694,    21.818182,   29.4736843,         -10.
   2695,    22.727272,   29.4736843,         -10.
   2696,    23.636364,   29.4736843,         -10.
   2697,    24.545454,   29.4736843,         -10.
   2698,    25.454546,   29.4736843,         -10.
   2699,    26.363636,   29.4736843,         -10.
   2700,    27.272728,   29.4736843,         -10.
   2701,    28.181818,   29.4736843,         -10.
   2702,     29.09091,   29.4736843,         -10.
   2703,     20.90909,   30.2631588,         -10.
   2704,    21.818182,   30.2631588,         -10.
   2705,    22.727272,   30.2631588,         -10.
   2706,    23.636364,   30.2631588,         -10.
   2707,    24.545454,   30.2631588,         -10.
   2708,    25.454546,   30.2631588,         -10.
   2709,    26.363636,   30.2631588,         -10.
   2710,    27.272728,   30.2631588,         -10.
   2711,    28.181818,   30.2631588,         -10.
   2712,     29.09091,   30.2631588,         -10.
   2713,     20.90909,   31.0526314,         -10.
   2714,    21.818182,   31.0526314,         -10.
   2715,    22.727272,   31.0526314,         -10.
   2716,    23.636364,   31.0526314,         -10.
   2717,    24.545454,   31.0526314,         -10.
   2718,    25.454546,   31.0526314,         -10.
   2719,    26.363636,   31.0526314,         -10.
   2720,    27.272728,   31.0526314,         -10.
   2721,    28.181818,   31.0526314,         -10.
   2722,     29.09091,   31.0526314,         -10.
   2723,     20.90909,   31.8421059,         -10.
   2724,    21.818182,   31.8421059,         -10.
   2725,    22.727272,   31.8421059,         -10.
   2726,    23.636364,   31.8421059,         -10.
   2727,    24.545454,   31.8421059,         -10.
   2728,    25.454546,   31.8421059,         -10.
   2729,    26.363636,   31.8421059,         -10.
   2730,    27.272728,   31.8421059,         -10.
   2731,    28.181818,   31.8421059,         -10.
   2732,     29.09091,   31.8421059,         -10.
   2733,     20.90909,   32.6315804,         -10.
   2734,    21.818182,   32.6315804,         -10.
   2735,    22.727272,   32.6315804,         -10.
   2736,    23.636364,   32.6315804,         -10.
   2737,    24.545454,   32.6315804,         -10.
   2738,    25.454546,   32.6315804,         -10.
   2739,    26.363636,   32.6315804,         -10.
   2740,    27.272728,   32.6315804,         -10.
   2741,    28.181818,   32.6315804,         -10.
   2742,     29.09091,   32.6315804,         -10.
   2743,     20.90909,    33.421051,         -10.
   2744,    21.818182,    33.421051,         -10.
   2745,    22.727272,    33.421051,         -10.
   2746,    23.636364,    33.421051,         -10.
   2747,    24.545454,    33.421051,         -10.
   2748,    25.454546,    33.421051,         -10.
   2749,    26.363636,    33.421051,         -10.
   2750,    27.272728,    33.421051,         -10.
   2751,    28.181818,    33.421051,         -10.
   2752,     29.09091,    33.421051,         -10.
   2753,     20.90909,   34.2105255,         -10.
   2754,    21.818182,   34.2105255,         -10.
   2755,    22.727272,   34.2105255,         -10.
   2756,    23.636364,   34.2105255,         -10.
   2757,    24.545454,   34.2105255,         -10.
   2758,    25.454546,   34.2105255,         -10.
   2759,    26.363636,   34.2105255,         -10.
   2760,    27.272728,   34.2105255,         -10.
   2761,    28.181818,   34.2105255,         -10.
   2762,     29.09091,   34.2105255,         -10.
   2763,     20.90909,          35.,         -10.
   2764,    21.818182,          35.,         -10.
   2765,    22.727272,          35.,         -10.
   2766,    23.636364,          35.,         -10.
   2767,    24.545454,          35.,         -10.
   2768,    25.454546,          35.,         -10.
   2769,    26.363636,          35.,         -10.
   2770,    27.272728,          35.,         -10.
   2771,    28.181818,          35.,         -10.
   2772,     29.09091,          35.,         -10.
   2773,     20.90909,   35.7894745,         -10.
   2774,    21.818182,   35.7894745,         -10.
   2775,    22.727272,   35.7894745,         -10.
   2776,    23.636364,   35.7894745,         -10.
   2777,    24.545454,   35.7894745,         -10.
   2778,    25.454546,   35.7894745,         -10.
   2779,    26.363636,   35.7894745,         -10.
   2780,    27.272728,   35.7894745,         -10.
   2781,    28.181818,   35.7894745,         -10.
   2782,     29.09091,   35.7894745,         -10.
   2783,     20.90909,    36.578949,         -10.
   2784,    21.818182,    36.578949,         -10.
   2785,    22.727272,    36.578949,         -10.
   2786,    23.636364,    36.578949,         -10.
   2787,    24.545454,    36.578949,         -10.
   2788,    25.454546,    36.578949,         -10.
   2789,    26.363636,    36.578949,         -10.
   2790,    27.272728,    36.578949,         -10.
   2791,    28.181818,    36.578949,         -10.
   2792,     29.09091,    36.578949,         -10.
   2793,     20.90909,   37.3684196,         -10.
   2794,    21.818182,   37.3684196,         -10.
   2795,    22.727272,   37.3684196,         -10.
   2796,    23.636364,   37.3684196,         -10.
   2797,    24.545454,   37.3684196,         -10.
   2798,    25.454546,   37.3684196,         -10.
   2799,    26.363636,   37.3684196,         -10.
   2800,    27.272728,   37.3684196,         -10.
   2801,    28.181818,   37.3684196,         -10.
   2802,     29.09091,   37.3684196,         -10.
   2803,     20.90909,   38.1578941,         -10.
   2804,    21.818182,   38.1578941,         -10.
   2805,    22.727272,   38.1578941,         -10.
   2806,    23.636364,   38.1578941,         -10.
   2807,    24.545454,   38.1578941,         -10.
   2808,    25.454546,   38.1578941,         -10.
   2809,    26.363636,   38.1578941,         -10.
   2810,    27.272728,   38.1578941,         -10.
   2811,    28.181818,   38.1578941,         -10.
   2812,     29.09091,   38.1578941,         -10.
   2813,     20.90909,   38.9473686,         -10.
   2814,    21.818182,   38.9473686,         -10.
   2815,    22.727272,   38.9473686,         -10.
   2816,    23.636364,   38.9473686,         -10.
   2817,    24.545454,   38.9473686,         -10.
   2818,    25.454546,   38.9473686,         -10.
   2819,    26.363636,   38.9473686,         -10.
   2820,    27.272728,   38.9473686,         -10.
   2821,    28.181818,   38.9473686,         -10.
   2822,     29.09091,   38.9473686,         -10.
   2823,     20.90909,   39.7368431,         -10.
   2824,    21.818182,   39.7368431,         -10.
   2825,    22.727272,   39.7368431,         -10.
   2826,    23.636364,   39.7368431,         -10.
   2827,    24.545454,   39.7368431,         -10.
   2828,    25.454546,   39.7368431,         -10.
   2829,    26.363636,   39.7368431,         -10.
   2830,    27.272728,   39.7368431,         -10.
   2831,    28.181818,   39.7368431,         -10.
   2832,     29.09091,   39.7368431,         -10.
   2833,     20.90909,   40.5263176,         -10.
   2834,    21.818182,   40.5263176,         -10.
   2835,    22.727272,   40.5263176,         -10.
   2836,    23.636364,   40.5263176,         -10.
   2837,    24.545454,   40.5263176,         -10.
   2838,    25.454546,   40.5263176,         -10.
   2839,    26.363636,   40.5263176,         -10.
   2840,    27.272728,   40.5263176,         -10.
   2841,    28.181818,   40.5263176,         -10.
   2842,     29.09091,   40.5263176,         -10.
   2843,     20.90909,   41.3157883,         -10.
   2844,    21.818182,   41.3157883,         -10.
   2845,    22.727272,   41.3157883,         -10.
   2846,    23.636364,   41.3157883,         -10.
   2847,    24.545454,   41.3157883,         -10.
   2848,    25.454546,   41.3157883,         -10.
   2849,    26.363636,   41.3157883,         -10.
   2850,    27.272728,   41.3157883,         -10.
   2851,    28.181818,   41.3157883,         -10.
   2852,     29.09091,   41.3157883,         -10.
   2853,     20.90909,   42.1052628,         -10.
   2854,    21.818182,   42.1052628,         -10.
   2855,    22.727272,   42.1052628,         -10.
   2856,    23.636364,   42.1052628,         -10.
   2857,    24.545454,   42.1052628,         -10.
   2858,    25.454546,   42.1052628,         -10.
   2859,    26.363636,   42.1052628,         -10.
   2860,    27.272728,   42.1052628,         -10.
   2861,    28.181818,   42.1052628,         -10.
   2862,     29.09091,   42.1052628,         -10.
   2863,     20.90909,   42.8947372,         -10.
   2864,    21.818182,   42.8947372,         -10.
   2865,    22.727272,   42.8947372,         -10.
   2866,    23.636364,   42.8947372,         -10.
   2867,    24.545454,   42.8947372,         -10.
   2868,    25.454546,   42.8947372,         -10.
   2869,    26.363636,   42.8947372,         -10.
   2870,    27.272728,   42.8947372,         -10.
   2871,    28.181818,   42.8947372,         -10.
   2872,     29.09091,   42.8947372,         -10.
   2873,     20.90909,   43.6842117,         -10.
   2874,    21.818182,   43.6842117,         -10.
   2875,    22.727272,   43.6842117,         -10.
   2876,    23.636364,   43.6842117,         -10.
   2877,    24.545454,   43.6842117,         -10.
   2878,    25.454546,   43.6842117,         -10.
   2879,    26.363636,   43.6842117,         -10.
   2880,    27.272728,   43.6842117,         -10.
   2881,    28.181818,   43.6842117,         -10.
   2882,     29.09091,   43.6842117,         -10.
   2883,     20.90909,   44.4736824,         -10.
   2884,    21.818182,   44.4736824,         -10.
   2885,    22.727272,   44.4736824,         -10.
   2886,    23.636364,   44.4736824,         -10.
   2887,    24.545454,   44.4736824,         -10.
   2888,    25.454546,   44.4736824,         -10.
   2889,    26.363636,   44.4736824,         -10.
   2890,    27.272728,   44.4736824,         -10.
   2891,    28.181818,   44.4736824,         -10.
   2892,     29.09091,   44.4736824,         -10.
   2893,     20.90909,   45.2631569,         -10.
   2894,    21.818182,   45.2631569,         -10.
   2895,    22.727272,   45.2631569,         -10.
   2896,    23.636364,   45.2631569,         -10.
   2897,    24.545454,   45.2631569,         -10.
   2898,    25.454546,   45.2631569,         -10.
   2899,    26.363636,   45.2631569,         -10.
   2900,    27.272728,   45.2631569,         -10.
   2901,    28.181818,   45.2631569,         -10.
   2902,     29.09091,   45.2631569,         -10.
   2903,     20.90909,   46.0526314,         -10.
   2904,    21.818182,   46.0526314,         -10.
   2905,    22.727272,   46.0526314,         -10.
   2906,    23.636364,   46.0526314,         -10.
   2907,    24.545454,   46.0526314,         -10.
   2908,    25.454546,   46.0526314,         -10.
   2909,    26.363636,   46.0526314,         -10.
   2910,    27.272728,   46.0526314,         -10.
   2911,    28.181818,   46.0526314,         -10.
   2912,     29.09091,   46.0526314,         -10.
   2913,     20.90909,   46.8421059,         -10.
   2914,    21.818182,   46.8421059,         -10.
   2915,    22.727272,   46.8421059,         -10.
   2916,    23.636364,   46.8421059,         -10.
   2917,    24.545454,   46.8421059,         -10.
   2918,    25.454546,   46.8421059,         -10.
   2919,    26.363636,   46.8421059,         -10.
   2920,    27.272728,   46.8421059,         -10.
   2921,    28.181818,   46.8421059,         -10.
   2922,     29.09091,   46.8421059,         -10.
   2923,     20.90909,   47.6315804,         -10.
   2924,    21.818182,   47.6315804,         -10.
   2925,    22.727272,   47.6315804,         -10.
   2926,    23.636364,   47.6315804,         -10.
   2927,    24.545454,   47.6315804,         -10.
   2928,    25.454546,   47.6315804,         -10.
   2929,    26.363636,   47.6315804,         -10.
   2930,    27.272728,   47.6315804,         -10.
   2931,    28.181818,   47.6315804,         -10.
   2932,     29.09091,   47.6315804,         -10.
   2933,     20.90909,    48.421051,         -10.
   2934,    21.818182,    48.421051,         -10.
   2935,    22.727272,    48.421051,         -10.
   2936,    23.636364,    48.421051,         -10.
   2937,    24.545454,    48.421051,         -10.
   2938,    25.454546,    48.421051,         -10.
   2939,    26.363636,    48.421051,         -10.
   2940,    27.272728,    48.421051,         -10.
   2941,    28.181818,    48.421051,         -10.
   2942,     29.09091,    48.421051,         -10.
   2943,     20.90909,   49.2105255,         -10.
   2944,    21.818182,   49.2105255,         -10.
   2945,    22.727272,   49.2105255,         -10.
   2946,    23.636364,   49.2105255,         -10.
   2947,    24.545454,   49.2105255,         -10.
   2948,    25.454546,   49.2105255,         -10.
   2949,    26.363636,   49.2105255,         -10.
   2950,    27.272728,   49.2105255,         -10.
   2951,    28.181818,   49.2105255,         -10.
   2952,     29.09091,   49.2105255,         -10.
   2953,          20.,   20.7211208, -0.909090936
   2954,          20.,   21.4422417, -0.909090936
   2955,          20.,   22.1633625, -0.909090936
   2956,          20.,   22.8844833, -0.909090936
   2957,          20.,   23.6056042, -0.909090936
   2958,          20.,    24.326725, -0.909090936
   2959,          20.,   25.0478477, -0.909090936
   2960,          20.,   25.8468895, -0.909090936
   2961,          20.,   26.6459332, -0.909090936
   2962,          20.,   27.4449768, -0.909090936
   2963,          20.,   28.2440186, -0.909090936
   2964,          20.,   29.0430622, -0.909090936
   2965,          20.,   29.8421059, -0.909090936
   2966,          20.,   30.6411476, -0.909090936
   2967,          20.,   31.4401913, -0.909090936
   2968,          20.,   32.2392349, -0.909090936
   2969,          20.,   33.0382767, -0.909090936
   2970,          20.,   33.8373222, -0.909090936
   2971,          20.,    34.636364, -0.909090936
   2972,          20.,   35.4354057, -0.909090936
   2973,          20.,   36.2344513, -0.909090936
   2974,          20.,    37.033493, -0.909090936
   2975,          20.,   37.8325348, -0.909090936
   2976,          20.,   38.6315804, -0.909090936
   2977,          20.,   39.4306221, -0.909090936
   2978,          20.,   40.2296638, -0.909090936
   2979,          20.,   41.0287094, -0.909090936
   2980,          20.,   41.8277512, -0.909090936
   2981,          20.,   42.6267929, -0.909090936
   2982,          20.,   43.4258385, -0.909090936
   2983,          20.,   44.2248802, -0.909090936
   2984,          20.,    45.023922, -0.909090936
   2985,          20.,   45.8532677, -0.909090936
   2986,          20.,   46.6826172, -0.909090936
   2987,          20.,   47.5119629, -0.909090936
   2988,          20.,   48.3413086, -0.909090936
   2989,          20.,   49.1706543, -0.909090936
   2990,          20.,   20.7279568,  -1.81818187
   2991,          20.,   21.4559116,  -1.81818187
   2992,          20.,   22.1838684,  -1.81818187
   2993,          20.,   22.9118252,  -1.81818187
   2994,          20.,    23.639782,  -1.81818187
   2995,          20.,   24.3677368,  -1.81818187
   2996,          20.,   25.0956936,  -1.81818187
   2997,          20.,   25.8937798,  -1.81818187
   2998,          20.,   26.6918659,  -1.81818187
   2999,          20.,   27.4899521,  -1.81818187
   3000,          20.,   28.2880383,  -1.81818187
   3001,          20.,   29.0861244,  -1.81818187
   3002,          20.,   29.8842106,  -1.81818187
   3003,          20.,   30.6822968,  -1.81818187
   3004,          20.,   31.4803829,  -1.81818187
   3005,          20.,   32.2784691,  -1.81818187
   3006,          20.,   33.0765533,  -1.81818187
   3007,          20.,   33.8746414,  -1.81818187
   3008,          20.,   34.6727257,  -1.81818187
   3009,          20.,   35.4708138,  -1.81818187
   3010,          20.,    36.268898,  -1.81818187
   3011,          20.,   37.0669861,  -1.81818187
   3012,          20.,   37.8650703,  -1.81818187
   3013,          20.,   38.6631584,  -1.81818187
   3014,          20.,   39.4612427,  -1.81818187
   3015,          20.,   40.2593307,  -1.81818187
   3016,          20.,    41.057415,  -1.81818187
   3017,          20.,   41.8555031,  -1.81818187
   3018,          20.,   42.6535873,  -1.81818187
   3019,          20.,   43.4516754,  -1.81818187
   3020,          20.,   44.2497597,  -1.81818187
   3021,          20.,   45.0478477,  -1.81818187
   3022,          20.,   45.8732071,  -1.81818187
   3023,          20.,   46.6985664,  -1.81818187
   3024,          20.,    47.523922,  -1.81818187
   3025,          20.,   48.3492813,  -1.81818187
   3026,          20.,   49.1746407,  -1.81818187
   3027,          20.,   20.7347908,  -2.72727275
   3028,          20.,   21.4695835,  -2.72727275
   3029,          20.,   22.2043743,  -2.72727275
   3030,          20.,    22.939167,  -2.72727275
   3031,          20.,   23.6739578,  -2.72727275
   3032,          20.,   24.4087486,  -2.72727275
   3033,          20.,   25.1435413,  -2.72727275
   3034,          20.,     25.94067,  -2.72727275
   3035,          20.,   26.7377987,  -2.72727275
   3036,          20.,   27.5349274,  -2.72727275
   3037,          20.,    28.332058,  -2.72727275
   3038,          20.,   29.1291866,  -2.72727275
   3039,          20.,   29.9263153,  -2.72727275
   3040,          20.,   30.7234459,  -2.72727275
   3041,          20.,   31.5205746,  -2.72727275
   3042,          20.,   32.3177032,  -2.72727275
   3043,          20.,   33.1148338,  -2.72727275
   3044,          20.,   33.9119606,  -2.72727275
   3045,          20.,   34.7090912,  -2.72727275
   3046,          20.,   35.5062218,  -2.72727275
   3047,          20.,   36.3033485,  -2.72727275
   3048,          20.,   37.1004791,  -2.72727275
   3049,          20.,   37.8976059,  -2.72727275
   3050,          20.,   38.6947365,  -2.72727275
   3051,          20.,   39.4918671,  -2.72727275
   3052,          20.,   40.2889938,  -2.72727275
   3053,          20.,   41.0861244,  -2.72727275
   3054,          20.,    41.883255,  -2.72727275
   3055,          20.,   42.6803818,  -2.72727275
   3056,          20.,   43.4775124,  -2.72727275
   3057,          20.,   44.2746429,  -2.72727275
   3058,          20.,   45.0717697,  -2.72727275
   3059,          20.,   45.8931427,  -2.72727275
   3060,          20.,   46.7145119,  -2.72727275
   3061,          20.,   47.5358849,  -2.72727275
   3062,          20.,   48.3572578,  -2.72727275
   3063,          20.,    49.178627,  -2.72727275
   3064,          20.,   20.7416267,  -3.63636374
   3065,          20.,   21.4832535,  -3.63636374
   3066,          20.,   22.2248802,  -3.63636374
   3067,          20.,    22.966507,  -3.63636374
   3068,          20.,   23.7081337,  -3.63636374
   3069,          20.,   24.4497604,  -3.63636374
   3070,          20.,   25.1913872,  -3.63636374
   3071,          20.,   25.9875603,  -3.63636374
   3072,          20.,   26.7837315,  -3.63636374
   3073,          20.,   27.5799046,  -3.63636374
   3074,          20.,   28.3760757,  -3.63636374
   3075,          20.,   29.1722488,  -3.63636374
   3076,          20.,   29.9684219,  -3.63636374
   3077,          20.,   30.7645931,  -3.63636374
   3078,          20.,   31.5607662,  -3.63636374
   3079,          20.,   32.3569374,  -3.63636374
   3080,          20.,   33.1531105,  -3.63636374
   3081,          20.,   33.9492836,  -3.63636374
   3082,          20.,   34.7454529,  -3.63636374
   3083,          20.,    35.541626,  -3.63636374
   3084,          20.,   36.3377991,  -3.63636374
   3085,          20.,   37.1339722,  -3.63636374
   3086,          20.,   37.9301453,  -3.63636374
   3087,          20.,   38.7263145,  -3.63636374
   3088,          20.,   39.5224876,  -3.63636374
   3089,          20.,   40.3186607,  -3.63636374
   3090,          20.,   41.1148338,  -3.63636374
   3091,          20.,   41.9110031,  -3.63636374
   3092,          20.,   42.7071762,  -3.63636374
   3093,          20.,   43.5033493,  -3.63636374
   3094,          20.,   44.2995224,  -3.63636374
   3095,          20.,   45.0956955,  -3.63636374
   3096,          20.,   45.9130783,  -3.63636374
   3097,          20.,   46.7304611,  -3.63636374
   3098,          20.,   47.5478477,  -3.63636374
   3099,          20.,   48.3652306,  -3.63636374
   3100,          20.,   49.1826172,  -3.63636374
   3101,          20.,   20.7484627,   -4.5454545
   3102,          20.,   21.4969234,   -4.5454545
   3103,          20.,   22.2453861,   -4.5454545
   3104,          20.,   22.9938488,   -4.5454545
   3105,          20.,   23.7423096,   -4.5454545
   3106,          20.,   24.4907722,   -4.5454545
   3107,          20.,   25.2392349,   -4.5454545
   3108,          20.,   26.0344505,   -4.5454545
   3109,          20.,   26.8296642,   -4.5454545
   3110,          20.,   27.6248798,   -4.5454545
   3111,          20.,   28.4200954,   -4.5454545
   3112,          20.,   29.2153111,   -4.5454545
   3113,          20.,   30.0105267,   -4.5454545
   3114,          20.,   30.8057423,   -4.5454545
   3115,          20.,   31.6009579,   -4.5454545
   3116,          20.,   32.3961716,   -4.5454545
   3117,          20.,   33.1913872,   -4.5454545
   3118,          20.,   33.9866028,   -4.5454545
   3119,          20.,   34.7818184,   -4.5454545
   3120,          20.,    35.577034,   -4.5454545
   3121,          20.,   36.3722496,   -4.5454545
   3122,          20.,   37.1674652,   -4.5454545
   3123,          20.,   37.9626808,   -4.5454545
   3124,          20.,   38.7578964,   -4.5454545
   3125,          20.,   39.5531082,   -4.5454545
   3126,          20.,   40.3483238,   -4.5454545
   3127,          20.,   41.1435394,   -4.5454545
   3128,          20.,    41.938755,   -4.5454545
   3129,          20.,   42.7339706,   -4.5454545
   3130,          20.,   43.5291862,   -4.5454545
   3131,          20.,   44.3244019,   -4.5454545
   3132,          20.,   45.1196175,   -4.5454545
   3133,          20.,   45.9330139,   -4.5454545
   3134,          20.,   46.7464104,   -4.5454545
   3135,          20.,   47.5598068,   -4.5454545
   3136,          20.,   48.3732071,   -4.5454545
   3137,          20.,   49.1866035,   -4.5454545
   3138,          20.,   20.7552967,   -5.4545455
   3139,          20.,   21.5105953,   -5.4545455
   3140,          20.,    22.265892,   -5.4545455
   3141,          20.,   23.0211887,   -5.4545455
   3142,          20.,   23.7764874,   -5.4545455
   3143,          20.,   24.5317841,   -5.4545455
   3144,          20.,   25.2870808,   -5.4545455
   3145,          20.,   26.0813389,   -5.4545455
   3146,          20.,   26.8755989,   -5.4545455
   3147,          20.,    27.669857,   -5.4545455
   3148,          20.,   28.4641151,   -5.4545455
   3149,          20.,   29.2583733,   -5.4545455
   3150,          20.,   30.0526314,   -5.4545455
   3151,          20.,   30.8468895,   -5.4545455
   3152,          20.,   31.6411476,   -5.4545455
   3153,          20.,   32.4354057,   -5.4545455
   3154,          20.,   33.2296638,   -5.4545455
   3155,          20.,    34.023922,   -5.4545455
   3156,          20.,   34.8181801,   -5.4545455
   3157,          20.,    35.612442,   -5.4545455
   3158,          20.,   36.4067001,   -5.4545455
   3159,          20.,   37.2009583,   -5.4545455
   3160,          20.,   37.9952164,   -5.4545455
   3161,          20.,   38.7894745,   -5.4545455
   3162,          20.,   39.5837326,   -5.4545455
   3163,          20.,   40.3779907,   -5.4545455
   3164,          20.,   41.1722488,   -5.4545455
   3165,          20.,    41.966507,   -5.4545455
   3166,          20.,   42.7607651,   -5.4545455
   3167,          20.,   43.5550232,   -5.4545455
   3168,          20.,   44.3492813,   -5.4545455
   3169,          20.,   45.1435394,   -5.4545455
   3170,          20.,   45.9529495,   -5.4545455
   3171,          20.,   46.7623596,   -5.4545455
   3172,          20.,   47.5717697,   -5.4545455
   3173,          20.,   48.3811798,   -5.4545455
   3174,          20.,   49.1905899,   -5.4545455
   3175,          20.,   20.7621326,  -6.36363649
   3176,          20.,   21.5242653,  -6.36363649
   3177,          20.,   22.2863979,  -6.36363649
   3178,          20.,   23.0485306,  -6.36363649
   3179,          20.,   23.8106632,  -6.36363649
   3180,          20.,   24.5727959,  -6.36363649
   3181,          20.,   25.3349285,  -6.36363649
   3182,          20.,   26.1282291,  -6.36363649
   3183,          20.,   26.9215317,  -6.36363649
   3184,          20.,   27.7148323,  -6.36363649
   3185,          20.,   28.5081348,  -6.36363649
   3186,          20.,   29.3014355,  -6.36363649
   3187,          20.,   30.0947361,  -6.36363649
   3188,          20.,   30.8880386,  -6.36363649
   3189,          20.,   31.6813393,  -6.36363649
   3190,          20.,   32.4746399,  -6.36363649
   3191,          20.,   33.2679443,  -6.36363649
   3192,          20.,    34.061245,  -6.36363649
   3193,          20.,   34.8545456,  -6.36363649
   3194,          20.,   35.6478462,  -6.36363649
   3195,          20.,   36.4411469,  -6.36363649
   3196,          20.,   37.2344513,  -6.36363649
   3197,          20.,   38.0277519,  -6.36363649
   3198,          20.,   38.8210526,  -6.36363649
   3199,          20.,   39.6143532,  -6.36363649
   3200,          20.,   40.4076538,  -6.36363649
   3201,          20.,   41.2009583,  -6.36363649
   3202,          20.,   41.9942589,  -6.36363649
   3203,          20.,   42.7875595,  -6.36363649
   3204,          20.,   43.5808601,  -6.36363649
   3205,          20.,   44.3741646,  -6.36363649
   3206,          20.,   45.1674652,  -6.36363649
   3207,          20.,   45.9728851,  -6.36363649
   3208,          20.,   46.7783089,  -6.36363649
   3209,          20.,   47.5837326,  -6.36363649
   3210,          20.,   48.3891563,  -6.36363649
   3211,          20.,   49.1945763,  -6.36363649
   3212,          20.,   20.7689686,  -7.27272749
   3213,          20.,   21.5379353,  -7.27272749
   3214,          20.,   22.3069038,  -7.27272749
   3215,          20.,   23.0758724,  -7.27272749
   3216,          20.,   23.8448391,  -7.27272749
   3217,          20.,   24.6138077,  -7.27272749
   3218,          20.,   25.3827744,  -7.27272749
   3219,          20.,   26.1751194,  -7.27272749
   3220,          20.,   26.9674644,  -7.27272749
   3221,          20.,   27.7598095,  -7.27272749
   3222,          20.,   28.5521526,  -7.27272749
   3223,          20.,   29.3444977,  -7.27272749
   3224,          20.,   30.1368427,  -7.27272749
   3225,          20.,   30.9291859,  -7.27272749
   3226,          20.,   31.7215309,  -7.27272749
   3227,          20.,   32.5138741,  -7.27272749
   3228,          20.,    33.306221,  -7.27272749
   3229,          20.,   34.0985641,  -7.27272749
   3230,          20.,   34.8909073,  -7.27272749
   3231,          20.,   35.6832542,  -7.27272749
   3232,          20.,   36.4755974,  -7.27272749
   3233,          20.,   37.2679443,  -7.27272749
   3234,          20.,   38.0602875,  -7.27272749
   3235,          20.,   38.8526306,  -7.27272749
   3236,          20.,   39.6449776,  -7.27272749
   3237,          20.,   40.4373207,  -7.27272749
   3238,          20.,   41.2296638,  -7.27272749
   3239,          20.,   42.0220108,  -7.27272749
   3240,          20.,   42.8143539,  -7.27272749
   3241,          20.,   43.6066971,  -7.27272749
   3242,          20.,    44.399044,  -7.27272749
   3243,          20.,   45.1913872,  -7.27272749
   3244,          20.,   45.9928246,  -7.27272749
   3245,          20.,   46.7942581,  -7.27272749
   3246,          20.,   47.5956955,  -7.27272749
   3247,          20.,   48.3971291,  -7.27272749
   3248,          20.,   49.1985664,  -7.27272749
   3249,          20.,   20.7758026,  -8.18181801
   3250,          20.,   21.5516071,  -8.18181801
   3251,          20.,   22.3274097,  -8.18181801
   3252,          20.,   23.1032124,  -8.18181801
   3253,          20.,    23.879015,  -8.18181801
   3254,          20.,   24.6548195,  -8.18181801
   3255,          20.,   25.4306221,  -8.18181801
   3256,          20.,   26.2220097,  -8.18181801
   3257,          20.,   27.0133972,  -8.18181801
   3258,          20.,   27.8047848,  -8.18181801
   3259,          20.,   28.5961723,  -8.18181801
   3260,          20.,   29.3875599,  -8.18181801
   3261,          20.,   30.1789474,  -8.18181801
   3262,          20.,    30.970335,  -8.18181801
   3263,          20.,   31.7617226,  -8.18181801
   3264,          20.,   32.5531082,  -8.18181801
   3265,          20.,   33.3444977,  -8.18181801
   3266,          20.,   34.1358833,  -8.18181801
   3267,          20.,   34.9272728,  -8.18181801
   3268,          20.,   35.7186584,  -8.18181801
   3269,          20.,   36.5100479,  -8.18181801
   3270,          20.,   37.3014336,  -8.18181801
   3271,          20.,    38.092823,  -8.18181801
   3272,          20.,   38.8842087,  -8.18181801
   3273,          20.,   39.6755981,  -8.18181801
   3274,          20.,   40.4669838,  -8.18181801
   3275,          20.,   41.2583733,  -8.18181801
   3276,          20.,   42.0497589,  -8.18181801
   3277,          20.,   42.8411484,  -8.18181801
   3278,          20.,    43.632534,  -8.18181801
   3279,          20.,   44.4239235,  -8.18181801
   3280,          20.,   45.2153091,  -8.18181801
   3281,          20.,   46.0127602,  -8.18181801
   3282,          20.,   46.8102074,  -8.18181801
   3283,          20.,   47.6076546,  -8.18181801
   3284,          20.,   48.4051018,  -8.18181801
   3285,          20.,   49.2025528,  -8.18181801
   3286,          20.,   20.7826385,    -9.090909
   3287,          20.,   21.5652771,    -9.090909
   3288,          20.,   22.3479156,    -9.090909
   3289,          20.,   23.1305542,    -9.090909
   3290,          20.,   23.9131927,    -9.090909
   3291,          20.,   24.6958313,    -9.090909
   3292,          20.,   25.4784698,    -9.090909
   3293,          20.,   26.2688999,    -9.090909
   3294,          20.,     27.05933,    -9.090909
   3295,          20.,   27.8497601,    -9.090909
   3296,          20.,    28.640192,    -9.090909
   3297,          20.,   29.4306221,    -9.090909
   3298,          20.,   30.2210522,    -9.090909
   3299,          20.,   31.0114841,    -9.090909
   3300,          20.,   31.8019142,    -9.090909
   3301,          20.,   32.5923462,    -9.090909
   3302,          20.,   33.3827744,    -9.090909
   3303,          20.,   34.1732063,    -9.090909
   3304,          20.,   34.9636345,    -9.090909
   3305,          20.,   35.7540665,    -9.090909
   3306,          20.,   36.5444984,    -9.090909
   3307,          20.,   37.3349266,    -9.090909
   3308,          20.,   38.1253586,    -9.090909
   3309,          20.,   38.9157906,    -9.090909
   3310,          20.,   39.7062187,    -9.090909
   3311,          20.,   40.4966507,    -9.090909
   3312,          20.,   41.2870827,    -9.090909
   3313,          20.,   42.0775108,    -9.090909
   3314,          20.,   42.8679428,    -9.090909
   3315,          20.,   43.6583748,    -9.090909
   3316,          20.,   44.4488029,    -9.090909
   3317,          20.,   45.2392349,    -9.090909
   3318,          20.,   46.0326958,    -9.090909
   3319,          20.,   46.8261566,    -9.090909
   3320,          20.,   47.6196175,    -9.090909
   3321,          20.,   48.4130783,    -9.090909
   3322,          20.,   49.2065392,    -9.090909
   3323,          30.,   20.7211208, -0.909090936
   3324,          30.,   21.4422417, -0.909090936
   3325,          30.,   22.1633625, -0.909090936
   3326,          30.,   22.8844833, -0.909090936
   3327,          30.,   23.6056042, -0.909090936
   3328,          30.,    24.326725, -0.909090936
   3329,          30.,   25.0478477, -0.909090936
   3330,          30.,   25.8468895, -0.909090936
   3331,          30.,   26.6459332, -0.909090936
   3332,          30.,   27.4449768, -0.909090936
   3333,          30.,   28.2440186, -0.909090936
   3334,          30.,   29.0430622, -0.909090936
   3335,          30.,   29.8421059, -0.909090936
   3336,          30.,   30.6411476, -0.909090936
   3337,          30.,   31.4401913, -0.909090936
   3338,          30.,   32.2392349, -0.909090936
   3339,          30.,   33.0382767, -0.909090936
   3340,          30.,   33.8373222, -0.909090936
   3341,          30.,    34.636364, -0.909090936
   3342,          30.,   35.4354057, -0.909090936
   3343,          30.,   36.2344513, -0.909090936
   3344,          30.,    37.033493, -0.909090936
   3345,          30.,   37.8325348, -0.909090936
   3346,          30.,   38.6315804, -0.909090936
   3347,          30.,   39.4306221, -0.909090936
   3348,          30.,   40.2296638, -0.909090936
   3349,          30.,   41.0287094, -0.909090936
   3350,          30.,   41.8277512, -0.909090936
   3351,          30.,   42.6267929, -0.909090936
   3352,          30.,   43.4258385, -0.909090936
   3353,          30.,   44.2248802, -0.909090936
   3354,          30.,    45.023922, -0.909090936
   3355,          30.,   45.8532677, -0.909090936
   3356,          30.,   46.6826172, -0.909090936
   3357,          30.,   47.5119629, -0.909090936
   3358,          30.,   48.3413086, -0.909090936
   3359,          30.,   49.1706543, -0.909090936
   3360,          30.,   20.7279568,  -1.81818187
   3361,          30.,   21.4559116,  -1.81818187
   3362,          30.,   22.1838684,  -1.81818187
   3363,          30.,   22.9118252,  -1.81818187
   3364,          30.,    23.639782,  -1.81818187
   3365,          30.,   24.3677368,  -1.81818187
   3366,          30.,   25.0956936,  -1.81818187
   3367,          30.,   25.8937798,  -1.81818187
   3368,          30.,   26.6918659,  -1.81818187
   3369,          30.,   27.4899521,  -1.81818187
   3370,          30.,   28.2880383,  -1.81818187
   3371,          30.,   29.0861244,  -1.81818187
   3372,          30.,   29.8842106,  -1.81818187
   3373,          30.,   30.6822968,  -1.81818187
   3374,          30.,   31.4803829,  -1.81818187
   3375,          30.,   32.2784691,  -1.81818187
   3376,          30.,   33.0765533,  -1.81818187
   3377,          30.,   33.8746414,  -1.81818187
   3378,          30.,   34.6727257,  -1.81818187
   3379,          30.,   35.4708138,  -1.81818187
   3380,          30.,    36.268898,  -1.81818187
   3381,          30.,   37.0669861,  -1.81818187
   3382,          30.,   37.8650703,  -1.81818187
   3383,          30.,   38.6631584,  -1.81818187
   3384,          30.,   39.4612427,  -1.81818187
   3385,          30.,   40.2593307,  -1.81818187
   3386,          30.,    41.057415,  -1.81818187
   3387,          30.,   41.8555031,  -1.81818187
   3388,          30.,   42.6535873,  -1.81818187
   3389,          30.,   43.4516754,  -1.81818187
   3390,          30.,   44.2497597,  -1.81818187
   3391,          30.,   45.0478477,  -1.81818187
   3392,          30.,   45.8732071,  -1.81818187
   3393,          30.,   46.6985664,  -1.81818187
   3394,          30.,    47.523922,  -1.81818187
   3395,          30.,   48.3492813,  -1.81818187
   3396,          30.,   49.1746407,  -1.81818187
   3397,          30.,   20.7347908,  -2.72727275
   3398,          30.,   21.4695835,  -2.72727275
   3399,          30.,   22.2043743,  -2.72727275
   3400,          30.,    22.939167,  -2.72727275
   3401,          30.,   23.6739578,  -2.72727275
   3402,          30.,   24.4087486,  -2.72727275
   3403,          30.,   25.1435413,  -2.72727275
   3404,          30.,     25.94067,  -2.72727275
   3405,          30.,   26.7377987,  -2.72727275
   3406,          30.,   27.5349274,  -2.72727275
   3407,          30.,    28.332058,  -2.72727275
   3408,          30.,   29.1291866,  -2.72727275
   3409,          30.,   29.9263153,  -2.72727275
   3410,          30.,   30.7234459,  -2.72727275
   3411,          30.,   31.5205746,  -2.72727275
   3412,          30.,   32.3177032,  -2.72727275
   3413,          30.,   33.1148338,  -2.72727275
   3414,          30.,   33.9119606,  -2.72727275
   3415,          30.,   34.7090912,  -2.72727275
   3416,          30.,   35.5062218,  -2.72727275
   3417,          30.,   36.3033485,  -2.72727275
   3418,          30.,   37.1004791,  -2.72727275
   3419,          30.,   37.8976059,  -2.72727275
   3420,          30.,   38.6947365,  -2.72727275
   3421,          30.,   39.4918671,  -2.72727275
   3422,          30.,   40.2889938,  -2.72727275
   3423,          30.,   41.0861244,  -2.72727275
   3424,          30.,    41.883255,  -2.72727275
   3425,          30.,   42.6803818,  -2.72727275
   3426,          30.,   43.4775124,  -2.72727275
   3427,          30.,   44.2746429,  -2.72727275
   3428,          30.,   45.0717697,  -2.72727275
   3429,          30.,   45.8931427,  -2.72727275
   3430,          30.,   46.7145119,  -2.72727275
   3431,          30.,   47.5358849,  -2.72727275
   3432,          30.,   48.3572578,  -2.72727275
   3433,          30.,    49.178627,  -2.72727275
   3434,          30.,   20.7416267,  -3.63636374
   3435,          30.,   21.4832535,  -3.63636374
   3436,          30.,   22.2248802,  -3.63636374
   3437,          30.,    22.966507,  -3.63636374
   3438,          30.,   23.7081337,  -3.63636374
   3439,          30.,   24.4497604,  -3.63636374
   3440,          30.,   25.1913872,  -3.63636374
   3441,          30.,   25.9875603,  -3.63636374
   3442,          30.,   26.7837315,  -3.63636374
   3443,          30.,   27.5799046,  -3.63636374
   3444,          30.,   28.3760757,  -3.63636374
   3445,          30.,   29.1722488,  -3.63636374
   3446,          30.,   29.9684219,  -3.63636374
   3447,          30.,   30.7645931,  -3.63636374
   3448,          30.,   31.5607662,  -3.63636374
   3449,          30.,   32.3569374,  -3.63636374
   3450,          30.,   33.1531105,  -3.63636374
   3451,          30.,   33.9492836,  -3.63636374
   3452,          30.,   34.7454529,  -3.63636374
   3453,          30.,    35.541626,  -3.63636374
   3454,          30.,   36.3377991,  -3.63636374
   3455,          30.,   37.1339722,  -3.63636374
   3456,          30.,   37.9301453,  -3.63636374
   3457,          30.,   38.7263145,  -3.63636374
   3458,          30.,   39.5224876,  -3.63636374
   3459,          30.,   40.3186607,  -3.63636374
   3460,          30.,   41.1148338,  -3.63636374
   3461,          30.,   41.9110031,  -3.63636374
   3462,          30.,   42.7071762,  -3.63636374
   3463,          30.,   43.5033493,  -3.63636374
   3464,          30.,   44.2995224,  -3.63636374
   3465,          30.,   45.0956955,  -3.63636374
   3466,          30.,   45.9130783,  -3.63636374
   3467,          30.,   46.7304611,  -3.63636374
   3468,          30.,   47.5478477,  -3.63636374
   3469,          30.,   48.3652306,  -3.63636374
   3470,          30.,   49.1826172,  -3.63636374
   3471,          30.,   20.7484627,   -4.5454545
   3472,          30.,   21.4969234,   -4.5454545
   3473,          30.,   22.2453861,   -4.5454545
   3474,          30.,   22.9938488,   -4.5454545
   3475,          30.,   23.7423096,   -4.5454545
   3476,          30.,   24.4907722,   -4.5454545
   3477,          30.,   25.2392349,   -4.5454545
   3478,          30.,   26.0344505,   -4.5454545
   3479,          30.,   26.8296642,   -4.5454545
   3480,          30.,   27.6248798,   -4.5454545
   3481,          30.,   28.4200954,   -4.5454545
   3482,          30.,   29.2153111,   -4.5454545
   3483,          30.,   30.0105267,   -4.5454545
   3484,          30.,   30.8057423,   -4.5454545
   3485,          30.,   31.6009579,   -4.5454545
   3486,          30.,   32.3961716,   -4.5454545
   3487,          30.,   33.1913872,   -4.5454545
   3488,          30.,   33.9866028,   -4.5454545
   3489,          30.,   34.7818184,   -4.5454545
   3490,          30.,    35.577034,   -4.5454545
   3491,          30.,   36.3722496,   -4.5454545
   3492,          30.,   37.1674652,   -4.5454545
   3493,          30.,   37.9626808,   -4.5454545
   3494,          30.,   38.7578964,   -4.5454545
   3495,          30.,   39.5531082,   -4.5454545
   3496,          30.,   40.3483238,   -4.5454545
   3497,          30.,   41.1435394,   -4.5454545
   3498,          30.,    41.938755,   -4.5454545
   3499,          30.,   42.7339706,   -4.5454545
   3500,          30.,   43.5291862,   -4.5454545
   3501,          30.,   44.3244019,   -4.5454545
   3502,          30.,   45.1196175,   -4.5454545
   3503,          30.,   45.9330139,   -4.5454545
   3504,          30.,   46.7464104,   -4.5454545
   3505,          30.,   47.5598068,   -4.5454545
   3506,          30.,   48.3732071,   -4.5454545
   3507,          30.,   49.1866035,   -4.5454545
   3508,          30.,   20.7552967,   -5.4545455
   3509,          30.,   21.5105953,   -5.4545455
   3510,          30.,    22.265892,   -5.4545455
   3511,          30.,   23.0211887,   -5.4545455
   3512,          30.,   23.7764874,   -5.4545455
   3513,          30.,   24.5317841,   -5.4545455
   3514,          30.,   25.2870808,   -5.4545455
   3515,          30.,   26.0813389,   -5.4545455
   3516,          30.,   26.8755989,   -5.4545455
   3517,          30.,    27.669857,   -5.4545455
   3518,          30.,   28.4641151,   -5.4545455
   3519,          30.,   29.2583733,   -5.4545455
   3520,          30.,   30.0526314,   -5.4545455
   3521,          30.,   30.8468895,   -5.4545455
   3522,          30.,   31.6411476,   -5.4545455
   3523,          30.,   32.4354057,   -5.4545455
   3524,          30.,   33.2296638,   -5.4545455
   3525,          30.,    34.023922,   -5.4545455
   3526,          30.,   34.8181801,   -5.4545455
   3527,          30.,    35.612442,   -5.4545455
   3528,          30.,   36.4067001,   -5.4545455
   3529,          30.,   37.2009583,   -5.4545455
   3530,          30.,   37.9952164,   -5.4545455
   3531,          30.,   38.7894745,   -5.4545455
   3532,          30.,   39.5837326,   -5.4545455
   3533,          30.,   40.3779907,   -5.4545455
   3534,          30.,   41.1722488,   -5.4545455
   3535,          30.,    41.966507,   -5.4545455
   3536,          30.,   42.7607651,   -5.4545455
   3537,          30.,   43.5550232,   -5.4545455
   3538,          30.,   44.3492813,   -5.4545455
   3539,          30.,   45.1435394,   -5.4545455
   3540,          30.,   45.9529495,   -5.4545455
   3541,          30.,   46.7623596,   -5.4545455
   3542,          30.,   47.5717697,   -5.4545455
   3543,          30.,   48.3811798,   -5.4545455
   3544,          30.,   49.1905899,   -5.4545455
   3545,          30.,   20.7621326,  -6.36363649
   3546,          30.,   21.5242653,  -6.36363649
   3547,          30.,   22.2863979,  -6.36363649
   3548,          30.,   23.0485306,  -6.36363649
   3549,          30.,   23.8106632,  -6.36363649
   3550,          30.,   24.5727959,  -6.36363649
   3551,          30.,   25.3349285,  -6.36363649
   3552,          30.,   26.1282291,  -6.36363649
   3553,          30.,   26.9215317,  -6.36363649
   3554,          30.,   27.7148323,  -6.36363649
   3555,          30.,   28.5081348,  -6.36363649
   3556,          30.,   29.3014355,  -6.36363649
   3557,          30.,   30.0947361,  -6.36363649
   3558,          30.,   30.8880386,  -6.36363649
   3559,          30.,   31.6813393,  -6.36363649
   3560,          30.,   32.4746399,  -6.36363649
   3561,          30.,   33.2679443,  -6.36363649
   3562,          30.,    34.061245,  -6.36363649
   3563,          30.,   34.8545456,  -6.36363649
   3564,          30.,   35.6478462,  -6.36363649
   3565,          30.,   36.4411469,  -6.36363649
   3566,          30.,   37.2344513,  -6.36363649
   3567,          30.,   38.0277519,  -6.36363649
   3568,          30.,   38.8210526,  -6.36363649
   3569,          30.,   39.6143532,  -6.36363649
   3570,          30.,   40.4076538,  -6.36363649
   3571,          30.,   41.2009583,  -6.36363649
   3572,          30.,   41.9942589,  -6.36363649
   3573,          30.,   42.7875595,  -6.36363649
   3574,          30.,   43.5808601,  -6.36363649
   3575,          30.,   44.3741646,  -6.36363649
   3576,          30.,   45.1674652,  -6.36363649
   3577,          30.,   45.9728851,  -6.36363649
   3578,          30.,   46.7783089,  -6.36363649
   3579,          30.,   47.5837326,  -6.36363649
   3580,          30.,   48.3891563,  -6.36363649
   3581,          30.,   49.1945763,  -6.36363649
   3582,          30.,   20.7689686,  -7.27272749
   3583,          30.,   21.5379353,  -7.27272749
   3584,          30.,   22.3069038,  -7.27272749
   3585,          30.,   23.0758724,  -7.27272749
   3586,          30.,   23.8448391,  -7.27272749
   3587,          30.,   24.6138077,  -7.27272749
   3588,          30.,   25.3827744,  -7.27272749
   3589,          30.,   26.1751194,  -7.27272749
   3590,          30.,   26.9674644,  -7.27272749
   3591,          30.,   27.7598095,  -7.27272749
   3592,          30.,   28.5521526,  -7.27272749
   3593,          30.,   29.3444977,  -7.27272749
   3594,          30.,   30.1368427,  -7.27272749
   3595,          30.,   30.9291859,  -7.27272749
   3596,          30.,   31.7215309,  -7.27272749
   3597,          30.,   32.5138741,  -7.27272749
   3598,          30.,    33.306221,  -7.27272749
   3599,          30.,   34.0985641,  -7.27272749
   3600,          30.,   34.8909073,  -7.27272749
   3601,          30.,   35.6832542,  -7.27272749
   3602,          30.,   36.4755974,  -7.27272749
   3603,          30.,   37.2679443,  -7.27272749
   3604,          30.,   38.0602875,  -7.27272749
   3605,          30.,   38.8526306,  -7.27272749
   3606,          30.,   39.6449776,  -7.27272749
   3607,          30.,   40.4373207,  -7.27272749
   3608,          30.,   41.2296638,  -7.27272749
   3609,          30.,   42.0220108,  -7.27272749
   3610,          30.,   42.8143539,  -7.27272749
   3611,          30.,   43.6066971,  -7.27272749
   3612,          30.,    44.399044,  -7.27272749
   3613,          30.,   45.1913872,  -7.27272749
   3614,          30.,   45.9928246,  -7.27272749
   3615,          30.,   46.7942581,  -7.27272749
   3616,          30.,   47.5956955,  -7.27272749
   3617,          30.,   48.3971291,  -7.27272749
   3618,          30.,   49.1985664,  -7.27272749
   3619,          30.,   20.7758026,  -8.18181801
   3620,          30.,   21.5516071,  -8.18181801
   3621,          30.,   22.3274097,  -8.18181801
   3622,          30.,   23.1032124,  -8.18181801
   3623,          30.,    23.879015,  -8.18181801
   3624,          30.,   24.6548195,  -8.18181801
   3625,          30.,   25.4306221,  -8.18181801
   3626,          30.,   26.2220097,  -8.18181801
   3627,          30.,   27.0133972,  -8.18181801
   3628,          30.,   27.8047848,  -8.18181801
   3629,          30.,   28.5961723,  -8.18181801
   3630,          30.,   29.3875599,  -8.18181801
   3631,          30.,   30.1789474,  -8.18181801
   3632,          30.,    30.970335,  -8.18181801
   3633,          30.,   31.7617226,  -8.18181801
   3634,          30.,   32.5531082,  -8.18181801
   3635,          30.,   33.3444977,  -8.18181801
   3636,          30.,   34.1358833,  -8.18181801
   3637,          30.,   34.9272728,  -8.18181801
   3638,          30.,   35.7186584,  -8.18181801
   3639,          30.,   36.5100479,  -8.18181801
   3640,          30.,   37.3014336,  -8.18181801
   3641,          30.,    38.092823,  -8.18181801
   3642,          30.,   38.8842087,  -8.18181801
   3643,          30.,   39.6755981,  -8.18181801
   3644,          30.,   40.4669838,  -8.18181801
   3645,          30.,   41.2583733,  -8.18181801
   3646,          30.,   42.0497589,  -8.18181801
   3647,          30.,   42.8411484,  -8.18181801
   3648,          30.,    43.632534,  -8.18181801
   3649,          30.,   44.4239235,  -8.18181801
   3650,          30.,   45.2153091,  -8.18181801
   3651,          30.,   46.0127602,  -8.18181801
   3652,          30.,   46.8102074,  -8.18181801
   3653,          30.,   47.6076546,  -8.18181801
   3654,          30.,   48.4051018,  -8.18181801
   3655,          30.,   49.2025528,  -8.18181801
   3656,          30.,   20.7826385,    -9.090909
   3657,          30.,   21.5652771,    -9.090909
   3658,          30.,   22.3479156,    -9.090909
   3659,          30.,   23.1305542,    -9.090909
   3660,          30.,   23.9131927,    -9.090909
   3661,          30.,   24.6958313,    -9.090909
   3662,          30.,   25.4784698,    -9.090909
   3663,          30.,   26.2688999,    -9.090909
   3664,          30.,     27.05933,    -9.090909
   3665,          30.,   27.8497601,    -9.090909
   3666,          30.,    28.640192,    -9.090909
   3667,          30.,   29.4306221,    -9.090909
   3668,          30.,   30.2210522,    -9.090909
   3669,          30.,   31.0114841,    -9.090909
   3670,          30.,   31.8019142,    -9.090909
   3671,          30.,   32.5923462,    -9.090909
   3672,          30.,   33.3827744,    -9.090909
   3673,          30.,   34.1732063,    -9.090909
   3674,          30.,   34.9636345,    -9.090909
   3675,          30.,   35.7540665,    -9.090909
   3676,          30.,   36.5444984,    -9.090909
   3677,          30.,   37.3349266,    -9.090909
   3678,          30.,   38.1253586,    -9.090909
   3679,          30.,   38.9157906,    -9.090909
   3680,          30.,   39.7062187,    -9.090909
   3681,          30.,   40.4966507,    -9.090909
   3682,          30.,   41.2870827,    -9.090909
   3683,          30.,   42.0775108,    -9.090909
   3684,          30.,   42.8679428,    -9.090909
   3685,          30.,   43.6583748,    -9.090909
   3686,          30.,   44.4488029,    -9.090909
   3687,          30.,   45.2392349,    -9.090909
   3688,          30.,   46.0326958,    -9.090909
   3689,          30.,   46.8261566,    -9.090909
   3690,          30.,   47.6196175,    -9.090909
   3691,          30.,   48.4130783,    -9.090909
   3692,          30.,   49.2065392,    -9.090909
   3693,     20.90909,          20., -0.909090936
   3694,    21.818182,          20., -0.909090936
   3695,    22.727272,          20., -0.909090936
   3696,    23.636364,          20., -0.909090936
   3697,    24.545454,          20., -0.909090936
   3698,    25.454546,          20., -0.909090936
   3699,    26.363636,          20., -0.909090936
   3700,    27.272728,          20., -0.909090936
   3701,    28.181818,          20., -0.909090936
   3702,     29.09091,          20., -0.909090936
   3703,     20.90909,          20.,  -1.81818187
   3704,    21.818182,          20.,  -1.81818187
   3705,    22.727272,          20.,  -1.81818187
   3706,    23.636364,          20.,  -1.81818187
   3707,    24.545454,          20.,  -1.81818187
   3708,    25.454546,          20.,  -1.81818187
   3709,    26.363636,          20.,  -1.81818187
   3710,    27.272728,          20.,  -1.81818187
   3711,    28.181818,          20.,  -1.81818187
   3712,     29.09091,          20.,  -1.81818187
   3713,     20.90909,          20.,  -2.72727275
   3714,    21.818182,          20.,  -2.72727275
   3715,    22.727272,          20.,  -2.72727275
   3716,    23.636364,          20.,  -2.72727275
   3717,    24.545454,          20.,  -2.72727275
   3718,    25.454546,          20.,  -2.72727275
   3719,    26.363636,          20.,  -2.72727275
   3720,    27.272728,          20.,  -2.72727275
   3721,    28.181818,          20.,  -2.72727275
   3722,     29.09091,          20.,  -2.72727275
   3723,     20.90909,          20.,  -3.63636374
   3724,    21.818182,          20.,  -3.63636374
   3725,    22.727272,          20.,  -3.63636374
   3726,    23.636364,          20.,  -3.63636374
   3727,    24.545454,          20.,  -3.63636374
   3728,    25.454546,          20.,  -3.63636374
   3729,    26.363636,          20.,  -3.63636374
   3730,    27.272728,          20.,  -3.63636374
   3731,    28.181818,          20.,  -3.63636374
   3732,     29.09091,          20.,  -3.63636374
   3733,     20.90909,          20.,   -4.5454545
   3734,    21.818182,          20.,   -4.5454545
   3735,    22.727272,          20.,   -4.5454545
   3736,    23.636364,          20.,   -4.5454545
   3737,    24.545454,          20.,   -4.5454545
   3738,    25.454546,          20.,   -4.5454545
   3739,    26.363636,          20.,   -4.5454545
   3740,    27.272728,          20.,   -4.5454545
   3741,    28.181818,          20.,   -4.5454545
   3742,     29.09091,          20.,   -4.5454545
   3743,     20.90909,          20.,   -5.4545455
   3744,    21.818182,          20.,   -5.4545455
   3745,    22.727272,          20.,   -5.4545455
   3746,    23.636364,          20.,   -5.4545455
   3747,    24.545454,          20.,   -5.4545455
   3748,    25.454546,          20.,   -5.4545455
   3749,    26.363636,          20.,   -5.4545455
   3750,    27.272728,          20.,   -5.4545455
   3751,    28.181818,          20.,   -5.4545455
   3752,     29.09091,          20.,   -5.4545455
   3753,     20.90909,          20.,  -6.36363649
   3754,    21.818182,          20.,  -6.36363649
   3755,    22.727272,          20.,  -6.36363649
   3756,    23.636364,          20.,  -6.36363649
   3757,    24.545454,          20.,  -6.36363649
   3758,    25.454546,          20.,  -6.36363649
   3759,    26.363636,          20.,  -6.36363649
   3760,    27.272728,          20.,  -6.36363649
   3761,    28.181818,          20.,  -6.36363649
   3762,     29.09091,          20.,  -6.36363649
   3763,     20.90909,          20.,  -7.27272749
   3764,    21.818182,          20.,  -7.27272749
   3765,    22.727272,          20.,  -7.27272749
   3766,    23.636364,          20.,  -7.27272749
   3767,    24.545454,          20.,  -7.27272749
   3768,    25.454546,          20.,  -7.27272749
   3769,    26.363636,          20.,  -7.27272749
   3770,    27.272728,          20.,  -7.27272749
   3771,    28.181818,          20.,  -7.27272749
   3772,     29.09091,          20.,  -7.27272749
   3773,     20.90909,          20.,  -8.18181801
   3774,    21.818182,          20.,  -8.18181801
   3775,    22.727272,          20.,  -8.18181801
   3776,    23.636364,          20.,  -8.18181801
   3777,    24.545454,          20.,  -8.18181801
   3778,    25.454546,          20.,  -8.18181801
   3779,    26.363636,          20.,  -8.18181801
   3780,    27.272728,          20.,  -8.18181801
   3781,    28.181818,          20.,  -8.18181801
   3782,     29.09091,          20.,  -8.18181801
   3783,     20.90909,          20.,    -9.090909
   3784,    21.818182,          20.,    -9.090909
   3785,    22.727272,          20.,    -9.090909
   3786,    23.636364,          20.,    -9.090909
   3787,    24.545454,          20.,    -9.090909
   3788,    25.454546,          20.,    -9.090909
   3789,    26.363636,          20.,    -9.090909
   3790,    27.272728,          20.,    -9.090909
   3791,    28.181818,          20.,    -9.090909
   3792,     29.09091,          20.,    -9.090909
   3793,     20.90909,          50., -0.909090936
   3794,    21.818182,          50., -0.909090936
   3795,    22.727272,          50., -0.909090936
   3796,    23.636364,          50., -0.909090936
   3797,    24.545454,          50., -0.909090936
   3798,    25.454546,          50., -0.909090936
   3799,    26.363636,          50., -0.909090936
   3800,    27.272728,          50., -0.909090936
   3801,    28.181818,          50., -0.909090936
   3802,     29.09091,          50., -0.909090936
   3803,     20.90909,          50.,  -1.81818187
   3804,    21.818182,          50.,  -1.81818187
   3805,    22.727272,          50.,  -1.81818187
   3806,    23.636364,          50.,  -1.81818187
   3807,    24.545454,          50.,  -1.81818187
   3808,    25.454546,          50.,  -1.81818187
   3809,    26.363636,          50.,  -1.81818187
   3810,    27.272728,          50.,  -1.81818187
   3811,    28.181818,          50.,  -1.81818187
   3812,     29.09091,          50.,  -1.81818187
   3813,     20.90909,          50.,  -2.72727275
   3814,    21.818182,          50.,  -2.72727275
   3815,    22.727272,          50.,  -2.72727275
   3816,    23.636364,          50.,  -2.72727275
   3817,    24.545454,          50.,  -2.72727275
   3818,    25.454546,          50.,  -2.72727275
   3819,    26.363636,          50.,  -2.72727275
   3820,    27.272728,          50.,  -2.72727275
   3821,    28.181818,          50.,  -2.72727275
   3822,     29.09091,          50.,  -2.72727275
   3823,     20.90909,          50.,  -3.63636374
   3824,    21.818182,          50.,  -3.63636374
   3825,    22.727272,          50.,  -3.63636374
   3826,    23.636364,          50.,  -3.63636374
   3827,    24.545454,          50.,  -3.63636374
   3828,    25.454546,          50.,  -3.63636374
   3829,    26.363636,          50.,  -3.63636374
   3830,    27.272728,          50.,  -3.63636374
   3831,    28.181818,          50.,  -3.63636374
   3832,     29.09091,          50.,  -3.63636374
   3833,     20.90909,          50.,   -4.5454545
   3834,    21.818182,          50.,   -4.5454545
   3835,    22.727272,          50.,   -4.5454545
   3836,    23.636364,          50.,   -4.5454545
   3837,    24.545454,          50.,   -4.5454545
   3838,    25.454546,          50.,   -4.5454545
   3839,    26.363636,          50.,   -4.5454545
   3840,    27.272728,          50.,   -4.5454545
   3841,    28.181818,          50.,   -4.5454545
   3842,     29.09091,          50.,   -4.5454545
   3843,     20.90909,          50.,   -5.4545455
   3844,    21.818182,          50.,   -5.4545455
   3845,    22.727272,          50.,   -5.4545455
   3846,    23.636364,          50.,   -5.4545455
   3847,    24.545454,          50.,   -5.4545455
   3848,    25.454546,          50.,   -5.4545455
   3849,    26.363636,          50.,   -5.4545455
   3850,    27.272728,          50.,   -5.4545455
   3851,    28.181818,          50.,   -5.4545455
   3852,     29.09091,          50.,   -5.4545455
   3853,     20.90909,          50.,  -6.36363649
   3854,    21.818182,          50.,  -6.36363649
   3855,    22.727272,          50.,  -6.36363649
   3856,    23.636364,          50.,  -6.36363649
   3857,    24.545454,          50.,  -6.36363649
   3858,    25.454546,          50.,  -6.36363649
   3859,    26.363636,          50.,  -6.36363649
   3860,    27.272728,          50.,  -6.36363649
   3861,    28.181818,          50.,  -6.36363649
   3862,     29.09091,          50.,  -6.36363649
   3863,     20.90909,          50.,  -7.27272749
   3864,    21.818182,          50.,  -7.27272749
   3865,    22.727272,          50.,  -7.27272749
   3866,    23.636364,          50.,  -7.27272749
   3867,    24.545454,          50.,  -7.27272749
   3868,    25.454546,          50.,  -7.27272749
   3869,    26.363636,          50.,  -7.27272749
   3870,    27.272728,          50.,  -7.27272749
   3871,    28.181818,          50.,  -7.27272749
   3872,     29.09091,          50.,  -7.27272749
   3873,     20.90909,          50.,  -8.18181801
   3874,    21.818182,          50.,  -8.18181801
   3875,    22.727272,          50.,  -8.18181801
   3876,    23.636364,          50.,  -8.18181801
   3877,    24.545454,          50.,  -8.18181801
   3878,    25.454546,          50.,  -8.18181801
   3879,    26.363636,          50.,  -8.18181801
   3880,    27.272728,          50.,  -8.18181801
   3881,    28.181818,          50.,  -8.18181801
   3882,     29.09091,          50.,  -8.18181801
   3883,     20.90909,          50.,    -9.090909
   3884,    21.818182,          50.,    -9.090909
   3885,    22.727272,          50.,    -9.090909
   3886,    23.636364,          50.,    -9.090909
   3887,    24.545454,          50.,    -9.090909
   3888,    25.454546,          50.,    -9.090909
   3889,    26.363636,          50.,    -9.090909
   3890,    27.272728,          50.,    -9.090909
   3891,    28.181818,          50.,    -9.090909
   3892,     29.09091,          50.,    -9.090909
   3893,    -20.90909,          20.,    -9.090909
   3894,   -21.818182,          20.,    -9.090909
   3895,   -22.727272,          20.,    -9.090909
   3896,   -23.636364,          20.,    -9.090909
   3897,   -24.545454,          20.,    -9.090909
   3898,   -25.454546,          20.,    -9.090909
   3899,   -26.363636,          20.,    -9.090909
   3900,   -27.272728,          20.,    -9.090909
   3901,   -28.181818,          20.,    -9.090909
   3902,    -29.09091,          20.,    -9.090909
   3903,    -20.90909,          20.,  -8.18181801
   3904,   -21.818182,          20.,  -8.18181801
   3905,   -22.727272,          20.,  -8.18181801
   3906,   -23.636364,          20.,  -8.18181801
   3907,   -24.545454,          20.,  -8.18181801
   3908,   -25.454546,          20.,  -8.18181801
   3909,   -26.363636,          20.,  -8.18181801
   3910,   -27.272728,          20.,  -8.18181801
   3911,   -28.181818,          20.,  -8.18181801
   3912,    -29.09091,          20.,  -8.18181801
   3913,    -20.90909,          20.,  -7.27272749
   3914,   -21.818182,          20.,  -7.27272749
   3915,   -22.727272,          20.,  -7.27272749
   3916,   -23.636364,          20.,  -7.27272749
   3917,   -24.545454,          20.,  -7.27272749
   3918,   -25.454546,          20.,  -7.27272749
   3919,   -26.363636,          20.,  -7.27272749
   3920,   -27.272728,          20.,  -7.27272749
   3921,   -28.181818,          20.,  -7.27272749
   3922,    -29.09091,          20.,  -7.27272749
   3923,    -20.90909,          20.,  -6.36363649
   3924,   -21.818182,          20.,  -6.36363649
   3925,   -22.727272,          20.,  -6.36363649
   3926,   -23.636364,          20.,  -6.36363649
   3927,   -24.545454,          20.,  -6.36363649
   3928,   -25.454546,          20.,  -6.36363649
   3929,   -26.363636,          20.,  -6.36363649
   3930,   -27.272728,          20.,  -6.36363649
   3931,   -28.181818,          20.,  -6.36363649
   3932,    -29.09091,          20.,  -6.36363649
   3933,    -20.90909,          20.,   -5.4545455
   3934,   -21.818182,          20.,   -5.4545455
   3935,   -22.727272,          20.,   -5.4545455
   3936,   -23.636364,          20.,   -5.4545455
   3937,   -24.545454,          20.,   -5.4545455
   3938,   -25.454546,          20.,   -5.4545455
   3939,   -26.363636,          20.,   -5.4545455
   3940,   -27.272728,          20.,   -5.4545455
   3941,   -28.181818,          20.,   -5.4545455
   3942,    -29.09091,          20.,   -5.4545455
   3943,    -20.90909,          20.,   -4.5454545
   3944,   -21.818182,          20.,   -4.5454545
   3945,   -22.727272,          20.,   -4.5454545
   3946,   -23.636364,          20.,   -4.5454545
   3947,   -24.545454,          20.,   -4.5454545
   3948,   -25.454546,          20.,   -4.5454545
   3949,   -26.363636,          20.,   -4.5454545
   3950,   -27.272728,          20.,   -4.5454545
   3951,   -28.181818,          20.,   -4.5454545
   3952,    -29.09091,          20.,   -4.5454545
   3953,    -20.90909,          20.,  -3.63636374
   3954,   -21.818182,          20.,  -3.63636374
   3955,   -22.727272,          20.,  -3.63636374
   3956,   -23.636364,          20.,  -3.63636374
   3957,   -24.545454,          20.,  -3.63636374
   3958,   -25.454546,          20.,  -3.63636374
   3959,   -26.363636,          20.,  -3.63636374
   3960,   -27.272728,          20.,  -3.63636374
   3961,   -28.181818,          20.,  -3.63636374
   3962,    -29.09091,          20.,  -3.63636374
   3963,    -20.90909,          20.,  -2.72727275
   3964,   -21.818182,          20.,  -2.72727275
   3965,   -22.727272,          20.,  -2.72727275
   3966,   -23.636364,          20.,  -2.72727275
   3967,   -24.545454,          20.,  -2.72727275
   3968,   -25.454546,          20.,  -2.72727275
   3969,   -26.363636,          20.,  -2.72727275
   3970,   -27.272728,          20.,  -2.72727275
   3971,   -28.181818,          20.,  -2.72727275
   3972,    -29.09091,          20.,  -2.72727275
   3973,    -20.90909,          20.,  -1.81818187
   3974,   -21.818182,          20.,  -1.81818187
   3975,   -22.727272,          20.,  -1.81818187
   3976,   -23.636364,          20.,  -1.81818187
   3977,   -24.545454,          20.,  -1.81818187
   3978,   -25.454546,          20.,  -1.81818187
   3979,   -26.363636,          20.,  -1.81818187
   3980,   -27.272728,          20.,  -1.81818187
   3981,   -28.181818,          20.,  -1.81818187
   3982,    -29.09091,          20.,  -1.81818187
   3983,    -20.90909,          20., -0.909090936
   3984,   -21.818182,          20., -0.909090936
   3985,   -22.727272,          20., -0.909090936
   3986,   -23.636364,          20., -0.909090936
   3987,   -24.545454,          20., -0.909090936
   3988,   -25.454546,          20., -0.909090936
   3989,   -26.363636,          20., -0.909090936
   3990,   -27.272728,          20., -0.909090936
   3991,   -28.181818,          20., -0.909090936
   3992,    -29.09091,          20., -0.909090936
   3993,    -20.90909,          50.,    -9.090909
   3994,   -21.818182,          50.,    -9.090909
