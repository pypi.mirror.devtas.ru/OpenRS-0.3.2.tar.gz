   7995,   -4.2076335,   76.0257034,           0.
   7996,  -4.35272455,   76.9231415,           0.
   7997,  -4.49781513,   77.8205795,           0.
   7998,  -4.64290619,   78.7180176,           0.
   7999,  -3.99695325,   70.5235062,           0.
   8000,  -4.17073393,   71.4158325,           0.
   8001,  -4.34451437,   72.3081589,           0.
   8002,  -4.51829481,   73.2004929,           0.
   8003,  -4.69207525,   74.0928192,           0.
   8004,  -4.86585617,   74.9851456,           0.
   8005,  -5.03963661,   75.8774719,           0.
   8006,  -5.21341705,   76.7697983,           0.
   8007,  -5.38719749,   77.6621246,           0.
   8008,  -5.56097841,    78.554451,           0.
   8009,  -4.65271044,   70.3848572,           0.
   8010,   -4.8550024,   71.2711563,           0.
   8011,  -5.05729389,   72.1574554,           0.
   8012,  -5.25958586,   73.0437469,           0.
   8013,  -5.46187735,   73.9300461,           0.
   8014,  -5.66416931,   74.8163452,           0.
   8015,   -5.8664608,   75.7026443,           0.
   8016,  -6.06875277,   76.5889435,           0.
   8017,  -6.27104473,   77.4752426,           0.
   8018,  -6.47333622,   78.3615417,           0.
   8019,  -5.30368662,   70.2252579,           0.
   8020,  -5.53428173,   71.1046143,           0.
   8021,  -5.76487684,   71.9839706,           0.
   8022,  -5.99547195,   72.8633347,           0.
   8023,  -6.22606707,    73.742691,           0.
   8024,  -6.45666218,   74.6220474,           0.
   8025,  -6.68725729,   75.5014114,           0.
   8026,   -6.9178524,   76.3807678,           0.
   8027,  -7.14844751,   77.2601242,           0.
   8028,  -7.37904263,   78.1394882,           0.
   8029,  -5.94921303,   70.0448761,           0.
   8030,  -6.20787477,   70.9163895,           0.
   8031,  -6.46653605,   71.7879028,           0.
   8032,  -6.72519732,   72.6594238,           0.
   8033,  -6.98385906,   73.5309372,           0.
   8034,  -7.24252033,   74.4024582,           0.
   8035,   -7.5011816,   75.2739716,           0.
   8036,  -7.75984335,   76.1454849,           0.
   8037,   -8.0185051,   77.0170059,           0.
   8038,  -8.27716637,   77.8885193,           0.
   8039,  -6.58862638,    69.843895,           0.
   8040,  -6.87508821,   70.7066727,           0.
   8041,  -7.16155052,   71.5694504,           0.
   8042,  -7.44801235,   72.4322281,           0.
   8043,  -7.73447466,   73.2950058,           0.
   8044,  -8.02093601,   74.1577835,           0.
   8045,   -8.3073988,   75.0205612,           0.
   8046,  -8.59386063,   75.8833389,           0.
   8047,  -8.88032246,   76.7461166,           0.
   8048,  -9.16678429,   77.6088943,           0.
   8049,  -7.22126913,   69.6225204,           0.
   8050,  -7.53523779,   70.4756775,           0.
   8051,  -7.84920597,   71.3288269,           0.
   8052,  -8.16317368,   72.1819839,           0.
   8053,  -8.47714233,   73.0351334,           0.
   8054,  -8.79111004,   73.8882904,           0.
   8055,   -9.1050787,   74.7414398,           0.
   8056,  -9.41904736,   75.5945969,           0.
   8057,  -9.73301506,   76.4477463,           0.
   8058,  -10.0469837,   77.3009033,           0.
   8059,  -7.84649181,   69.3809891,           0.
   8060,    -8.187644,   70.2236404,           0.
   8061,  -8.52879524,   71.0662918,           0.
   8062,  -8.86994743,   71.9089432,           0.
   8063,  -9.21109962,   72.7515945,           0.
   8064,  -9.55225086,   73.5942459,           0.
   8065,  -9.89340305,   74.4368973,           0.
   8066,  -10.2345543,   75.2795486,           0.
   8067,  -10.5757065,      76.1222,           0.
   8068,  -10.9168587,   76.9648514,           0.
   8069,  -8.46365166,   69.1195374,           0.
   8070,  -8.83163643,   69.9508209,           0.
   8071,   -9.1996212,   70.7821045,           0.
   8072,  -9.56760597,   71.6133881,           0.
   8073,  -9.93559074,   72.4446716,           0.
   8074,  -10.3035765,   73.2759552,           0.
   8075,  -10.6715612,   74.1072388,           0.
   8076,   -11.039546,   74.9385223,           0.
   8077,  -11.4075308,   75.7698135,           0.
   8078,  -11.7755156,   76.6010971,           0.
   8079,  -9.07211494,   68.8384399,           0.
   8080,  -9.46655464,   69.6575012,           0.
   8081,  -9.86099434,   70.4765625,           0.
   8082,   -10.255434,   71.2956314,           0.
   8083,  -10.6498737,   72.1146927,           0.
   8084,  -11.0443134,    72.933754,           0.
   8085,  -11.4387531,   73.7528152,           0.
   8086,  -11.8331928,   74.5718765,           0.
   8087,  -12.2276325,   75.3909378,           0.
   8088,  -12.6220722,   76.2100067,           0.
   8089,  -9.67125511,   68.5379868,           0.
   8090,  -10.0917444,   69.3439865,           0.
   8091,  -10.5122337,   70.1499863,           0.
   8092,   -10.932723,    70.955986,           0.
   8093,  -11.3532124,   71.7619858,           0.
   8094,  -11.7737017,   72.5679855,           0.
   8095,   -12.194191,   73.3739853,           0.
   8096,  -12.6146803,   74.1799774,           0.
   8097,  -13.0351696,   74.9859772,           0.
   8098,  -13.4556589,   75.7919769,           0.
   8099,   -10.260458,    68.218483,           0.
   8100,  -10.7065649,   69.0105896,           0.
   8101,  -11.1526718,   69.8026962,           0.
   8102,  -11.5987787,   70.5948029,           0.
   8103,  -12.0448856,   71.3869171,           0.
   8104,  -12.4909925,   72.1790237,           0.
   8105,  -12.9370995,   72.9711304,           0.
   8106,  -13.3832064,    73.763237,           0.
   8107,  -13.8293133,   74.5553436,           0.
   8108,  -14.2754192,   75.3474503,           0.
   8109,  -10.8391171,   67.8802567,           0.
   8110,  -11.3103828,   68.6576614,           0.
   8111,  -11.7816496,   69.4350662,           0.
   8112,  -12.2529154,   70.2124634,           0.
   8113,  -12.7241812,   70.9898682,           0.
   8114,   -13.195447,   71.7672729,           0.
   8115,  -13.6667128,   72.5446701,           0.
   8116,  -14.1379795,   73.3220749,           0.
   8117,  -14.6092453,   74.0994797,           0.
   8118,  -15.0805111,   74.8768768,           0.
   8119,  -11.4066391,   67.5236588,           0.
   8120,  -11.9025793,   68.2855606,           0.
   8121,  -12.3985205,   69.0474548,           0.
   8122,  -12.8944616,   69.8093567,           0.
   8123,  -13.3904018,   70.5712509,           0.
   8124,   -13.886343,   71.3331528,           0.
   8125,  -14.3822842,    72.095047,           0.
   8126,  -14.8782244,   72.8569489,           0.
   8127,  -15.3741655,   73.6188431,           0.
   8128,  -15.8701057,   74.3807449,           0.
   8129,  -11.9624395,   67.1490555,           0.
   8130,  -12.4825449,   67.8946686,           0.
   8131,  -13.0026512,   68.6402817,           0.
   8132,  -13.5227575,   69.3858871,           0.
   8133,  -14.0428638,   70.1315002,           0.
   8134,  -14.5629692,   70.8771133,           0.
   8135,  -15.0830755,   71.6227264,           0.
   8136,  -15.6031818,   72.3683319,           0.
   8137,  -16.1232872,    73.113945,           0.
   8138,  -16.6433945,   73.8595581,           0.
   8139,  -12.5059471,   66.7568283,           0.
   8140,  -13.0496845,   67.4853897,           0.
   8141,   -13.593421,   68.2139435,           0.
   8142,  -14.1371584,   68.9425049,           0.
   8143,  -14.6808949,   69.6710587,           0.
   8144,  -15.2246313,   70.3996201,           0.
   8145,  -15.7683687,   71.1281738,           0.
   8146,  -16.3121052,   71.8567352,           0.
   8147,  -16.8558426,   72.5852966,           0.
   8148,    -17.39958,   73.3138504,           0.
   8149,  -13.0366049,   66.3473892,           0.
   8150,  -13.6034136,   67.0581436,           0.
   8151,  -14.1702232,    67.768898,           0.
   8152,  -14.7370319,   68.4796524,           0.
   8153,  -15.3038406,   69.1904068,           0.
   8154,  -15.8706493,   69.9011612,           0.
   8155,   -16.437458,   70.6119232,           0.
   8156,  -17.0042667,   71.3226776,           0.
   8157,  -17.5710754,    72.033432,           0.
   8158,   -18.137886,   72.7441864,           0.
   8159,  -13.5538664,   65.9211426,           0.
   8160,  -14.1431646,   66.6133652,           0.
   8161,  -14.7324638,   67.3055878,           0.
   8162,  -15.3217621,   67.9978104,           0.
   8163,  -15.9110603,   68.6900406,           0.
   8164,  -16.5003586,   69.3822632,           0.
   8165,  -17.0896568,   70.0744858,           0.
   8166,   -17.678957,   70.7667084,           0.
   8167,  -18.2682552,    71.458931,           0.
   8168,  -18.8575535,   72.1511536,           0.
   8169,  -14.0572004,   65.4785385,           0.
   8170,  -14.6683826,   66.1515198,           0.
   8171,  -15.2795658,    66.824501,           0.
   8172,   -15.890748,   67.4974823,           0.
   8173,  -16.5019302,   68.1704636,           0.
   8174,  -17.1131134,   68.8434372,           0.
   8175,  -17.7242966,   69.5164185,           0.
   8176,  -18.3354797,   70.1893997,           0.
   8177,   -18.946661,    70.862381,           0.
   8178,  -19.5578442,   71.5353622,           0.
   8179,  -14.5460901,   65.0200348,           0.
   8180,  -15.1785288,   65.6730804,           0.
   8181,  -15.8109674,   66.3261185,           0.
   8182,  -16.4434052,   66.9791641,           0.
   8183,  -17.0758438,   67.6322098,           0.
   8184,  -17.7082825,   68.2852554,           0.
   8185,  -18.3407211,   68.9383011,           0.
   8186,  -18.9731598,   69.5913467,           0.
   8187,  -19.6055984,   70.2443924,           0.
   8188,  -20.2380371,    70.897438,           0.
   8189,  -15.0200319,   64.5460892,           0.
   8190,  -15.6730766,   65.1785278,           0.
   8191,  -16.3261223,   65.8109665,           0.
   8192,   -16.979166,   66.4434052,           0.
   8193,  -17.6322117,   67.0758438,           0.
   8194,  -18.2852554,   67.7082825,           0.
   8195,  -18.9383011,   68.3407211,           0.
   8196,  -19.5913467,   68.9731598,           0.
   8197,  -20.2443905,   69.6055984,           0.
   8198,  -20.8974361,   70.2380371,           0.
   8199,  -15.4785395,   64.0571976,           0.
   8200,  -16.1515198,   64.6683807,           0.
   8201,  -16.8244991,   65.2795639,           0.
   8202,  -17.4974804,   65.8907471,           0.
   8203,  -18.1704597,   66.5019302,           0.
   8204,  -18.8434391,   67.1131134,           0.
   8205,  -19.5164204,   67.7242966,           0.
   8206,  -20.1893997,   68.3354797,           0.
   8207,  -20.8623791,   68.9466629,           0.
   8208,  -21.5353603,   69.5578461,           0.
   8209,  -15.9211426,   63.5538673,           0.
   8210,  -16.6133671,   64.1431656,           0.
   8211,  -17.3055897,     64.73246,           0.
   8212,  -17.9978142,   65.3217621,           0.
   8213,  -18.6900368,   65.9110641,           0.
   8214,  -19.3822613,   66.5003586,           0.
   8215,  -20.0744839,   67.0896606,           0.
   8216,  -20.7667084,   67.6789551,           0.
   8217,   -21.458931,   68.2682571,           0.
   8218,  -22.1511555,   68.8575516,           0.
   8219,  -16.3473854,   63.0366058,           0.
   8220,  -17.0581417,   63.6034126,           0.
   8221,   -17.768898,   64.1702194,           0.
   8222,  -18.4796524,     64.73703,           0.
   8223,  -19.1904087,   65.3038406,           0.
   8224,   -19.901165,   65.8706512,           0.
   8225,  -20.6119213,   66.4374619,           0.
   8226,  -21.3226776,   67.0042648,           0.
   8227,   -22.033432,   67.5710754,           0.
   8228,  -22.7441883,    68.137886,           0.
   8229,  -16.7568302,   62.5059471,           0.
   8230,  -17.4853878,   63.0496826,           0.
   8231,  -18.2139454,   63.5934219,           0.
   8232,   -18.942503,   64.1371613,           0.
   8233,  -19.6710625,   64.6808929,           0.
   8234,  -20.3996201,   65.2246323,           0.
   8235,  -21.1281776,   65.7683716,           0.
   8236,  -21.8567352,   66.3121033,           0.
   8237,  -22.5852928,   66.8558426,           0.
   8238,  -23.3138504,   67.3995819,           0.
   8239,  -17.1490555,   61.9624405,           0.
   8240,  -17.8946667,   62.4825439,           0.
   8241,  -18.6402779,   63.0026512,           0.
   8242,  -19.3858891,   63.5227585,           0.
   8243,  -20.1315002,   64.0428619,           0.
   8244,  -20.8771114,    64.562973,           0.
   8245,  -21.6227226,   65.0830765,           0.
   8246,  -22.3683338,   65.6031799,           0.
   8247,   -23.113945,    66.123291,           0.
   8248,  -23.8595562,   66.6433945,           0.
   8249,  -17.5236607,   61.4066391,           0.
   8250,  -18.2855587,   61.9025803,           0.
   8251,  -19.0474567,   62.3985214,           0.
   8252,  -19.8093548,   62.8944626,           0.
   8253,  -20.5712528,   63.3904037,           0.
   8254,  -21.3331509,   63.8863411,           0.
   8255,  -22.0950508,   64.3822861,           0.
   8256,  -22.8569489,   64.8782272,           0.
   8257,  -23.6188469,   65.3741684,           0.
   8258,  -24.3807449,   65.8701096,           0.
   8259,  -17.8802586,    60.839119,           0.
   8260,  -18.6576595,   61.3103828,           0.
   8261,  -19.4350624,   61.7816505,           0.
   8262,  -20.2124653,   62.2529144,           0.
   8263,  -20.9898682,   62.7241821,           0.
   8264,   -21.767271,    63.195446,           0.
   8265,   -22.544672,   63.6667137,           0.
   8266,  -23.3220749,   64.1379776,           0.
   8267,  -24.0994778,   64.6092453,           0.
   8268,  -24.8768806,    65.080513,           0.
   8269,  -18.2184811,   60.2604561,           0.
   8270,  -19.0105896,   60.7065659,           0.
   8271,  -19.8026981,   61.1526718,           0.
   8272,  -20.5948067,   61.5987778,           0.
   8273,  -21.3869133,   62.0448837,           0.
   8274,  -22.1790218,   62.4909935,           0.
   8275,  -22.9711304,   62.9370995,           0.
   8276,   -23.763237,   63.3832054,           0.
   8277,  -24.5553455,   63.8293114,           0.
   8278,  -25.3474541,   64.2754211,           0.
   8279,  -18.5379848,    59.671257,           0.
   8280,  -19.3439846,   60.0917435,           0.
   8281,  -20.1499844,   60.5122337,           0.
   8282,  -20.9559841,    60.932724,           0.
   8283,  -21.7619839,   61.3532143,           0.
   8284,  -22.5679817,   61.7737007,           0.
   8285,  -23.3739815,    62.194191,           0.
   8286,  -24.1799812,   62.6146812,           0.
   8287,   -24.985981,   63.0351715,           0.
   8288,  -25.7919807,    63.455658,           0.
   8289,  -18.8384399,    59.072113,           0.
   8290,  -19.6575031,   59.4665527,           0.
   8291,  -20.4765644,   59.8609924,           0.
   8292,  -21.2956276,   60.2554321,           0.
   8293,  -22.1146908,   60.6498718,           0.
   8294,  -22.9337521,   61.0443115,           0.
   8295,  -23.7528152,   61.4387512,           0.
   8296,  -24.5718784,   61.8331947,           0.
   8297,  -25.3909416,   62.2276344,           0.
   8298,  -26.2100029,   62.6220741,           0.
   8299,  -19.1195374,   58.4636536,           0.
   8300,  -19.9508209,   58.8316383,           0.
   8301,  -20.7821045,   59.1996231,           0.
   8302,    -21.61339,   59.5676079,           0.
   8303,  -22.4446735,   59.9355927,           0.
   8304,  -23.2759571,   60.3035774,           0.
   8305,  -24.1072426,   60.6715622,           0.
   8306,  -24.9385262,    61.039547,           0.
   8307,  -25.7698097,   61.4075317,           0.
   8308,  -26.6010952,   61.7755165,           0.
   8309,  -19.3809872,   57.8464928,           0.
   8310,  -20.2236385,    58.187645,           0.
   8311,  -21.0662899,   58.5287971,           0.
   8312,  -21.9089413,   58.8699455,           0.
   8313,  -22.7515926,   59.2110977,           0.
   8314,   -23.594244,   59.5522499,           0.
   8315,  -24.4368973,   59.8934021,           0.
   8316,  -25.2795486,   60.2345543,           0.
   8317,     -26.1222,   60.5757065,           0.
   8318,  -26.9648514,   60.9168587,           0.
   8319,  -19.6225224,   57.2212677,           0.
   8320,  -20.4756756,   57.5352364,           0.
   8321,  -21.3288269,    57.849205,           0.
   8322,  -22.1819801,   58.1631737,           0.
   8323,  -23.0351334,   58.4771423,           0.
   8324,  -23.8882866,    58.791111,           0.
   8325,  -24.7414398,   59.1050797,           0.
   8326,   -25.594593,   59.4190483,           0.
   8327,  -26.4477463,    59.733017,           0.
   8328,  -27.3008995,   60.0469818,           0.
   8329,  -19.8438931,   56.5886269,           0.
   8330,  -20.7066708,   56.8750877,           0.
   8331,  -21.5694485,   57.1615486,           0.
   8332,  -22.4322262,   57.4480133,           0.
   8333,  -23.2950039,   57.7344742,           0.
   8334,  -24.1577835,   58.0209351,           0.
   8335,  -25.0205612,   58.3073997,           0.
   8336,  -25.8833389,   58.5938606,           0.
   8337,  -26.7461166,   58.8803215,           0.
   8338,  -27.6088943,   59.1667862,           0.
   8339,  -20.0448742,   55.9492149,           0.
   8340,  -20.9163895,   56.2078743,           0.
   8341,  -21.7879066,   56.4665375,           0.
   8342,  -22.6594219,   56.7251968,           0.
   8343,  -23.5309391,     56.98386,           0.
   8344,  -24.4024544,   57.2425194,           0.
   8345,  -25.2739716,   57.5011826,           0.
   8346,  -26.1454868,   57.7598419,           0.
   8347,   -27.017004,   58.0185051,           0.
   8348,  -27.8885193,   58.2771645,           0.
   8349,   -20.225256,    55.303688,           0.
   8350,  -21.1046143,   55.5342827,           0.
   8351,  -21.9839745,   55.7648773,           0.
   8352,  -22.8633327,    55.995472,           0.
   8353,  -23.7426929,   56.2260666,           0.
   8354,  -24.6220512,   56.4566612,           0.
   8355,  -25.5014095,   56.6872559,           0.
   8356,  -26.3807697,   56.9178505,           0.
   8357,   -27.260128,   57.1484489,           0.
   8358,  -28.1394863,   57.3790436,           0.
   8359,  -20.3848572,     54.65271,           0.
   8360,  -21.2711544,   54.8550034,           0.
   8361,  -22.1574516,   55.0572929,           0.
   8362,  -23.0437508,   55.2595863,           0.
   8363,   -23.930048,   55.4618759,           0.
   8364,  -24.8163471,   55.6641693,           0.
   8365,  -25.7026443,   55.8664627,           0.
   8366,  -26.5889435,   56.0687523,           0.
   8367,  -27.4752407,   56.2710457,           0.
   8368,  -28.3615398,   56.4733353,           0.
   8369,    -20.52351,   53.9969521,           0.
   8370,  -21.4158363,   54.1707344,           0.
   8371,  -22.3081627,   54.3445129,           0.
   8372,   -23.200489,   54.5182953,           0.
   8373,  -24.0928154,   54.6920738,           0.
   8374,  -24.9851418,   54.8658562,           0.
   8375,  -25.8774681,   55.0396347,           0.
   8376,  -26.7697945,   55.2134171,           0.
   8377,  -27.6621208,   55.3871994,           0.
   8378,  -28.5544491,   55.5609779,           0.
   8379,  -20.6410732,   53.3370895,           0.
   8380,  -21.5385113,   53.4821777,           0.
   8381,  -22.4359493,   53.6272697,           0.
   8382,  -23.3333874,   53.7723618,           0.
   8383,  -24.2308254,   53.9174538,           0.
   8384,  -25.1282635,    54.062542,           0.
   8385,  -26.0257015,    54.207634,           0.
   8386,  -26.9231396,    54.352726,           0.
   8387,  -27.8205776,   54.4978142,           0.
   8388,  -28.7180157,   54.6429062,           0.
   8389,  -20.7374268,   52.6737938,           0.
   8390,  -21.6390553,   52.7900467,           0.
   8391,  -22.5406818,   52.9062996,           0.
   8392,  -23.4423103,   53.0225525,           0.
   8393,  -24.3439369,   53.1388016,           0.
   8394,  -25.2455635,   53.2550545,           0.
   8395,   -26.147192,   53.3713074,           0.
   8396,  -27.0488186,   53.4875603,           0.
   8397,  -27.9504452,   53.6038094,           0.
   8398,  -28.8520737,   53.7200623,           0.
   8399,  -20.8124733,   52.0077553,           0.
   8400,  -21.7173634,    52.095047,           0.
   8401,  -22.6222534,   52.1823425,           0.
   8402,  -23.5271435,   52.2696342,           0.
   8403,  -24.4320335,   52.3569298,           0.
   8404,  -25.3369236,   52.4442215,           0.
   8405,  -26.2418137,    52.531517,           0.
   8406,  -27.1467037,   52.6188087,           0.
   8407,  -28.0515938,   52.7061043,           0.
   8408,  -28.9564838,    52.793396,           0.
   8409,  -20.8661308,   51.3396492,           0.
   8410,  -21.7733536,   51.3978958,           0.
   8411,  -22.6805763,   51.4561424,           0.
   8412,   -23.587801,   51.5143852,           0.
   8413,  -24.4950237,   51.5726318,           0.
   8414,  -25.4022465,   51.6308784,           0.
   8415,  -26.3094692,   51.6891251,           0.
   8416,   -27.216692,   51.7473679,           0.
   8417,  -28.1239147,   51.8056145,           0.
   8418,  -29.0311394,   51.8638611,           0.
   8419,  -20.8983479,   50.6701698,           0.
   8420,  -21.8069725,   50.6993065,           0.
   8421,  -22.7155952,   50.7284431,           0.
   8422,  -23.6242199,   50.7575836,           0.
   8423,  -24.5328426,   50.7867203,           0.
   8424,  -25.4414673,   50.8158569,           0.
   8425,  -26.3500919,   50.8449974,           0.
   8426,  -27.2587147,   50.8741341,           0.
   8427,  -28.1673393,   50.9032707,           0.
   8428,  -29.0759621,   50.9324112,           0.
   8429,   20.8983479,   50.6701698,         -10.
   8430,   21.8069725,   50.6993065,         -10.
   8431,   22.7155952,   50.7284431,         -10.
   8432,   23.6242199,   50.7575836,         -10.
   8433,   24.5328426,   50.7867203,         -10.
   8434,   25.4414673,   50.8158569,         -10.
   8435,   26.3500919,   50.8449974,         -10.
   8436,   27.2587147,   50.8741341,         -10.
   8437,   28.1673393,   50.9032707,         -10.
   8438,   29.0759621,   50.9324112,         -10.
   8439,   20.8661308,   51.3396492,         -10.
   8440,   21.7733536,   51.3978958,         -10.
   8441,   22.6805763,   51.4561424,         -10.
   8442,    23.587801,   51.5143852,         -10.
   8443,   24.4950237,   51.5726318,         -10.
   8444,   25.4022465,   51.6308784,         -10.
   8445,   26.3094692,   51.6891251,         -10.
   8446,    27.216692,   51.7473679,         -10.
   8447,   28.1239147,   51.8056145,         -10.
   8448,   29.0311394,   51.8638611,         -10.
   8449,   20.8124733,   52.0077553,         -10.
   8450,   21.7173634,    52.095047,         -10.
   8451,   22.6222534,   52.1823425,         -10.
   8452,   23.5271435,   52.2696342,         -10.
   8453,   24.4320335,   52.3569298,         -10.
   8454,   25.3369236,   52.4442215,         -10.
   8455,   26.2418137,    52.531517,         -10.
   8456,   27.1467037,   52.6188087,         -10.
   8457,   28.0515938,   52.7061043,         -10.
   8458,   28.9564838,    52.793396,         -10.
   8459,   20.7374268,   52.6737938,         -10.
   8460,   21.6390553,   52.7900467,         -10.
   8461,   22.5406818,   52.9062996,         -10.
   8462,   23.4423103,   53.0225525,         -10.
   8463,   24.3439369,   53.1388016,         -10.
   8464,   25.2455635,   53.2550545,         -10.
   8465,    26.147192,   53.3713074,         -10.
   8466,   27.0488186,   53.4875603,         -10.
   8467,   27.9504452,   53.6038094,         -10.
   8468,   28.8520737,   53.7200623,         -10.
   8469,   20.6410732,   53.3370895,         -10.
   8470,   21.5385113,   53.4821777,         -10.
   8471,   22.4359493,   53.6272697,         -10.
   8472,   23.3333874,   53.7723618,         -10.
   8473,   24.2308254,   53.9174538,         -10.
   8474,   25.1282635,    54.062542,         -10.
   8475,   26.0257015,    54.207634,         -10.
   8476,   26.9231396,    54.352726,         -10.
   8477,   27.8205776,   54.4978142,         -10.
   8478,   28.7180157,   54.6429062,         -10.
   8479,     20.52351,   53.9969521,         -10.
   8480,   21.4158363,   54.1707344,         -10.
   8481,   22.3081627,   54.3445129,         -10.
   8482,    23.200489,   54.5182953,         -10.
   8483,   24.0928154,   54.6920738,         -10.
   8484,   24.9851418,   54.8658562,         -10.
   8485,   25.8774681,   55.0396347,         -10.
   8486,   26.7697945,   55.2134171,         -10.
   8487,   27.6621208,   55.3871994,         -10.
   8488,   28.5544491,   55.5609779,         -10.
   8489,   20.3848572,     54.65271,         -10.
   8490,   21.2711544,   54.8550034,         -10.
   8491,   22.1574516,   55.0572929,         -10.
   8492,   23.0437508,   55.2595863,         -10.
   8493,    23.930048,   55.4618759,         -10.
   8494,   24.8163471,   55.6641693,         -10.
   8495,   25.7026443,   55.8664627,         -10.
   8496,   26.5889435,   56.0687523,         -10.
   8497,   27.4752407,   56.2710457,         -10.
   8498,   28.3615398,   56.4733353,         -10.
   8499,    20.225256,    55.303688,         -10.
   8500,   21.1046143,   55.5342827,         -10.
   8501,   21.9839745,   55.7648773,         -10.
   8502,   22.8633327,    55.995472,         -10.
   8503,   23.7426929,   56.2260666,         -10.
   8504,   24.6220512,   56.4566612,         -10.
   8505,   25.5014095,   56.6872559,         -10.
   8506,   26.3807697,   56.9178505,         -10.
   8507,    27.260128,   57.1484489,         -10.
   8508,   28.1394863,   57.3790436,         -10.
   8509,   20.0448742,   55.9492149,         -10.
   8510,   20.9163895,   56.2078743,         -10.
   8511,   21.7879066,   56.4665375,         -10.
   8512,   22.6594219,   56.7251968,         -10.
   8513,   23.5309391,     56.98386,         -10.
   8514,   24.4024544,   57.2425194,         -10.
   8515,   25.2739716,   57.5011826,         -10.
   8516,   26.1454868,   57.7598419,         -10.
   8517,    27.017004,   58.0185051,         -10.
   8518,   27.8885193,   58.2771645,         -10.
   8519,   19.8438931,   56.5886269,         -10.
   8520,   20.7066708,   56.8750877,         -10.
   8521,   21.5694485,   57.1615486,         -10.
   8522,   22.4322262,   57.4480133,         -10.
   8523,   23.2950039,   57.7344742,         -10.
   8524,   24.1577835,   58.0209351,         -10.
   8525,   25.0205612,   58.3073997,         -10.
   8526,   25.8833389,   58.5938606,         -10.
   8527,   26.7461166,   58.8803215,         -10.
   8528,   27.6088943,   59.1667862,         -10.
   8529,   19.6225224,   57.2212677,         -10.
   8530,   20.4756756,   57.5352364,         -10.
   8531,   21.3288269,    57.849205,         -10.
   8532,   22.1819801,   58.1631737,         -10.
   8533,   23.0351334,   58.4771423,         -10.
   8534,   23.8882866,    58.791111,         -10.
   8535,   24.7414398,   59.1050797,         -10.
   8536,    25.594593,   59.4190483,         -10.
   8537,   26.4477463,    59.733017,         -10.
   8538,   27.3008995,   60.0469818,         -10.
   8539,   19.3809872,   57.8464928,         -10.
   8540,   20.2236385,    58.187645,         -10.
   8541,   21.0662899,   58.5287971,         -10.
   8542,   21.9089413,   58.8699455,         -10.
   8543,   22.7515926,   59.2110977,         -10.
   8544,    23.594244,   59.5522499,         -10.
   8545,   24.4368973,   59.8934021,         -10.
   8546,   25.2795486,   60.2345543,         -10.
   8547,      26.1222,   60.5757065,         -10.
   8548,   26.9648514,   60.9168587,         -10.
   8549,   19.1195374,   58.4636536,         -10.
   8550,   19.9508209,   58.8316383,         -10.
   8551,   20.7821045,   59.1996231,         -10.
   8552,     21.61339,   59.5676079,         -10.
   8553,   22.4446735,   59.9355927,         -10.
   8554,   23.2759571,   60.3035774,         -10.
   8555,   24.1072426,   60.6715622,         -10.
   8556,   24.9385262,    61.039547,         -10.
   8557,   25.7698097,   61.4075317,         -10.
   8558,   26.6010952,   61.7755165,         -10.
   8559,   18.8384399,    59.072113,         -10.
   8560,   19.6575031,   59.4665527,         -10.
   8561,   20.4765644,   59.8609924,         -10.
   8562,   21.2956276,   60.2554321,         -10.
   8563,   22.1146908,   60.6498718,         -10.
   8564,   22.9337521,   61.0443115,         -10.
   8565,   23.7528152,   61.4387512,         -10.
   8566,   24.5718784,   61.8331947,         -10.
   8567,   25.3909416,   62.2276344,         -10.
   8568,   26.2100029,   62.6220741,         -10.
   8569,   18.5379848,    59.671257,         -10.
   8570,   19.3439846,   60.0917435,         -10.
   8571,   20.1499844,   60.5122337,         -10.
   8572,   20.9559841,    60.932724,         -10.
   8573,   21.7619839,   61.3532143,         -10.
   8574,   22.5679817,   61.7737007,         -10.
   8575,   23.3739815,    62.194191,         -10.
   8576,   24.1799812,   62.6146812,         -10.
   8577,    24.985981,   63.0351715,         -10.
   8578,   25.7919807,    63.455658,         -10.
   8579,   18.2184811,   60.2604561,         -10.
   8580,   19.0105896,   60.7065659,         -10.
   8581,   19.8026981,   61.1526718,         -10.
   8582,   20.5948067,   61.5987778,         -10.
   8583,   21.3869133,   62.0448837,         -10.
   8584,   22.1790218,   62.4909935,         -10.
   8585,   22.9711304,   62.9370995,         -10.
   8586,    23.763237,   63.3832054,         -10.
   8587,   24.5553455,   63.8293114,         -10.
   8588,   25.3474541,   64.2754211,         -10.
   8589,   17.8802586,    60.839119,         -10.
   8590,   18.6576595,   61.3103828,         -10.
   8591,   19.4350624,   61.7816505,         -10.
   8592,   20.2124653,   62.2529144,         -10.
   8593,   20.9898682,   62.7241821,         -10.
   8594,    21.767271,    63.195446,         -10.
   8595,    22.544672,   63.6667137,         -10.
   8596,   23.3220749,   64.1379776,         -10.
   8597,   24.0994778,   64.6092453,         -10.
   8598,   24.8768806,    65.080513,         -10.
   8599,   17.5236607,   61.4066391,         -10.
   8600,   18.2855587,   61.9025803,         -10.
   8601,   19.0474567,   62.3985214,         -10.
   8602,   19.8093548,   62.8944626,         -10.
   8603,   20.5712528,   63.3904037,         -10.
   8604,   21.3331509,   63.8863411,         -10.
   8605,   22.0950508,   64.3822861,         -10.
   8606,   22.8569489,   64.8782272,         -10.
   8607,   23.6188469,   65.3741684,         -10.
   8608,   24.3807449,   65.8701096,         -10.
   8609,   17.1490555,   61.9624405,         -10.
   8610,   17.8946667,   62.4825439,         -10.
   8611,   18.6402779,   63.0026512,         -10.
   8612,   19.3858891,   63.5227585,         -10.
   8613,   20.1315002,   64.0428619,         -10.
   8614,   20.8771114,    64.562973,         -10.
   8615,   21.6227226,   65.0830765,         -10.
   8616,   22.3683338,   65.6031799,         -10.
   8617,    23.113945,    66.123291,         -10.
   8618,   23.8595562,   66.6433945,         -10.
   8619,   16.7568302,   62.5059471,         -10.
   8620,   17.4853878,   63.0496826,         -10.
   8621,   18.2139454,   63.5934219,         -10.
   8622,    18.942503,   64.1371613,         -10.
   8623,   19.6710625,   64.6808929,         -10.
   8624,   20.3996201,   65.2246323,         -10.
   8625,   21.1281776,   65.7683716,         -10.
   8626,   21.8567352,   66.3121033,         -10.
   8627,   22.5852928,   66.8558426,         -10.
   8628,   23.3138504,   67.3995819,         -10.
   8629,   16.3473854,   63.0366058,         -10.
   8630,   17.0581417,   63.6034126,         -10.
   8631,    17.768898,   64.1702194,         -10.
   8632,   18.4796524,     64.73703,         -10.
   8633,   19.1904087,   65.3038406,         -10.
   8634,    19.901165,   65.8706512,         -10.
   8635,   20.6119213,   66.4374619,         -10.
   8636,   21.3226776,   67.0042648,         -10.
   8637,    22.033432,   67.5710754,         -10.
   8638,   22.7441883,    68.137886,         -10.
   8639,   15.9211426,   63.5538673,         -10.
   8640,   16.6133671,   64.1431656,         -10.
   8641,   17.3055897,     64.73246,         -10.
   8642,   17.9978142,   65.3217621,         -10.
   8643,   18.6900368,   65.9110641,         -10.
   8644,   19.3822613,   66.5003586,         -10.
   8645,   20.0744839,   67.0896606,         -10.
   8646,   20.7667084,   67.6789551,         -10.
   8647,    21.458931,   68.2682571,         -10.
   8648,   22.1511555,   68.8575516,         -10.
   8649,   15.4785395,   64.0571976,         -10.
   8650,   16.1515198,   64.6683807,         -10.
   8651,   16.8244991,   65.2795639,         -10.
   8652,   17.4974804,   65.8907471,         -10.
   8653,   18.1704597,   66.5019302,         -10.
   8654,   18.8434391,   67.1131134,         -10.
   8655,   19.5164204,   67.7242966,         -10.
   8656,   20.1893997,   68.3354797,         -10.
   8657,   20.8623791,   68.9466629,         -10.
   8658,   21.5353603,   69.5578461,         -10.
   8659,   15.0200319,   64.5460892,         -10.
   8660,   15.6730766,   65.1785278,         -10.
   8661,   16.3261223,   65.8109665,         -10.
   8662,    16.979166,   66.4434052,         -10.
   8663,   17.6322117,   67.0758438,         -10.
   8664,   18.2852554,   67.7082825,         -10.
   8665,   18.9383011,   68.3407211,         -10.
   8666,   19.5913467,   68.9731598,         -10.
   8667,   20.2443905,   69.6055984,         -10.
   8668,   20.8974361,   70.2380371,         -10.
   8669,   14.5460901,   65.0200348,         -10.
   8670,   15.1785288,   65.6730804,         -10.
   8671,   15.8109674,   66.3261185,         -10.
   8672,   16.4434052,   66.9791641,         -10.
   8673,   17.0758438,   67.6322098,         -10.
   8674,   17.7082825,   68.2852554,         -10.
   8675,   18.3407211,   68.9383011,         -10.
   8676,   18.9731598,   69.5913467,         -10.
   8677,   19.6055984,   70.2443924,         -10.
   8678,   20.2380371,    70.897438,         -10.
   8679,   14.0572004,   65.4785385,         -10.
   8680,   14.6683826,   66.1515198,         -10.
   8681,   15.2795658,    66.824501,         -10.
   8682,    15.890748,   67.4974823,         -10.
   8683,   16.5019302,   68.1704636,         -10.
   8684,   17.1131134,   68.8434372,         -10.
   8685,   17.7242966,   69.5164185,         -10.
   8686,   18.3354797,   70.1893997,         -10.
   8687,    18.946661,    70.862381,         -10.
   8688,   19.5578442,   71.5353622,         -10.
   8689,   13.5538664,   65.9211426,         -10.
   8690,   14.1431646,   66.6133652,         -10.
   8691,   14.7324638,   67.3055878,         -10.
   8692,   15.3217621,   67.9978104,         -10.
   8693,   15.9110603,   68.6900406,         -10.
   8694,   16.5003586,   69.3822632,         -10.
   8695,   17.0896568,   70.0744858,         -10.
   8696,    17.678957,   70.7667084,         -10.
   8697,   18.2682552,    71.458931,         -10.
   8698,   18.8575535,   72.1511536,         -10.
   8699,   13.0366049,   66.3473892,         -10.
   8700,   13.6034136,   67.0581436,         -10.
   8701,   14.1702232,    67.768898,         -10.
   8702,   14.7370319,   68.4796524,         -10.
   8703,   15.3038406,   69.1904068,         -10.
   8704,   15.8706493,   69.9011612,         -10.
   8705,    16.437458,   70.6119232,         -10.
   8706,   17.0042667,   71.3226776,         -10.
   8707,   17.5710754,    72.033432,         -10.
   8708,    18.137886,   72.7441864,         -10.
   8709,   12.5059471,   66.7568283,         -10.
   8710,   13.0496845,   67.4853897,         -10.
   8711,    13.593421,   68.2139435,         -10.
   8712,   14.1371584,   68.9425049,         -10.
   8713,   14.6808949,   69.6710587,         -10.
   8714,   15.2246313,   70.3996201,         -10.
   8715,   15.7683687,   71.1281738,         -10.
   8716,   16.3121052,   71.8567352,         -10.
   8717,   16.8558426,   72.5852966,         -10.
   8718,     17.39958,   73.3138504,         -10.
   8719,   11.9624395,   67.1490555,         -10.
   8720,   12.4825449,   67.8946686,         -10.
   8721,   13.0026512,   68.6402817,         -10.
   8722,   13.5227575,   69.3858871,         -10.
   8723,   14.0428638,   70.1315002,         -10.
   8724,   14.5629692,   70.8771133,         -10.
   8725,   15.0830755,   71.6227264,         -10.
   8726,   15.6031818,   72.3683319,         -10.
   8727,   16.1232872,    73.113945,         -10.
   8728,   16.6433945,   73.8595581,         -10.
   8729,   11.4066391,   67.5236588,         -10.
   8730,   11.9025793,   68.2855606,         -10.
   8731,   12.3985205,   69.0474548,         -10.
   8732,   12.8944616,   69.8093567,         -10.
   8733,   13.3904018,   70.5712509,         -10.
   8734,    13.886343,   71.3331528,         -10.
   8735,   14.3822842,    72.095047,         -10.
   8736,   14.8782244,   72.8569489,         -10.
   8737,   15.3741655,   73.6188431,         -10.
   8738,   15.8701057,   74.3807449,         -10.
   8739,   10.8391171,   67.8802567,         -10.
   8740,   11.3103828,   68.6576614,         -10.
   8741,   11.7816496,   69.4350662,         -10.
   8742,   12.2529154,   70.2124634,         -10.
   8743,   12.7241812,   70.9898682,         -10.
   8744,    13.195447,   71.7672729,         -10.
   8745,   13.6667128,   72.5446701,         -10.
   8746,   14.1379795,   73.3220749,         -10.
   8747,   14.6092453,   74.0994797,         -10.
   8748,   15.0805111,   74.8768768,         -10.
   8749,    10.260458,    68.218483,         -10.
   8750,   10.7065649,   69.0105896,         -10.
   8751,   11.1526718,   69.8026962,         -10.
   8752,   11.5987787,   70.5948029,         -10.
   8753,   12.0448856,   71.3869171,         -10.
   8754,   12.4909925,   72.1790237,         -10.
   8755,   12.9370995,   72.9711304,         -10.
   8756,   13.3832064,    73.763237,         -10.
   8757,   13.8293133,   74.5553436,         -10.
   8758,   14.2754192,   75.3474503,         -10.
   8759,   9.67125511,   68.5379868,         -10.
   8760,   10.0917444,   69.3439865,         -10.
   8761,   10.5122337,   70.1499863,         -10.
   8762,    10.932723,    70.955986,         -10.
   8763,   11.3532124,   71.7619858,         -10.
   8764,   11.7737017,   72.5679855,         -10.
   8765,    12.194191,   73.3739853,         -10.
   8766,   12.6146803,   74.1799774,         -10.
   8767,   13.0351696,   74.9859772,         -10.
   8768,   13.4556589,   75.7919769,         -10.
   8769,   9.07211494,   68.8384399,         -10.
   8770,   9.46655464,   69.6575012,         -10.
   8771,   9.86099434,   70.4765625,         -10.
   8772,    10.255434,   71.2956314,         -10.
   8773,   10.6498737,   72.1146927,         -10.
   8774,   11.0443134,    72.933754,         -10.
   8775,   11.4387531,   73.7528152,         -10.
   8776,   11.8331928,   74.5718765,         -10.
   8777,   12.2276325,   75.3909378,         -10.
   8778,   12.6220722,   76.2100067,         -10.
   8779,   8.46365166,   69.1195374,         -10.
   8780,   8.83163643,   69.9508209,         -10.
   8781,    9.1996212,   70.7821045,         -10.
   8782,   9.56760597,   71.6133881,         -10.
   8783,   9.93559074,   72.4446716,         -10.
   8784,   10.3035765,   73.2759552,         -10.
   8785,   10.6715612,   74.1072388,         -10.
   8786,    11.039546,   74.9385223,         -10.
   8787,   11.4075308,   75.7698135,         -10.
   8788,   11.7755156,   76.6010971,         -10.
   8789,   7.84649181,   69.3809891,         -10.
   8790,     8.187644,   70.2236404,         -10.
   8791,   8.52879524,   71.0662918,         -10.
   8792,   8.86994743,   71.9089432,         -10.
   8793,   9.21109962,   72.7515945,         -10.
   8794,   9.55225086,   73.5942459,         -10.
   8795,   9.89340305,   74.4368973,         -10.
   8796,   10.2345543,   75.2795486,         -10.
   8797,   10.5757065,      76.1222,         -10.
   8798,   10.9168587,   76.9648514,         -10.
   8799,   7.22126913,   69.6225204,         -10.
   8800,   7.53523779,   70.4756775,         -10.
   8801,   7.84920597,   71.3288269,         -10.
   8802,   8.16317368,   72.1819839,         -10.
   8803,   8.47714233,   73.0351334,         -10.
   8804,   8.79111004,   73.8882904,         -10.
   8805,    9.1050787,   74.7414398,         -10.
   8806,   9.41904736,   75.5945969,         -10.
   8807,   9.73301506,   76.4477463,         -10.
   8808,   10.0469837,   77.3009033,         -10.
   8809,   6.58862638,    69.843895,         -10.
   8810,   6.87508821,   70.7066727,         -10.
   8811,   7.16155052,   71.5694504,         -10.
   8812,   7.44801235,   72.4322281,         -10.
   8813,   7.73447466,   73.2950058,         -10.
   8814,   8.02093601,   74.1577835,         -10.
   8815,    8.3073988,   75.0205612,         -10.
   8816,   8.59386063,   75.8833389,         -10.
   8817,   8.88032246,   76.7461166,         -10.
   8818,   9.16678429,   77.6088943,         -10.
   8819,   5.94921303,   70.0448761,         -10.
   8820,   6.20787477,   70.9163895,         -10.
   8821,   6.46653605,   71.7879028,         -10.
   8822,   6.72519732,   72.6594238,         -10.
   8823,   6.98385906,   73.5309372,         -10.
   8824,   7.24252033,   74.4024582,         -10.
   8825,    7.5011816,   75.2739716,         -10.
   8826,   7.75984335,   76.1454849,         -10.
   8827,    8.0185051,   77.0170059,         -10.
   8828,   8.27716637,   77.8885193,         -10.
   8829,   5.30368662,   70.2252579,         -10.
   8830,   5.53428173,   71.1046143,         -10.
   8831,   5.76487684,   71.9839706,         -10.
   8832,   5.99547195,   72.8633347,         -10.
   8833,   6.22606707,    73.742691,         -10.
   8834,   6.45666218,   74.6220474,         -10.
   8835,   6.68725729,   75.5014114,         -10.
   8836,    6.9178524,   76.3807678,         -10.
   8837,   7.14844751,   77.2601242,         -10.
   8838,   7.37904263,   78.1394882,         -10.
   8839,   4.65271044,   70.3848572,         -10.
   8840,    4.8550024,   71.2711563,         -10.
   8841,   5.05729389,   72.1574554,         -10.
   8842,   5.25958586,   73.0437469,         -10.
   8843,   5.46187735,   73.9300461,         -10.
   8844,   5.66416931,   74.8163452,         -10.
   8845,    5.8664608,   75.7026443,         -10.
   8846,   6.06875277,   76.5889435,         -10.
   8847,   6.27104473,   77.4752426,         -10.
   8848,   6.47333622,   78.3615417,         -10.
   8849,   3.99695325,   70.5235062,         -10.
   8850,   4.17073393,   71.4158325,         -10.
   8851,   4.34451437,   72.3081589,         -10.
   8852,   4.51829481,   73.2004929,         -10.
   8853,   4.69207525,   74.0928192,         -10.
   8854,   4.86585617,   74.9851456,         -10.
   8855,   5.03963661,   75.8774719,         -10.
   8856,   5.21341705,   76.7697983,         -10.
   8857,   5.38719749,   77.6621246,         -10.
   8858,   5.56097841,    78.554451,         -10.
   8859,   3.33708882,   70.6410751,         -10.
   8860,   3.48217964,   71.5385132,         -10.
   8861,   3.62727046,   72.4359512,         -10.
   8862,   3.77236104,   73.3333893,         -10.
   8863,   3.91745186,   74.2308273,         -10.
   8864,   4.06254292,   75.1282654,         -10.
   8865,    4.2076335,   76.0257034,         -10.
   8866,   4.35272455,   76.9231415,         -10.
   8867,   4.49781513,   77.8205795,         -10.
   8868,   4.64290619,   78.7180176,         -10.
   8869,   2.67379522,   70.7374268,         -10.
   8870,   2.79004717,   71.6390533,         -10.
   8871,   2.90629911,   72.5406799,         -10.
   8872,   3.02255106,   73.4423065,         -10.
   8873,   3.13880301,   74.3439331,         -10.
   8874,   3.25505495,   75.2455673,         -10.
   8875,    3.3713069,   76.1471939,         -10.
   8876,   3.48755884,   77.0488205,         -10.
   8877,   3.60381103,   77.9504471,         -10.
   8878,   3.72006297,   78.8520737,         -10.
   8879,   2.00775409,   70.8124695,         -10.
   8880,   2.09504795,   71.7173615,         -10.
   8881,   2.18234158,   72.6222534,         -10.
   8882,    2.2696352,   73.5271454,         -10.
   8883,   2.35692883,   74.4320297,         -10.
   8884,   2.44422245,   75.3369217,         -10.
   8885,   2.53151608,   76.2418137,         -10.
   8886,    2.6188097,   77.1467056,         -10.
   8887,   2.70610356,     78.05159,         -10.
   8888,   2.79339719,   78.9564819,         -10.
   8889,   1.33965003,   70.8661346,         -10.
   8890,   1.39789569,   71.7733536,         -10.
   8891,   1.45614135,   72.6805801,         -10.
   8892,   1.51438701,   73.5877991,         -10.
   8893,   1.57263267,   74.4950256,         -10.
   8894,   1.63087833,   75.4022446,         -10.
   8895,   1.68912399,   76.3094711,         -10.
   8896,   1.74736965,   77.2166901,         -10.
   8897,   1.80561531,   78.1239166,         -10.
   8898,   1.86386096,   79.0311356,         -10.
   8899,  0.670169353,   70.8983459,         -10.
   8900,  0.699307144,   71.8069687,         -10.
   8901,  0.728444934,   72.7155991,         -10.
   8902,  0.757582724,   73.6242218,         -10.
   8903,  0.786720514,   74.5328445,         -10.
   8904,  0.815858364,   75.4414673,         -10.
   8905,  0.844996154,     76.35009,         -10.
   8906,  0.874133945,   77.2587128,         -10.
   8907,  0.903271735,   78.1673355,         -10.
   8908,  0.932409525,   79.0759659,         -10.
   8909,           0.,   70.9090881,         -10.
   8910,           0.,   71.8181839,         -10.
   8911,           0.,    72.727272,         -10.
   8912,           0.,   73.6363602,         -10.
   8913,           0.,   74.5454559,         -10.
   8914,           0.,   75.4545441,         -10.
   8915,           0.,   76.3636398,         -10.
   8916,           0.,    77.272728,         -10.
   8917,           0.,   78.1818161,         -10.
   8918,           0.,   79.0909119,         -10.
   8919, -0.670169353,   70.8983459,         -10.
   8920, -0.699307144,   71.8069687,         -10.
   8921, -0.728444934,   72.7155991,         -10.
   8922, -0.757582724,   73.6242218,         -10.
   8923, -0.786720514,   74.5328445,         -10.
   8924, -0.815858364,   75.4414673,         -10.
   8925, -0.844996154,     76.35009,         -10.
   8926, -0.874133945,   77.2587128,         -10.
   8927, -0.903271735,   78.1673355,         -10.
   8928, -0.932409525,   79.0759659,         -10.
   8929,  -1.33965003,   70.8661346,         -10.
   8930,  -1.39789569,   71.7733536,         -10.
   8931,  -1.45614135,   72.6805801,         -10.
   8932,  -1.51438701,   73.5877991,         -10.
   8933,  -1.57263267,   74.4950256,         -10.
   8934,  -1.63087833,   75.4022446,         -10.
   8935,  -1.68912399,   76.3094711,         -10.
   8936,  -1.74736965,   77.2166901,         -10.
   8937,  -1.80561531,   78.1239166,         -10.
   8938,  -1.86386096,   79.0311356,         -10.
   8939,  -2.00775409,   70.8124695,         -10.
   8940,  -2.09504795,   71.7173615,         -10.
   8941,  -2.18234158,   72.6222534,         -10.
   8942,   -2.2696352,   73.5271454,         -10.
   8943,  -2.35692883,   74.4320297,         -10.
   8944,  -2.44422245,   75.3369217,         -10.
   8945,  -2.53151608,   76.2418137,         -10.
   8946,   -2.6188097,   77.1467056,         -10.
   8947,  -2.70610356,     78.05159,         -10.
   8948,  -2.79339719,   78.9564819,         -10.
   8949,  -2.67379522,   70.7374268,         -10.
   8950,  -2.79004717,   71.6390533,         -10.
   8951,  -2.90629911,   72.5406799,         -10.
   8952,  -3.02255106,   73.4423065,         -10.
   8953,  -3.13880301,   74.3439331,         -10.
   8954,  -3.25505495,   75.2455673,         -10.
   8955,   -3.3713069,   76.1471939,         -10.
   8956,  -3.48755884,   77.0488205,         -10.
   8957,  -3.60381103,   77.9504471,         -10.
   8958,  -3.72006297,   78.8520737,         -10.
   8959,  -3.33708882,   70.6410751,         -10.
   8960,  -3.48217964,   71.5385132,         -10.
   8961,  -3.62727046,   72.4359512,         -10.
   8962,  -3.77236104,   73.3333893,         -10.
   8963,  -3.91745186,   74.2308273,         -10.
   8964,  -4.06254292,   75.1282654,         -10.
   8965,   -4.2076335,   76.0257034,         -10.
   8966,  -4.35272455,   76.9231415,         -10.
   8967,  -4.49781513,   77.8205795,         -10.
   8968,  -4.64290619,   78.7180176,         -10.
   8969,  -3.99695325,   70.5235062,         -10.
   8970,  -4.17073393,   71.4158325,         -10.
   8971,  -4.34451437,   72.3081589,         -10.
   8972,  -4.51829481,   73.2004929,         -10.
   8973,  -4.69207525,   74.0928192,         -10.
   8974,  -4.86585617,   74.9851456,         -10.
   8975,  -5.03963661,   75.8774719,         -10.
   8976,  -5.21341705,   76.7697983,         -10.
   8977,  -5.38719749,   77.6621246,         -10.
   8978,  -5.56097841,    78.554451,         -10.
   8979,  -4.65271044,   70.3848572,         -10.
   8980,   -4.8550024,   71.2711563,         -10.
   8981,  -5.05729389,   72.1574554,         -10.
   8982,  -5.25958586,   73.0437469,         -10.
   8983,  -5.46187735,   73.9300461,         -10.
   8984,  -5.66416931,   74.8163452,         -10.
   8985,   -5.8664608,   75.7026443,         -10.
   8986,  -6.06875277,   76.5889435,         -10.
   8987,  -6.27104473,   77.4752426,         -10.
   8988,  -6.47333622,   78.3615417,         -10.
   8989,  -5.30368662,   70.2252579,         -10.
   8990,  -5.53428173,   71.1046143,         -10.
   8991,  -5.76487684,   71.9839706,         -10.
   8992,  -5.99547195,   72.8633347,         -10.
   8993,  -6.22606707,    73.742691,         -10.
   8994,  -6.45666218,   74.6220474,         -10.
   8995,  -6.68725729,   75.5014114,         -10.
   8996,   -6.9178524,   76.3807678,         -10.
   8997,  -7.14844751,   77.2601242,         -10.
   8998,  -7.37904263,   78.1394882,         -10.
   8999,  -5.94921303,   70.0448761,         -10.
   9000,  -6.20787477,   70.9163895,         -10.
   9001,  -6.46653605,   71.7879028,         -10.
   9002,  -6.72519732,   72.6594238,         -10.
   9003,  -6.98385906,   73.5309372,         -10.
   9004,  -7.24252033,   74.4024582,         -10.
   9005,   -7.5011816,   75.2739716,         -10.
   9006,  -7.75984335,   76.1454849,         -10.
   9007,   -8.0185051,   77.0170059,         -10.
   9008,  -8.27716637,   77.8885193,         -10.
   9009,  -6.58862638,    69.843895,         -10.
   9010,  -6.87508821,   70.7066727,         -10.
   9011,  -7.16155052,   71.5694504,         -10.
   9012,  -7.44801235,   72.4322281,         -10.
   9013,  -7.73447466,   73.2950058,         -10.
   9014,  -8.02093601,   74.1577835,         -10.
   9015,   -8.3073988,   75.0205612,         -10.
   9016,  -8.59386063,   75.8833389,         -10.
   9017,  -8.88032246,   76.7461166,         -10.
   9018,  -9.16678429,   77.6088943,         -10.
   9019,  -7.22126913,   69.6225204,         -10.
   9020,  -7.53523779,   70.4756775,         -10.
   9021,  -7.84920597,   71.3288269,         -10.
   9022,  -8.16317368,   72.1819839,         -10.
   9023,  -8.47714233,   73.0351334,         -10.
   9024,  -8.79111004,   73.8882904,         -10.
   9025,   -9.1050787,   74.7414398,         -10.
   9026,  -9.41904736,   75.5945969,         -10.
   9027,  -9.73301506,   76.4477463,         -10.
   9028,  -10.0469837,   77.3009033,         -10.
   9029,  -7.84649181,   69.3809891,         -10.
   9030,    -8.187644,   70.2236404,         -10.
   9031,  -8.52879524,   71.0662918,         -10.
   9032,  -8.86994743,   71.9089432,         -10.
   9033,  -9.21109962,   72.7515945,         -10.
   9034,  -9.55225086,   73.5942459,         -10.
   9035,  -9.89340305,   74.4368973,         -10.
   9036,  -10.2345543,   75.2795486,         -10.
   9037,  -10.5757065,      76.1222,         -10.
   9038,  -10.9168587,   76.9648514,         -10.
   9039,  -8.46365166,   69.1195374,         -10.
   9040,  -8.83163643,   69.9508209,         -10.
   9041,   -9.1996212,   70.7821045,         -10.
   9042,  -9.56760597,   71.6133881,         -10.
   9043,  -9.93559074,   72.4446716,         -10.
   9044,  -10.3035765,   73.2759552,         -10.
   9045,  -10.6715612,   74.1072388,         -10.
   9046,   -11.039546,   74.9385223,         -10.
   9047,  -11.4075308,   75.7698135,         -10.
   9048,  -11.7755156,   76.6010971,         -10.
   9049,  -9.07211494,   68.8384399,         -10.
   9050,  -9.46655464,   69.6575012,         -10.
   9051,  -9.86099434,   70.4765625,         -10.
   9052,   -10.255434,   71.2956314,         -10.
   9053,  -10.6498737,   72.1146927,         -10.
   9054,  -11.0443134,    72.933754,         -10.
   9055,  -11.4387531,   73.7528152,         -10.
   9056,  -11.8331928,   74.5718765,         -10.
   9057,  -12.2276325,   75.3909378,         -10.
   9058,  -12.6220722,   76.2100067,         -10.
   9059,  -9.67125511,   68.5379868,         -10.
   9060,  -10.0917444,   69.3439865,         -10.
   9061,  -10.5122337,   70.1499863,         -10.
   9062,   -10.932723,    70.955986,         -10.
   9063,  -11.3532124,   71.7619858,         -10.
   9064,  -11.7737017,   72.5679855,         -10.
   9065,   -12.194191,   73.3739853,         -10.
   9066,  -12.6146803,   74.1799774,         -10.
   9067,  -13.0351696,   74.9859772,         -10.
   9068,  -13.4556589,   75.7919769,         -10.
   9069,   -10.260458,    68.218483,         -10.
   9070,  -10.7065649,   69.0105896,         -10.
   9071,  -11.1526718,   69.8026962,         -10.
   9072,  -11.5987787,   70.5948029,         -10.
   9073,  -12.0448856,   71.3869171,         -10.
   9074,  -12.4909925,   72.1790237,         -10.
   9075,  -12.9370995,   72.9711304,         -10.
   9076,  -13.3832064,    73.763237,         -10.
   9077,  -13.8293133,   74.5553436,         -10.
   9078,  -14.2754192,   75.3474503,         -10.
   9079,  -10.8391171,   67.8802567,         -10.
   9080,  -11.3103828,   68.6576614,         -10.
   9081,  -11.7816496,   69.4350662,         -10.
   9082,  -12.2529154,   70.2124634,         -10.
   9083,  -12.7241812,   70.9898682,         -10.
   9084,   -13.195447,   71.7672729,         -10.
   9085,  -13.6667128,   72.5446701,         -10.
   9086,  -14.1379795,   73.3220749,         -10.
   9087,  -14.6092453,   74.0994797,         -10.
   9088,  -15.0805111,   74.8768768,         -10.
   9089,  -11.4066391,   67.5236588,         -10.
   9090,  -11.9025793,   68.2855606,         -10.
   9091,  -12.3985205,   69.0474548,         -10.
   9092,  -12.8944616,   69.8093567,         -10.
   9093,  -13.3904018,   70.5712509,         -10.
   9094,   -13.886343,   71.3331528,         -10.
   9095,  -14.3822842,    72.095047,         -10.
   9096,  -14.8782244,   72.8569489,         -10.
   9097,  -15.3741655,   73.6188431,         -10.
   9098,  -15.8701057,   74.3807449,         -10.
   9099,  -11.9624395,   67.1490555,         -10.
   9100,  -12.4825449,   67.8946686,         -10.
   9101,  -13.0026512,   68.6402817,         -10.
   9102,  -13.5227575,   69.3858871,         -10.
   9103,  -14.0428638,   70.1315002,         -10.
   9104,  -14.5629692,   70.8771133,         -10.
   9105,  -15.0830755,   71.6227264,         -10.
   9106,  -15.6031818,   72.3683319,         -10.
   9107,  -16.1232872,    73.113945,         -10.
   9108,  -16.6433945,   73.8595581,         -10.
   9109,  -12.5059471,   66.7568283,         -10.
   9110,  -13.0496845,   67.4853897,         -10.
   9111,   -13.593421,   68.2139435,         -10.
   9112,  -14.1371584,   68.9425049,         -10.
   9113,  -14.6808949,   69.6710587,         -10.
   9114,  -15.2246313,   70.3996201,         -10.
   9115,  -15.7683687,   71.1281738,         -10.
   9116,  -16.3121052,   71.8567352,         -10.
   9117,  -16.8558426,   72.5852966,         -10.
   9118,    -17.39958,   73.3138504,         -10.
   9119,  -13.0366049,   66.3473892,         -10.
   9120,  -13.6034136,   67.0581436,         -10.
   9121,  -14.1702232,    67.768898,         -10.
   9122,  -14.7370319,   68.4796524,         -10.
   9123,  -15.3038406,   69.1904068,         -10.
   9124,  -15.8706493,   69.9011612,         -10.
   9125,   -16.437458,   70.6119232,         -10.
   9126,  -17.0042667,   71.3226776,         -10.
   9127,  -17.5710754,    72.033432,         -10.
   9128,   -18.137886,   72.7441864,         -10.
   9129,  -13.5538664,   65.9211426,         -10.
   9130,  -14.1431646,   66.6133652,         -10.
   9131,  -14.7324638,   67.3055878,         -10.
   9132,  -15.3217621,   67.9978104,         -10.
   9133,  -15.9110603,   68.6900406,         -10.
   9134,  -16.5003586,   69.3822632,         -10.
   9135,  -17.0896568,   70.0744858,         -10.
   9136,   -17.678957,   70.7667084,         -10.
   9137,  -18.2682552,    71.458931,         -10.
   9138,  -18.8575535,   72.1511536,         -10.
   9139,  -14.0572004,   65.4785385,         -10.
   9140,  -14.6683826,   66.1515198,         -10.
   9141,  -15.2795658,    66.824501,         -10.
   9142,   -15.890748,   67.4974823,         -10.
   9143,  -16.5019302,   68.1704636,         -10.
   9144,  -17.1131134,   68.8434372,         -10.
   9145,  -17.7242966,   69.5164185,         -10.
   9146,  -18.3354797,   70.1893997,         -10.
   9147,   -18.946661,    70.862381,         -10.
   9148,  -19.5578442,   71.5353622,         -10.
   9149,  -14.5460901,   65.0200348,         -10.
   9150,  -15.1785288,   65.6730804,         -10.
   9151,  -15.8109674,   66.3261185,         -10.
   9152,  -16.4434052,   66.9791641,         -10.
   9153,  -17.0758438,   67.6322098,         -10.
   9154,  -17.7082825,   68.2852554,         -10.
   9155,  -18.3407211,   68.9383011,         -10.
   9156,  -18.9731598,   69.5913467,         -10.
   9157,  -19.6055984,   70.2443924,         -10.
   9158,  -20.2380371,    70.897438,         -10.
   9159,  -15.0200319,   64.5460892,         -10.
   9160,  -15.6730766,   65.1785278,         -10.
   9161,  -16.3261223,   65.8109665,         -10.
   9162,   -16.979166,   66.4434052,         -10.
   9163,  -17.6322117,   67.0758438,         -10.
   9164,  -18.2852554,   67.7082825,         -10.
   9165,  -18.9383011,   68.3407211,         -10.
   9166,  -19.5913467,   68.9731598,         -10.
   9167,  -20.2443905,   69.6055984,         -10.
   9168,  -20.8974361,   70.2380371,         -10.
   9169,  -15.4785395,   64.0571976,         -10.
   9170,  -16.1515198,   64.6683807,         -10.
   9171,  -16.8244991,   65.2795639,         -10.
   9172,  -17.4974804,   65.8907471,         -10.
   9173,  -18.1704597,   66.5019302,         -10.
   9174,  -18.8434391,   67.1131134,         -10.
   9175,  -19.5164204,   67.7242966,         -10.
   9176,  -20.1893997,   68.3354797,         -10.
   9177,  -20.8623791,   68.9466629,         -10.
   9178,  -21.5353603,   69.5578461,         -10.
   9179,  -15.9211426,   63.5538673,         -10.
   9180,  -16.6133671,   64.1431656,         -10.
   9181,  -17.3055897,     64.73246,         -10.
   9182,  -17.9978142,   65.3217621,         -10.
   9183,  -18.6900368,   65.9110641,         -10.
   9184,  -19.3822613,   66.5003586,         -10.
   9185,  -20.0744839,   67.0896606,         -10.
   9186,  -20.7667084,   67.6789551,         -10.
   9187,   -21.458931,   68.2682571,         -10.
   9188,  -22.1511555,   68.8575516,         -10.
   9189,  -16.3473854,   63.0366058,         -10.
   9190,  -17.0581417,   63.6034126,         -10.
   9191,   -17.768898,   64.1702194,         -10.
   9192,  -18.4796524,     64.73703,         -10.
   9193,  -19.1904087,   65.3038406,         -10.
   9194,   -19.901165,   65.8706512,         -10.
   9195,  -20.6119213,   66.4374619,         -10.
   9196,  -21.3226776,   67.0042648,         -10.
   9197,   -22.033432,   67.5710754,         -10.
   9198,  -22.7441883,    68.137886,         -10.
   9199,  -16.7568302,   62.5059471,         -10.
   9200,  -17.4853878,   63.0496826,         -10.
   9201,  -18.2139454,   63.5934219,         -10.
   9202,   -18.942503,   64.1371613,         -10.
   9203,  -19.6710625,   64.6808929,         -10.
   9204,  -20.3996201,   65.2246323,         -10.
   9205,  -21.1281776,   65.7683716,         -10.
   9206,  -21.8567352,   66.3121033,         -10.
   9207,  -22.5852928,   66.8558426,         -10.
   9208,  -23.3138504,   67.3995819,         -10.
   9209,  -17.1490555,   61.9624405,         -10.
   9210,  -17.8946667,   62.4825439,         -10.
   9211,  -18.6402779,   63.0026512,         -10.
   9212,  -19.3858891,   63.5227585,         -10.
   9213,  -20.1315002,   64.0428619,         -10.
   9214,  -20.8771114,    64.562973,         -10.
   9215,  -21.6227226,   65.0830765,         -10.
   9216,  -22.3683338,   65.6031799,         -10.
   9217,   -23.113945,    66.123291,         -10.
   9218,  -23.8595562,   66.6433945,         -10.
   9219,  -17.5236607,   61.4066391,         -10.
   9220,  -18.2855587,   61.9025803,         -10.
   9221,  -19.0474567,   62.3985214,         -10.
   9222,  -19.8093548,   62.8944626,         -10.
   9223,  -20.5712528,   63.3904037,         -10.
   9224,  -21.3331509,   63.8863411,         -10.
   9225,  -22.0950508,   64.3822861,         -10.
   9226,  -22.8569489,   64.8782272,         -10.
   9227,  -23.6188469,   65.3741684,         -10.
   9228,  -24.3807449,   65.8701096,         -10.
   9229,  -17.8802586,    60.839119,         -10.
   9230,  -18.6576595,   61.3103828,         -10.
   9231,  -19.4350624,   61.7816505,         -10.
   9232,  -20.2124653,   62.2529144,         -10.
   9233,  -20.9898682,   62.7241821,         -10.
   9234,   -21.767271,    63.195446,         -10.
   9235,   -22.544672,   63.6667137,         -10.
   9236,  -23.3220749,   64.1379776,         -10.
   9237,  -24.0994778,   64.6092453,         -10.
   9238,  -24.8768806,    65.080513,         -10.
   9239,  -18.2184811,   60.2604561,         -10.
   9240,  -19.0105896,   60.7065659,         -10.
   9241,  -19.8026981,   61.1526718,         -10.
   9242,  -20.5948067,   61.5987778,         -10.
   9243,  -21.3869133,   62.0448837,         -10.
   9244,  -22.1790218,   62.4909935,         -10.
   9245,  -22.9711304,   62.9370995,         -10.
   9246,   -23.763237,   63.3832054,         -10.
   9247,  -24.5553455,   63.8293114,         -10.
   9248,  -25.3474541,   64.2754211,         -10.
   9249,  -18.5379848,    59.671257,         -10.
   9250,  -19.3439846,   60.0917435,         -10.
   9251,  -20.1499844,   60.5122337,         -10.
   9252,  -20.9559841,    60.932724,         -10.
   9253,  -21.7619839,   61.3532143,         -10.
   9254,  -22.5679817,   61.7737007,         -10.
   9255,  -23.3739815,    62.194191,         -10.
   9256,  -24.1799812,   62.6146812,         -10.
   9257,   -24.985981,   63.0351715,         -10.
   9258,  -25.7919807,    63.455658,         -10.
   9259,  -18.8384399,    59.072113,         -10.
   9260,  -19.6575031,   59.4665527,         -10.
   9261,  -20.4765644,   59.8609924,         -10.
   9262,  -21.2956276,   60.2554321,         -10.
   9263,  -22.1146908,   60.6498718,         -10.
   9264,  -22.9337521,   61.0443115,         -10.
   9265,  -23.7528152,   61.4387512,         -10.
   9266,  -24.5718784,   61.8331947,         -10.
   9267,  -25.3909416,   62.2276344,         -10.
   9268,  -26.2100029,   62.6220741,         -10.
   9269,  -19.1195374,   58.4636536,         -10.
   9270,  -19.9508209,   58.8316383,         -10.
   9271,  -20.7821045,   59.1996231,         -10.
   9272,    -21.61339,   59.5676079,         -10.
   9273,  -22.4446735,   59.9355927,         -10.
   9274,  -23.2759571,   60.3035774,         -10.
   9275,  -24.1072426,   60.6715622,         -10.
   9276,  -24.9385262,    61.039547,         -10.
   9277,  -25.7698097,   61.4075317,         -10.
   9278,  -26.6010952,   61.7755165,         -10.
   9279,  -19.3809872,   57.8464928,         -10.
   9280,  -20.2236385,    58.187645,         -10.
   9281,  -21.0662899,   58.5287971,         -10.
   9282,  -21.9089413,   58.8699455,         -10.
   9283,  -22.7515926,   59.2110977,         -10.
   9284,   -23.594244,   59.5522499,         -10.
   9285,  -24.4368973,   59.8934021,         -10.
   9286,  -25.2795486,   60.2345543,         -10.
   9287,     -26.1222,   60.5757065,         -10.
   9288,  -26.9648514,   60.9168587,         -10.
   9289,  -19.6225224,   57.2212677,         -10.
   9290,  -20.4756756,   57.5352364,         -10.
   9291,  -21.3288269,    57.849205,         -10.
   9292,  -22.1819801,   58.1631737,         -10.
   9293,  -23.0351334,   58.4771423,         -10.
   9294,  -23.8882866,    58.791111,         -10.
   9295,  -24.7414398,   59.1050797,         -10.
   9296,   -25.594593,   59.4190483,         -10.
   9297,  -26.4477463,    59.733017,         -10.
   9298,  -27.3008995,   60.0469818,         -10.
   9299,  -19.8438931,   56.5886269,         -10.
   9300,  -20.7066708,   56.8750877,         -10.
   9301,  -21.5694485,   57.1615486,         -10.
   9302,  -22.4322262,   57.4480133,         -10.
   9303,  -23.2950039,   57.7344742,         -10.
   9304,  -24.1577835,   58.0209351,         -10.
   9305,  -25.0205612,   58.3073997,         -10.
   9306,  -25.8833389,   58.5938606,         -10.
   9307,  -26.7461166,   58.8803215,         -10.
   9308,  -27.6088943,   59.1667862,         -10.
   9309,  -20.0448742,   55.9492149,         -10.
   9310,  -20.9163895,   56.2078743,         -10.
   9311,  -21.7879066,   56.4665375,         -10.
   9312,  -22.6594219,   56.7251968,         -10.
   9313,  -23.5309391,     56.98386,         -10.
   9314,  -24.4024544,   57.2425194,         -10.
   9315,  -25.2739716,   57.5011826,         -10.
   9316,  -26.1454868,   57.7598419,         -10.
   9317,   -27.017004,   58.0185051,         -10.
   9318,  -27.8885193,   58.2771645,         -10.
   9319,   -20.225256,    55.303688,         -10.
   9320,  -21.1046143,   55.5342827,         -10.
   9321,  -21.9839745,   55.7648773,         -10.
   9322,  -22.8633327,    55.995472,         -10.
   9323,  -23.7426929,   56.2260666,         -10.
   9324,  -24.6220512,   56.4566612,         -10.
   9325,  -25.5014095,   56.6872559,         -10.
   9326,  -26.3807697,   56.9178505,         -10.
   9327,   -27.260128,   57.1484489,         -10.
   9328,  -28.1394863,   57.3790436,         -10.
   9329,  -20.3848572,     54.65271,         -10.
   9330,  -21.2711544,   54.8550034,         -10.
   9331,  -22.1574516,   55.0572929,         -10.
   9332,  -23.0437508,   55.2595863,         -10.
   9333,   -23.930048,   55.4618759,         -10.
   9334,  -24.8163471,   55.6641693,         -10.
   9335,  -25.7026443,   55.8664627,         -10.
   9336,  -26.5889435,   56.0687523,         -10.
   9337,  -27.4752407,   56.2710457,         -10.
   9338,  -28.3615398,   56.4733353,         -10.
   9339,    -20.52351,   53.9969521,         -10.
   9340,  -21.4158363,   54.1707344,         -10.
   9341,  -22.3081627,   54.3445129,         -10.
   9342,   -23.200489,   54.5182953,         -10.
   9343,  -24.0928154,   54.6920738,         -10.
   9344,  -24.9851418,   54.8658562,         -10.
   9345,  -25.8774681,   55.0396347,         -10.
   9346,  -26.7697945,   55.2134171,         -10.
   9347,  -27.6621208,   55.3871994,         -10.
   9348,  -28.5544491,   55.5609779,         -10.
   9349,  -20.6410732,   53.3370895,         -10.
   9350,  -21.5385113,   53.4821777,         -10.
   9351,  -22.4359493,   53.6272697,         -10.
   9352,  -23.3333874,   53.7723618,         -10.
   9353,  -24.2308254,   53.9174538,         -10.
   9354,  -25.1282635,    54.062542,         -10.
   9355,  -26.0257015,    54.207634,         -10.
   9356,  -26.9231396,    54.352726,         -10.
   9357,  -27.8205776,   54.4978142,         -10.
   9358,  -28.7180157,   54.6429062,         -10.
   9359,  -20.7374268,   52.6737938,         -10.
   9360,  -21.6390553,   52.7900467,         -10.
   9361,  -22.5406818,   52.9062996,         -10.
   9362,  -23.4423103,   53.0225525,         -10.
   9363,  -24.3439369,   53.1388016,         -10.
   9364,  -25.2455635,   53.2550545,         -10.
   9365,   -26.147192,   53.3713074,         -10.
   9366,  -27.0488186,   53.4875603,         -10.
   9367,  -27.9504452,   53.6038094,         -10.
   9368,  -28.8520737,   53.7200623,         -10.
   9369,  -20.8124733,   52.0077553,         -10.
   9370,  -21.7173634,    52.095047,         -10.
   9371,  -22.6222534,   52.1823425,         -10.
   9372,  -23.5271435,   52.2696342,         -10.
   9373,  -24.4320335,   52.3569298,         -10.
   9374,  -25.3369236,   52.4442215,         -10.
   9375,  -26.2418137,    52.531517,         -10.
   9376,  -27.1467037,   52.6188087,         -10.
   9377,  -28.0515938,   52.7061043,         -10.
   9378,  -28.9564838,    52.793396,         -10.
   9379,  -20.8661308,   51.3396492,         -10.
   9380,  -21.7733536,   51.3978958,         -10.
   9381,  -22.6805763,   51.4561424,         -10.
   9382,   -23.587801,   51.5143852,         -10.
   9383,  -24.4950237,   51.5726318,         -10.
   9384,  -25.4022465,   51.6308784,         -10.
   9385,  -26.3094692,   51.6891251,         -10.
   9386,   -27.216692,   51.7473679,         -10.
   9387,  -28.1239147,   51.8056145,         -10.
   9388,  -29.0311394,   51.8638611,         -10.
   9389,  -20.8983479,   50.6701698,         -10.
   9390,  -21.8069725,   50.6993065,         -10.
   9391,  -22.7155952,   50.7284431,         -10.
   9392,  -23.6242199,   50.7575836,         -10.
   9393,  -24.5328426,   50.7867203,         -10.
   9394,  -25.4414673,   50.8158569,         -10.
   9395,  -26.3500919,   50.8449974,         -10.
   9396,  -27.2587147,   50.8741341,         -10.
   9397,  -28.1673393,   50.9032707,         -10.
   9398,  -29.0759621,   50.9324112,         -10.
   9399,   29.9845867,   50.9615479,  0.909090936
   9400,   29.9383621,   51.9221077,  0.909090936
   9401,   29.8613739,   52.8806915,  0.909090936
   9402,   29.7537003,   53.8363152,  0.909090936
   9403,   29.6154537,   54.7879982,  0.909090936
   9404,   29.4467735,   55.7347603,  0.909090936
   9405,   29.2478371,   56.6756287,  0.909090936
   9406,   29.0188465,   57.6096382,  0.909090936
   9407,   28.7600365,   58.5358276,  0.909090936
   9408,   28.4716721,   59.4532471,  0.909090936
   9409,   28.1540527,   60.3609505,  0.909090936
   9410,   27.8075027,   61.2580109,  0.909090936
   9411,   27.4323788,   62.1435013,  0.909090936
   9412,   27.0290661,   63.0165138,  0.909090936
   9413,   26.5979786,   63.8761482,  0.909090936
   9414,   26.1395607,   64.7215271,  0.909090936
   9415,   25.6542816,   65.5517807,  0.909090936
   9416,   25.1426411,   66.3660507,  0.909090936
   9417,   24.6051693,   67.1634979,  0.909090936
   9418,   24.0424099,   67.9433136,  0.909090936
   9419,   23.4549427,   68.7046967,  0.909090936
   9420,   22.8433781,   69.4468536,  0.909090936
   9421,   22.2083378,   70.1690292,  0.909090936
   9422,   21.5504799,   70.8704758,  0.909090936
   9423,   20.8704739,   71.5504837,  0.909090936
   9424,   20.1690254,   72.2083435,  0.909090936
   9425,   19.4468536,   72.8433762,  0.909090936
   9426,   18.7046967,   73.4549408,  0.909090936
   9427,   17.9433136,   74.0424118,  0.909090936
   9428,   17.1634979,   74.6051712,  0.909090936
   9429,    16.366045,   75.1426468,  0.909090936
   9430,   15.5517778,   75.6542816,  0.909090936
   9431,   14.7215252,   76.1395645,  0.909090936
   9432,   13.8761501,   76.5979767,  0.909090936
   9433,    13.016511,    77.029068,  0.909090936
   9434,   12.1434994,   77.4323807,  0.909090936
   9435,   11.2580099,   77.8075027,  0.909090936
   9436,   10.3609514,   78.1540527,  0.909090936
   9437,   9.45324612,   78.4716721,  0.909090936
   9438,   8.53582859,   78.7600327,  0.909090936
   9439,   7.60963821,   79.0188446,  0.909090936
   9440,   6.67562723,   79.2478409,  0.909090936
   9441,   5.73475838,   79.4467773,  0.909090936
   9442,   4.78799629,   79.6154556,  0.909090936
   9443,   3.83631492,   79.7537003,  0.909090936
   9444,   2.88069081,   79.8613739,  0.909090936
   9445,   1.92210662,   79.9383621,  0.909090936
   9446,  0.961547256,   79.9845886,  0.909090936
   9447,           0.,          80.,  0.909090936
   9448, -0.961547256,   79.9845886,  0.909090936
   9449,  -1.92210662,   79.9383621,  0.909090936
   9450,  -2.88069081,   79.8613739,  0.909090936
   9451,  -3.83631492,   79.7537003,  0.909090936
   9452,  -4.78799629,   79.6154556,  0.909090936
   9453,  -5.73475838,   79.4467773,  0.909090936
   9454,  -6.67562723,   79.2478409,  0.909090936
   9455,  -7.60963821,   79.0188446,  0.909090936
   9456,  -8.53582859,   78.7600327,  0.909090936
   9457,  -9.45324612,   78.4716721,  0.909090936
   9458,  -10.3609514,   78.1540527,  0.909090936
   9459,  -11.2580099,   77.8075027,  0.909090936
   9460,  -12.1434994,   77.4323807,  0.909090936
   9461,   -13.016511,    77.029068,  0.909090936
   9462,  -13.8761501,   76.5979767,  0.909090936
   9463,  -14.7215252,   76.1395645,  0.909090936
   9464,  -15.5517778,   75.6542816,  0.909090936
   9465,   -16.366045,   75.1426468,  0.909090936
   9466,  -17.1634979,   74.6051712,  0.909090936
   9467,  -17.9433136,   74.0424118,  0.909090936
   9468,  -18.7046967,   73.4549408,  0.909090936
   9469,  -19.4468536,   72.8433762,  0.909090936
   9470,  -20.1690254,   72.2083435,  0.909090936
   9471,  -20.8704739,   71.5504837,  0.909090936
   9472,  -21.5504799,   70.8704758,  0.909090936
   9473,  -22.2083378,   70.1690292,  0.909090936
   9474,  -22.8433781,   69.4468536,  0.909090936
   9475,  -23.4549427,   68.7046967,  0.909090936
   9476,  -24.0424099,   67.9433136,  0.909090936
   9477,  -24.6051693,   67.1634979,  0.909090936
   9478,  -25.1426411,   66.3660507,  0.909090936
   9479,  -25.6542816,   65.5517807,  0.909090936
   9480,  -26.1395607,   64.7215271,  0.909090936
   9481,  -26.5979786,   63.8761482,  0.909090936
   9482,  -27.0290661,   63.0165138,  0.909090936
   9483,  -27.4323788,   62.1435013,  0.909090936
   9484,  -27.8075027,   61.2580109,  0.909090936
   9485,  -28.1540527,   60.3609505,  0.909090936
   9486,  -28.4716721,   59.4532471,  0.909090936
   9487,  -28.7600365,   58.5358276,  0.909090936
   9488,  -29.0188465,   57.6096382,  0.909090936
   9489,  -29.2478371,   56.6756287,  0.909090936
   9490,  -29.4467735,   55.7347603,  0.909090936
   9491,  -29.6154537,   54.7879982,  0.909090936
   9492,  -29.7537003,   53.8363152,  0.909090936
   9493,  -29.8613739,   52.8806915,  0.909090936
   9494,  -29.9383621,   51.9221077,  0.909090936
   9495,  -29.9845867,   50.9615479,  0.909090936
   9496,   29.9845867,   50.9615479,   1.81818187
   9497,   29.9383621,   51.9221077,   1.81818187
   9498,   29.8613739,   52.8806915,   1.81818187
   9499,   29.7537003,   53.8363152,   1.81818187
   9500,   29.6154537,   54.7879982,   1.81818187
   9501,   29.4467735,   55.7347603,   1.81818187
   9502,   29.2478371,   56.6756287,   1.81818187
   9503,   29.0188465,   57.6096382,   1.81818187
   9504,   28.7600365,   58.5358276,   1.81818187
   9505,   28.4716721,   59.4532471,   1.81818187
   9506,   28.1540527,   60.3609505,   1.81818187
   9507,   27.8075027,   61.2580109,   1.81818187
   9508,   27.4323788,   62.1435013,   1.81818187
   9509,   27.0290661,   63.0165138,   1.81818187
   9510,   26.5979786,   63.8761482,   1.81818187
   9511,   26.1395607,   64.7215271,   1.81818187
   9512,   25.6542816,   65.5517807,   1.81818187
   9513,   25.1426411,   66.3660507,   1.81818187
   9514,   24.6051693,   67.1634979,   1.81818187
   9515,   24.0424099,   67.9433136,   1.81818187
   9516,   23.4549427,   68.7046967,   1.81818187
   9517,   22.8433781,   69.4468536,   1.81818187
   9518,   22.2083378,   70.1690292,   1.81818187
   9519,   21.5504799,   70.8704758,   1.81818187
   9520,   20.8704739,   71.5504837,   1.81818187
   9521,   20.1690254,   72.2083435,   1.81818187
   9522,   19.4468536,   72.8433762,   1.81818187
   9523,   18.7046967,   73.4549408,   1.81818187
   9524,   17.9433136,   74.0424118,   1.81818187
   9525,   17.1634979,   74.6051712,   1.81818187
   9526,    16.366045,   75.1426468,   1.81818187
   9527,   15.5517778,   75.6542816,   1.81818187
   9528,   14.7215252,   76.1395645,   1.81818187
   9529,   13.8761501,   76.5979767,   1.81818187
   9530,    13.016511,    77.029068,   1.81818187
   9531,   12.1434994,   77.4323807,   1.81818187
   9532,   11.2580099,   77.8075027,   1.81818187
   9533,   10.3609514,   78.1540527,   1.81818187
   9534,   9.45324612,   78.4716721,   1.81818187
   9535,   8.53582859,   78.7600327,   1.81818187
   9536,   7.60963821,   79.0188446,   1.81818187
   9537,   6.67562723,   79.2478409,   1.81818187
   9538,   5.73475838,   79.4467773,   1.81818187
   9539,   4.78799629,   79.6154556,   1.81818187
   9540,   3.83631492,   79.7537003,   1.81818187
   9541,   2.88069081,   79.8613739,   1.81818187
   9542,   1.92210662,   79.9383621,   1.81818187
   9543,  0.961547256,   79.9845886,   1.81818187
   9544,           0.,          80.,   1.81818187
   9545, -0.961547256,   79.9845886,   1.81818187
   9546,  -1.92210662,   79.9383621,   1.81818187
   9547,  -2.88069081,   79.8613739,   1.81818187
   9548,  -3.83631492,   79.7537003,   1.81818187
   9549,  -4.78799629,   79.6154556,   1.81818187
   9550,  -5.73475838,   79.4467773,   1.81818187
   9551,  -6.67562723,   79.2478409,   1.81818187
   9552,  -7.60963821,   79.0188446,   1.81818187
   9553,  -8.53582859,   78.7600327,   1.81818187
   9554,  -9.45324612,   78.4716721,   1.81818187
   9555,  -10.3609514,   78.1540527,   1.81818187
   9556,  -11.2580099,   77.8075027,   1.81818187
   9557,  -12.1434994,   77.4323807,   1.81818187
   9558,   -13.016511,    77.029068,   1.81818187
   9559,  -13.8761501,   76.5979767,   1.81818187
   9560,  -14.7215252,   76.1395645,   1.81818187
   9561,  -15.5517778,   75.6542816,   1.81818187
   9562,   -16.366045,   75.1426468,   1.81818187
   9563,  -17.1634979,   74.6051712,   1.81818187
   9564,  -17.9433136,   74.0424118,   1.81818187
   9565,  -18.7046967,   73.4549408,   1.81818187
   9566,  -19.4468536,   72.8433762,   1.81818187
   9567,  -20.1690254,   72.2083435,   1.81818187
   9568,  -20.8704739,   71.5504837,   1.81818187
   9569,  -21.5504799,   70.8704758,   1.81818187
   9570,  -22.2083378,   70.1690292,   1.81818187
   9571,  -22.8433781,   69.4468536,   1.81818187
   9572,  -23.4549427,   68.7046967,   1.81818187
   9573,  -24.0424099,   67.9433136,   1.81818187
   9574,  -24.6051693,   67.1634979,   1.81818187
   9575,  -25.1426411,   66.3660507,   1.81818187
   9576,  -25.6542816,   65.5517807,   1.81818187
   9577,  -26.1395607,   64.7215271,   1.81818187
   9578,  -26.5979786,   63.8761482,   1.81818187
   9579,  -27.0290661,   63.0165138,   1.81818187
   9580,  -27.4323788,   62.1435013,   1.81818187
   9581,  -27.8075027,   61.2580109,   1.81818187
   9582,  -28.1540527,   60.3609505,   1.81818187
   9583,  -28.4716721,   59.4532471,   1.81818187
   9584,  -28.7600365,   58.5358276,   1.81818187
   9585,  -29.0188465,   57.6096382,   1.81818187
   9586,  -29.2478371,   56.6756287,   1.81818187
   9587,  -29.4467735,   55.7347603,   1.81818187
   9588,  -29.6154537,   54.7879982,   1.81818187
   9589,  -29.7537003,   53.8363152,   1.81818187
   9590,  -29.8613739,   52.8806915,   1.81818187
   9591,  -29.9383621,   51.9221077,   1.81818187
   9592,  -29.9845867,   50.9615479,   1.81818187
   9593,   29.9845867,   50.9615479,   2.72727275
   9594,   29.9383621,   51.9221077,   2.72727275
   9595,   29.8613739,   52.8806915,   2.72727275
   9596,   29.7537003,   53.8363152,   2.72727275
   9597,   29.6154537,   54.7879982,   2.72727275
   9598,   29.4467735,   55.7347603,   2.72727275
   9599,   29.2478371,   56.6756287,   2.72727275
   9600,   29.0188465,   57.6096382,   2.72727275
   9601,   28.7600365,   58.5358276,   2.72727275
   9602,   28.4716721,   59.4532471,   2.72727275
   9603,   28.1540527,   60.3609505,   2.72727275
   9604,   27.8075027,   61.2580109,   2.72727275
   9605,   27.4323788,   62.1435013,   2.72727275
   9606,   27.0290661,   63.0165138,   2.72727275
   9607,   26.5979786,   63.8761482,   2.72727275
   9608,   26.1395607,   64.7215271,   2.72727275
   9609,   25.6542816,   65.5517807,   2.72727275
   9610,   25.1426411,   66.3660507,   2.72727275
   9611,   24.6051693,   67.1634979,   2.72727275
   9612,   24.0424099,   67.9433136,   2.72727275
   9613,   23.4549427,   68.7046967,   2.72727275
   9614,   22.8433781,   69.4468536,   2.72727275
   9615,   22.2083378,   70.1690292,   2.72727275
   9616,   21.5504799,   70.8704758,   2.72727275
   9617,   20.8704739,   71.5504837,   2.72727275
   9618,   20.1690254,   72.2083435,   2.72727275
   9619,   19.4468536,   72.8433762,   2.72727275
   9620,   18.7046967,   73.4549408,   2.72727275
   9621,   17.9433136,   74.0424118,   2.72727275
   9622,   17.1634979,   74.6051712,   2.72727275
   9623,    16.366045,   75.1426468,   2.72727275
   9624,   15.5517778,   75.6542816,   2.72727275
   9625,   14.7215252,   76.1395645,   2.72727275
   9626,   13.8761501,   76.5979767,   2.72727275
   9627,    13.016511,    77.029068,   2.72727275
   9628,   12.1434994,   77.4323807,   2.72727275
   9629,   11.2580099,   77.8075027,   2.72727275
   9630,   10.3609514,   78.1540527,   2.72727275
   9631,   9.45324612,   78.4716721,   2.72727275
   9632,   8.53582859,   78.7600327,   2.72727275
   9633,   7.60963821,   79.0188446,   2.72727275
   9634,   6.67562723,   79.2478409,   2.72727275
   9635,   5.73475838,   79.4467773,   2.72727275
   9636,   4.78799629,   79.6154556,   2.72727275
   9637,   3.83631492,   79.7537003,   2.72727275
   9638,   2.88069081,   79.8613739,   2.72727275
   9639,   1.92210662,   79.9383621,   2.72727275
   9640,  0.961547256,   79.9845886,   2.72727275
   9641,           0.,          80.,   2.72727275
   9642, -0.961547256,   79.9845886,   2.72727275
   9643,  -1.92210662,   79.9383621,   2.72727275
   9644,  -2.88069081,   79.8613739,   2.72727275
   9645,  -3.83631492,   79.7537003,   2.72727275
   9646,  -4.78799629,   79.6154556,   2.72727275
   9647,  -5.73475838,   79.4467773,   2.72727275
   9648,  -6.67562723,   79.2478409,   2.72727275
   9649,  -7.60963821,   79.0188446,   2.72727275
   9650,  -8.53582859,   78.7600327,   2.72727275
   9651,  -9.45324612,   78.4716721,   2.72727275
   9652,  -10.3609514,   78.1540527,   2.72727275
   9653,  -11.2580099,   77.8075027,   2.72727275
   9654,  -12.1434994,   77.4323807,   2.72727275
   9655,   -13.016511,    77.029068,   2.72727275
   9656,  -13.8761501,   76.5979767,   2.72727275
   9657,  -14.7215252,   76.1395645,   2.72727275
   9658,  -15.5517778,   75.6542816,   2.72727275
   9659,   -16.366045,   75.1426468,   2.72727275
   9660,  -17.1634979,   74.6051712,   2.72727275
   9661,  -17.9433136,   74.0424118,   2.72727275
   9662,  -18.7046967,   73.4549408,   2.72727275
   9663,  -19.4468536,   72.8433762,   2.72727275
   9664,  -20.1690254,   72.2083435,   2.72727275
   9665,  -20.8704739,   71.5504837,   2.72727275
   9666,  -21.5504799,   70.8704758,   2.72727275
   9667,  -22.2083378,   70.1690292,   2.72727275
   9668,  -22.8433781,   69.4468536,   2.72727275
   9669,  -23.4549427,   68.7046967,   2.72727275
   9670,  -24.0424099,   67.9433136,   2.72727275
   9671,  -24.6051693,   67.1634979,   2.72727275
   9672,  -25.1426411,   66.3660507,   2.72727275
   9673,  -25.6542816,   65.5517807,   2.72727275
   9674,  -26.1395607,   64.7215271,   2.72727275
   9675,  -26.5979786,   63.8761482,   2.72727275
   9676,  -27.0290661,   63.0165138,   2.72727275
   9677,  -27.4323788,   62.1435013,   2.72727275
   9678,  -27.8075027,   61.2580109,   2.72727275
   9679,  -28.1540527,   60.3609505,   2.72727275
   9680,  -28.4716721,   59.4532471,   2.72727275
   9681,  -28.7600365,   58.5358276,   2.72727275
   9682,  -29.0188465,   57.6096382,   2.72727275
   9683,  -29.2478371,   56.6756287,   2.72727275
   9684,  -29.4467735,   55.7347603,   2.72727275
   9685,  -29.6154537,   54.7879982,   2.72727275
   9686,  -29.7537003,   53.8363152,   2.72727275
   9687,  -29.8613739,   52.8806915,   2.72727275
   9688,  -29.9383621,   51.9221077,   2.72727275
   9689,  -29.9845867,   50.9615479,   2.72727275
   9690,   29.9845867,   50.9615479,   3.63636374
   9691,   29.9383621,   51.9221077,   3.63636374
   9692,   29.8613739,   52.8806915,   3.63636374
   9693,   29.7537003,   53.8363152,   3.63636374
   9694,   29.6154537,   54.7879982,   3.63636374
   9695,   29.4467735,   55.7347603,   3.63636374
   9696,   29.2478371,   56.6756287,   3.63636374
   9697,   29.0188465,   57.6096382,   3.63636374
   9698,   28.7600365,   58.5358276,   3.63636374
   9699,   28.4716721,   59.4532471,   3.63636374
   9700,   28.1540527,   60.3609505,   3.63636374
   9701,   27.8075027,   61.2580109,   3.63636374
   9702,   27.4323788,   62.1435013,   3.63636374
   9703,   27.0290661,   63.0165138,   3.63636374
   9704,   26.5979786,   63.8761482,   3.63636374
   9705,   26.1395607,   64.7215271,   3.63636374
   9706,   25.6542816,   65.5517807,   3.63636374
   9707,   25.1426411,   66.3660507,   3.63636374
   9708,   24.6051693,   67.1634979,   3.63636374
   9709,   24.0424099,   67.9433136,   3.63636374
   9710,   23.4549427,   68.7046967,   3.63636374
   9711,   22.8433781,   69.4468536,   3.63636374
   9712,   22.2083378,   70.1690292,   3.63636374
   9713,   21.5504799,   70.8704758,   3.63636374
   9714,   20.8704739,   71.5504837,   3.63636374
   9715,   20.1690254,   72.2083435,   3.63636374
   9716,   19.4468536,   72.8433762,   3.63636374
   9717,   18.7046967,   73.4549408,   3.63636374
   9718,   17.9433136,   74.0424118,   3.63636374
   9719,   17.1634979,   74.6051712,   3.63636374
   9720,    16.366045,   75.1426468,   3.63636374
   9721,   15.5517778,   75.6542816,   3.63636374
   9722,   14.7215252,   76.1395645,   3.63636374
   9723,   13.8761501,   76.5979767,   3.63636374
   9724,    13.016511,    77.029068,   3.63636374
   9725,   12.1434994,   77.4323807,   3.63636374
   9726,   11.2580099,   77.8075027,   3.63636374
   9727,   10.3609514,   78.1540527,   3.63636374
   9728,   9.45324612,   78.4716721,   3.63636374
   9729,   8.53582859,   78.7600327,   3.63636374
   9730,   7.60963821,   79.0188446,   3.63636374
   9731,   6.67562723,   79.2478409,   3.63636374
   9732,   5.73475838,   79.4467773,   3.63636374
   9733,   4.78799629,   79.6154556,   3.63636374
   9734,   3.83631492,   79.7537003,   3.63636374
   9735,   2.88069081,   79.8613739,   3.63636374
   9736,   1.92210662,   79.9383621,   3.63636374
   9737,  0.961547256,   79.9845886,   3.63636374
   9738,           0.,          80.,   3.63636374
   9739, -0.961547256,   79.9845886,   3.63636374
   9740,  -1.92210662,   79.9383621,   3.63636374
   9741,  -2.88069081,   79.8613739,   3.63636374
   9742,  -3.83631492,   79.7537003,   3.63636374
   9743,  -4.78799629,   79.6154556,   3.63636374
   9744,  -5.73475838,   79.4467773,   3.63636374
   9745,  -6.67562723,   79.2478409,   3.63636374
   9746,  -7.60963821,   79.0188446,   3.63636374
   9747,  -8.53582859,   78.7600327,   3.63636374
   9748,  -9.45324612,   78.4716721,   3.63636374
   9749,  -10.3609514,   78.1540527,   3.63636374
   9750,  -11.2580099,   77.8075027,   3.63636374
   9751,  -12.1434994,   77.4323807,   3.63636374
   9752,   -13.016511,    77.029068,   3.63636374
   9753,  -13.8761501,   76.5979767,   3.63636374
   9754,  -14.7215252,   76.1395645,   3.63636374
   9755,  -15.5517778,   75.6542816,   3.63636374
   9756,   -16.366045,   75.1426468,   3.63636374
   9757,  -17.1634979,   74.6051712,   3.63636374
   9758,  -17.9433136,   74.0424118,   3.63636374
   9759,  -18.7046967,   73.4549408,   3.63636374
   9760,  -19.4468536,   72.8433762,   3.63636374
   9761,  -20.1690254,   72.2083435,   3.63636374
   9762,  -20.8704739,   71.5504837,   3.63636374
   9763,  -21.5504799,   70.8704758,   3.63636374
   9764,  -22.2083378,   70.1690292,   3.63636374
   9765,  -22.8433781,   69.4468536,   3.63636374
   9766,  -23.4549427,   68.7046967,   3.63636374
   9767,  -24.0424099,   67.9433136,   3.63636374
   9768,  -24.6051693,   67.1634979,   3.63636374
   9769,  -25.1426411,   66.3660507,   3.63636374
   9770,  -25.6542816,   65.5517807,   3.63636374
   9771,  -26.1395607,   64.7215271,   3.63636374
   9772,  -26.5979786,   63.8761482,   3.63636374
   9773,  -27.0290661,   63.0165138,   3.63636374
   9774,  -27.4323788,   62.1435013,   3.63636374
   9775,  -27.8075027,   61.2580109,   3.63636374
   9776,  -28.1540527,   60.3609505,   3.63636374
   9777,  -28.4716721,   59.4532471,   3.63636374
   9778,  -28.7600365,   58.5358276,   3.63636374
   9779,  -29.0188465,   57.6096382,   3.63636374
   9780,  -29.2478371,   56.6756287,   3.63636374
   9781,  -29.4467735,   55.7347603,   3.63636374
   9782,  -29.6154537,   54.7879982,   3.63636374
   9783,  -29.7537003,   53.8363152,   3.63636374
   9784,  -29.8613739,   52.8806915,   3.63636374
   9785,  -29.9383621,   51.9221077,   3.63636374
   9786,  -29.9845867,   50.9615479,   3.63636374
   9787,   29.9845867,   50.9615479,    4.5454545
   9788,   29.9383621,   51.9221077,    4.5454545
   9789,   29.8613739,   52.8806915,    4.5454545
   9790,   29.7537003,   53.8363152,    4.5454545
   9791,   29.6154537,   54.7879982,    4.5454545
   9792,   29.4467735,   55.7347603,    4.5454545
   9793,   29.2478371,   56.6756287,    4.5454545
   9794,   29.0188465,   57.6096382,    4.5454545
   9795,   28.7600365,   58.5358276,    4.5454545
   9796,   28.4716721,   59.4532471,    4.5454545
   9797,   28.1540527,   60.3609505,    4.5454545
   9798,   27.8075027,   61.2580109,    4.5454545
   9799,   27.4323788,   62.1435013,    4.5454545
   9800,   27.0290661,   63.0165138,    4.5454545
   9801,   26.5979786,   63.8761482,    4.5454545
   9802,   26.1395607,   64.7215271,    4.5454545
   9803,   25.6542816,   65.5517807,    4.5454545
   9804,   25.1426411,   66.3660507,    4.5454545
   9805,   24.6051693,   67.1634979,    4.5454545
   9806,   24.0424099,   67.9433136,    4.5454545
   9807,   23.4549427,   68.7046967,    4.5454545
   9808,   22.8433781,   69.4468536,    4.5454545
   9809,   22.2083378,   70.1690292,    4.5454545
   9810,   21.5504799,   70.8704758,    4.5454545
   9811,   20.8704739,   71.5504837,    4.5454545
   9812,   20.1690254,   72.2083435,    4.5454545
   9813,   19.4468536,   72.8433762,    4.5454545
   9814,   18.7046967,   73.4549408,    4.5454545
   9815,   17.9433136,   74.0424118,    4.5454545
   9816,   17.1634979,   74.6051712,    4.5454545
   9817,    16.366045,   75.1426468,    4.5454545
   9818,   15.5517778,   75.6542816,    4.5454545
   9819,   14.7215252,   76.1395645,    4.5454545
   9820,   13.8761501,   76.5979767,    4.5454545
   9821,    13.016511,    77.029068,    4.5454545
   9822,   12.1434994,   77.4323807,    4.5454545
   9823,   11.2580099,   77.8075027,    4.5454545
   9824,   10.3609514,   78.1540527,    4.5454545
   9825,   9.45324612,   78.4716721,    4.5454545
   9826,   8.53582859,   78.7600327,    4.5454545
   9827,   7.60963821,   79.0188446,    4.5454545
   9828,   6.67562723,   79.2478409,    4.5454545
   9829,   5.73475838,   79.4467773,    4.5454545
   9830,   4.78799629,   79.6154556,    4.5454545
   9831,   3.83631492,   79.7537003,    4.5454545
   9832,   2.88069081,   79.8613739,    4.5454545
   9833,   1.92210662,   79.9383621,    4.5454545
   9834,  0.961547256,   79.9845886,    4.5454545
   9835,           0.,          80.,    4.5454545
   9836, -0.961547256,   79.9845886,    4.5454545
   9837,  -1.92210662,   79.9383621,    4.5454545
   9838,  -2.88069081,   79.8613739,    4.5454545
   9839,  -3.83631492,   79.7537003,    4.5454545
   9840,  -4.78799629,   79.6154556,    4.5454545
   9841,  -5.73475838,   79.4467773,    4.5454545
   9842,  -6.67562723,   79.2478409,    4.5454545
   9843,  -7.60963821,   79.0188446,    4.5454545
   9844,  -8.53582859,   78.7600327,    4.5454545
   9845,  -9.45324612,   78.4716721,    4.5454545
   9846,  -10.3609514,   78.1540527,    4.5454545
   9847,  -11.2580099,   77.8075027,    4.5454545
   9848,  -12.1434994,   77.4323807,    4.5454545
   9849,   -13.016511,    77.029068,    4.5454545
   9850,  -13.8761501,   76.5979767,    4.5454545
   9851,  -14.7215252,   76.1395645,    4.5454545
   9852,  -15.5517778,   75.6542816,    4.5454545
   9853,   -16.366045,   75.1426468,    4.5454545
   9854,  -17.1634979,   74.6051712,    4.5454545
   9855,  -17.9433136,   74.0424118,    4.5454545
   9856,  -18.7046967,   73.4549408,    4.5454545
   9857,  -19.4468536,   72.8433762,    4.5454545
   9858,  -20.1690254,   72.2083435,    4.5454545
   9859,  -20.8704739,   71.5504837,    4.5454545
   9860,  -21.5504799,   70.8704758,    4.5454545
   9861,  -22.2083378,   70.1690292,    4.5454545
   9862,  -22.8433781,   69.4468536,    4.5454545
   9863,  -23.4549427,   68.7046967,    4.5454545
   9864,  -24.0424099,   67.9433136,    4.5454545
   9865,  -24.6051693,   67.1634979,    4.5454545
   9866,  -25.1426411,   66.3660507,    4.5454545
   9867,  -25.6542816,   65.5517807,    4.5454545
   9868,  -26.1395607,   64.7215271,    4.5454545
   9869,  -26.5979786,   63.8761482,    4.5454545
   9870,  -27.0290661,   63.0165138,    4.5454545
   9871,  -27.4323788,   62.1435013,    4.5454545
   9872,  -27.8075027,   61.2580109,    4.5454545
   9873,  -28.1540527,   60.3609505,    4.5454545
   9874,  -28.4716721,   59.4532471,    4.5454545
   9875,  -28.7600365,   58.5358276,    4.5454545
   9876,  -29.0188465,   57.6096382,    4.5454545
   9877,  -29.2478371,   56.6756287,    4.5454545
   9878,  -29.4467735,   55.7347603,    4.5454545
   9879,  -29.6154537,   54.7879982,    4.5454545
   9880,  -29.7537003,   53.8363152,    4.5454545
   9881,  -29.8613739,   52.8806915,    4.5454545
   9882,  -29.9383621,   51.9221077,    4.5454545
   9883,  -29.9845867,   50.9615479,    4.5454545
   9884,   29.9845867,   50.9615479,    5.4545455
   9885,   29.9383621,   51.9221077,    5.4545455
   9886,   29.8613739,   52.8806915,    5.4545455
   9887,   29.7537003,   53.8363152,    5.4545455
   9888,   29.6154537,   54.7879982,    5.4545455
   9889,   29.4467735,   55.7347603,    5.4545455
   9890,   29.2478371,   56.6756287,    5.4545455
   9891,   29.0188465,   57.6096382,    5.4545455
   9892,   28.7600365,   58.5358276,    5.4545455
   9893,   28.4716721,   59.4532471,    5.4545455
   9894,   28.1540527,   60.3609505,    5.4545455
   9895,   27.8075027,   61.2580109,    5.4545455
   9896,   27.4323788,   62.1435013,    5.4545455
   9897,   27.0290661,   63.0165138,    5.4545455
   9898,   26.5979786,   63.8761482,    5.4545455
   9899,   26.1395607,   64.7215271,    5.4545455
   9900,   25.6542816,   65.5517807,    5.4545455
   9901,   25.1426411,   66.3660507,    5.4545455
   9902,   24.6051693,   67.1634979,    5.4545455
   9903,   24.0424099,   67.9433136,    5.4545455
   9904,   23.4549427,   68.7046967,    5.4545455
   9905,   22.8433781,   69.4468536,    5.4545455
   9906,   22.2083378,   70.1690292,    5.4545455
   9907,   21.5504799,   70.8704758,    5.4545455
   9908,   20.8704739,   71.5504837,    5.4545455
   9909,   20.1690254,   72.2083435,    5.4545455
   9910,   19.4468536,   72.8433762,    5.4545455
   9911,   18.7046967,   73.4549408,    5.4545455
   9912,   17.9433136,   74.0424118,    5.4545455
   9913,   17.1634979,   74.6051712,    5.4545455
   9914,    16.366045,   75.1426468,    5.4545455
   9915,   15.5517778,   75.6542816,    5.4545455
   9916,   14.7215252,   76.1395645,    5.4545455
   9917,   13.8761501,   76.5979767,    5.4545455
   9918,    13.016511,    77.029068,    5.4545455
   9919,   12.1434994,   77.4323807,    5.4545455
   9920,   11.2580099,   77.8075027,    5.4545455
   9921,   10.3609514,   78.1540527,    5.4545455
   9922,   9.45324612,   78.4716721,    5.4545455
   9923,   8.53582859,   78.7600327,    5.4545455
   9924,   7.60963821,   79.0188446,    5.4545455
   9925,   6.67562723,   79.2478409,    5.4545455
   9926,   5.73475838,   79.4467773,    5.4545455
   9927,   4.78799629,   79.6154556,    5.4545455
   9928,   3.83631492,   79.7537003,    5.4545455
   9929,   2.88069081,   79.8613739,    5.4545455
   9930,   1.92210662,   79.9383621,    5.4545455
   9931,  0.961547256,   79.9845886,    5.4545455
   9932,           0.,          80.,    5.4545455
   9933, -0.961547256,   79.9845886,    5.4545455
   9934,  -1.92210662,   79.9383621,    5.4545455
   9935,  -2.88069081,   79.8613739,    5.4545455
   9936,  -3.83631492,   79.7537003,    5.4545455
   9937,  -4.78799629,   79.6154556,    5.4545455
   9938,  -5.73475838,   79.4467773,    5.4545455
   9939,  -6.67562723,   79.2478409,    5.4545455
   9940,  -7.60963821,   79.0188446,    5.4545455
   9941,  -8.53582859,   78.7600327,    5.4545455
   9942,  -9.45324612,   78.4716721,    5.4545455
   9943,  -10.3609514,   78.1540527,    5.4545455
   9944,  -11.2580099,   77.8075027,    5.4545455
   9945,  -12.1434994,   77.4323807,    5.4545455
   9946,   -13.016511,    77.029068,    5.4545455
   9947,  -13.8761501,   76.5979767,    5.4545455
   9948,  -14.7215252,   76.1395645,    5.4545455
   9949,  -15.5517778,   75.6542816,    5.4545455
   9950,   -16.366045,   75.1426468,    5.4545455
   9951,  -17.1634979,   74.6051712,    5.4545455
   9952,  -17.9433136,   74.0424118,    5.4545455
   9953,  -18.7046967,   73.4549408,    5.4545455
   9954,  -19.4468536,   72.8433762,    5.4545455
   9955,  -20.1690254,   72.2083435,    5.4545455
   9956,  -20.8704739,   71.5504837,    5.4545455
   9957,  -21.5504799,   70.8704758,    5.4545455
   9958,  -22.2083378,   70.1690292,    5.4545455
   9959,  -22.8433781,   69.4468536,    5.4545455
   9960,  -23.4549427,   68.7046967,    5.4545455
   9961,  -24.0424099,   67.9433136,    5.4545455
   9962,  -24.6051693,   67.1634979,    5.4545455
   9963,  -25.1426411,   66.3660507,    5.4545455
   9964,  -25.6542816,   65.5517807,    5.4545455
   9965,  -26.1395607,   64.7215271,    5.4545455
   9966,  -26.5979786,   63.8761482,    5.4545455
   9967,  -27.0290661,   63.0165138,    5.4545455
   9968,  -27.4323788,   62.1435013,    5.4545455
   9969,  -27.8075027,   61.2580109,    5.4545455
   9970,  -28.1540527,   60.3609505,    5.4545455
   9971,  -28.4716721,   59.4532471,    5.4545455
   9972,  -28.7600365,   58.5358276,    5.4545455
   9973,  -29.0188465,   57.6096382,    5.4545455
   9974,  -29.2478371,   56.6756287,    5.4545455
   9975,  -29.4467735,   55.7347603,    5.4545455
   9976,  -29.6154537,   54.7879982,    5.4545455
   9977,  -29.7537003,   53.8363152,    5.4545455
   9978,  -29.8613739,   52.8806915,    5.4545455
   9979,  -29.9383621,   51.9221077,    5.4545455
   9980,  -29.9845867,   50.9615479,    5.4545455
   9981,   29.9845867,   50.9615479,   6.36363649
   9982,   29.9383621,   51.9221077,   6.36363649
   9983,   29.8613739,   52.8806915,   6.36363649
   9984,   29.7537003,   53.8363152,   6.36363649
   9985,   29.6154537,   54.7879982,   6.36363649
   9986,   29.4467735,   55.7347603,   6.36363649
   9987,   29.2478371,   56.6756287,   6.36363649
   9988,   29.0188465,   57.6096382,   6.36363649
   9989,   28.7600365,   58.5358276,   6.36363649
   9990,   28.4716721,   59.4532471,   6.36363649
   9991,   28.1540527,   60.3609505,   6.36363649
   9992,   27.8075027,   61.2580109,   6.36363649
   9993,   27.4323788,   62.1435013,   6.36363649
   9994,   27.0290661,   63.0165138,   6.36363649
