  47995,   23.7685947,   29.3014355,   6.36363649
  47996,   22.8264465,   29.3014355,   6.36363649
  47997,   21.8842983,   29.3014355,   6.36363649
  47998,   20.9421482,   29.3014355,   6.36363649
  47999,    29.130579,   28.5081348,   6.36363649
  48000,   28.2611561,   28.5081348,   6.36363649
  48001,    27.391737,   28.5081348,   6.36363649
  48002,   26.5223141,   28.5081348,   6.36363649
  48003,   25.6528931,   28.5081348,   6.36363649
  48004,    24.710743,   28.5081348,   6.36363649
  48005,   23.7685947,   28.5081348,   6.36363649
  48006,   22.8264465,   28.5081348,   6.36363649
  48007,   21.8842983,   28.5081348,   6.36363649
  48008,   20.9421482,   28.5081348,   6.36363649
  48009,    29.130579,   27.7148323,   6.36363649
  48010,   28.2611561,   27.7148323,   6.36363649
  48011,    27.391737,   27.7148323,   6.36363649
  48012,   26.5223141,   27.7148323,   6.36363649
  48013,   25.6528931,   27.7148323,   6.36363649
  48014,    24.710743,   27.7148323,   6.36363649
  48015,   23.7685947,   27.7148323,   6.36363649
  48016,   22.8264465,   27.7148323,   6.36363649
  48017,   21.8842983,   27.7148323,   6.36363649
  48018,   20.9421482,   27.7148323,   6.36363649
  48019,    29.130579,   26.9215317,   6.36363649
  48020,   28.2611561,   26.9215317,   6.36363649
  48021,    27.391737,   26.9215317,   6.36363649
  48022,   26.5223141,   26.9215317,   6.36363649
  48023,   25.6528931,   26.9215317,   6.36363649
  48024,    24.710743,   26.9215317,   6.36363649
  48025,   23.7685947,   26.9215317,   6.36363649
  48026,   22.8264465,   26.9215317,   6.36363649
  48027,   21.8842983,   26.9215317,   6.36363649
  48028,   20.9421482,   26.9215317,   6.36363649
  48029,    29.130579,   26.1282291,   6.36363649
  48030,   28.2611561,   26.1282291,   6.36363649
  48031,    27.391737,   26.1282291,   6.36363649
  48032,   26.5223141,   26.1282291,   6.36363649
  48033,   25.6528931,   26.1282291,   6.36363649
  48034,    24.710743,   26.1282291,   6.36363649
  48035,   23.7685947,   26.1282291,   6.36363649
  48036,   22.8264465,   26.1282291,   6.36363649
  48037,   21.8842983,   26.1282291,   6.36363649
  48038,   20.9421482,   26.1282291,   6.36363649
  48039,    29.130579,   25.3349285,   6.36363649
  48040,   28.2611561,   25.3349285,   6.36363649
  48041,    27.391737,   25.3349285,   6.36363649
  48042,   26.5223141,   25.3349285,   6.36363649
  48043,   25.6528931,   25.3349285,   6.36363649
  48044,    24.710743,   25.3349285,   6.36363649
  48045,   23.7685947,   25.3349285,   6.36363649
  48046,   22.8264465,   25.3349285,   6.36363649
  48047,   21.8842983,   25.3349285,   6.36363649
  48048,   20.9421482,   25.3349285,   6.36363649
  48049,   29.1249123,   24.5727959,   6.36363649
  48050,   28.2498226,   24.5727959,   6.36363649
  48051,   27.3747349,   24.5727959,   6.36363649
  48052,   26.4996452,   24.5727959,   6.36363649
  48053,   25.6245575,   24.5727959,   6.36363649
  48054,     24.68713,   24.5727959,   6.36363649
  48055,   23.7497044,   24.5727959,   6.36363649
  48056,   22.8122787,   24.5727959,   6.36363649
  48057,   21.8748531,   24.5727959,   6.36363649
  48058,   20.9374256,   24.5727959,   6.36363649
  48059,   29.1192455,   23.8106632,   6.36363649
  48060,   28.2384892,   23.8106632,   6.36363649
  48061,   27.3577328,   23.8106632,   6.36363649
  48062,   26.4769783,   23.8106632,   6.36363649
  48063,   25.5962219,   23.8106632,   6.36363649
  48064,   24.6635189,   23.8106632,   6.36363649
  48065,   23.7308159,   23.8106632,   6.36363649
  48066,    22.798111,   23.8106632,   6.36363649
  48067,   21.8654079,   23.8106632,   6.36363649
  48068,    20.932703,   23.8106632,   6.36363649
  48069,   29.1135769,   23.0485306,   6.36363649
  48070,   28.2271538,   23.0485306,   6.36363649
  48071,   27.3407326,   23.0485306,   6.36363649
  48072,   26.4543095,   23.0485306,   6.36363649
  48073,   25.5678864,   23.0485306,   6.36363649
  48074,   24.6399059,   23.0485306,   6.36363649
  48075,   23.7119255,   23.0485306,   6.36363649
  48076,   22.7839432,   23.0485306,   6.36363649
  48077,   21.8559628,   23.0485306,   6.36363649
  48078,   20.9279804,   23.0485306,   6.36363649
  48079,   29.1079102,   22.2863979,   6.36363649
  48080,   28.2158203,   22.2863979,   6.36363649
  48081,   27.3237305,   22.2863979,   6.36363649
  48082,   26.4316406,   22.2863979,   6.36363649
  48083,   25.5395527,   22.2863979,   6.36363649
  48084,    24.616293,   22.2863979,   6.36363649
  48085,   23.6930351,   22.2863979,   6.36363649
  48086,   22.7697754,   22.2863979,   6.36363649
  48087,   21.8465176,   22.2863979,   6.36363649
  48088,   20.9232578,   22.2863979,   6.36363649
  48089,   29.1022434,   21.5242653,   6.36363649
  48090,   28.2044868,   21.5242653,   6.36363649
  48091,   27.3067303,   21.5242653,   6.36363649
  48092,   26.4089718,   21.5242653,   6.36363649
  48093,   25.5112171,   21.5242653,   6.36363649
  48094,     24.59268,   21.5242653,   6.36363649
  48095,   23.6741447,   21.5242653,   6.36363649
  48096,   22.7556076,   21.5242653,   6.36363649
  48097,   21.8370724,   21.5242653,   6.36363649
  48098,   20.9185352,   21.5242653,   6.36363649
  48099,   29.0965767,   20.7621326,   6.36363649
  48100,   28.1931534,   20.7621326,   6.36363649
  48101,   27.2897282,   20.7621326,   6.36363649
  48102,   26.3863049,   20.7621326,   6.36363649
  48103,   25.4828815,   20.7621326,   6.36363649
  48104,    24.569067,   20.7621326,   6.36363649
  48105,   23.6552544,   20.7621326,   6.36363649
  48106,   22.7414398,   20.7621326,   6.36363649
  48107,   21.8276272,   20.7621326,   6.36363649
  48108,   20.9138126,   20.7621326,   6.36363649
  48109,   29.0991745,   49.1905899,    5.4545455
  48110,   28.1983471,   49.1905899,    5.4545455
  48111,   27.2975216,   49.1905899,    5.4545455
  48112,   26.3966942,   49.1905899,    5.4545455
  48113,   25.4958687,   49.1905899,    5.4545455
  48114,   24.5798893,   49.1905899,    5.4545455
  48115,   23.6639118,   49.1905899,    5.4545455
  48116,   22.7479343,   49.1905899,    5.4545455
  48117,    21.831955,   49.1905899,    5.4545455
  48118,   20.9159775,   49.1905899,    5.4545455
  48119,    29.107439,   48.3811798,    5.4545455
  48120,   28.2148762,   48.3811798,    5.4545455
  48121,   27.3223152,   48.3811798,    5.4545455
  48122,   26.4297523,   48.3811798,    5.4545455
  48123,   25.5371914,   48.3811798,    5.4545455
  48124,   24.6143246,   48.3811798,    5.4545455
  48125,   23.6914597,   48.3811798,    5.4545455
  48126,   22.7685947,   48.3811798,    5.4545455
  48127,   21.8457298,   48.3811798,    5.4545455
  48128,   20.9228649,   48.3811798,    5.4545455
  48129,   29.1157036,   47.5717697,    5.4545455
  48130,   28.2314053,   47.5717697,    5.4545455
  48131,   27.3471069,   47.5717697,    5.4545455
  48132,   26.4628086,   47.5717697,    5.4545455
  48133,   25.5785122,   47.5717697,    5.4545455
  48134,   24.6487598,   47.5717697,    5.4545455
  48135,   23.7190094,   47.5717697,    5.4545455
  48136,   22.7892551,   47.5717697,    5.4545455
  48137,   21.8595047,   47.5717697,    5.4545455
  48138,   20.9297523,   47.5717697,    5.4545455
  48139,   29.1239681,   46.7623596,    5.4545455
  48140,   28.2479343,   46.7623596,    5.4545455
  48141,   27.3719006,   46.7623596,    5.4545455
  48142,   26.4958668,   46.7623596,    5.4545455
  48143,   25.6198349,   46.7623596,    5.4545455
  48144,   24.6831951,   46.7623596,    5.4545455
  48145,   23.7465572,   46.7623596,    5.4545455
  48146,   22.8099174,   46.7623596,    5.4545455
  48147,   21.8732777,   46.7623596,    5.4545455
  48148,   20.9366379,   46.7623596,    5.4545455
  48149,   29.1322327,   45.9529495,    5.4545455
  48150,   28.2644634,   45.9529495,    5.4545455
  48151,   27.3966942,   45.9529495,    5.4545455
  48152,   26.5289249,   45.9529495,    5.4545455
  48153,   25.6611576,   45.9529495,    5.4545455
  48154,   24.7176304,   45.9529495,    5.4545455
  48155,   23.7741051,   45.9529495,    5.4545455
  48156,   22.8305779,   45.9529495,    5.4545455
  48157,   21.8870525,   45.9529495,    5.4545455
  48158,   20.9435253,   45.9529495,    5.4545455
  48159,   29.1404972,   45.1435394,    5.4545455
  48160,   28.2809906,   45.1435394,    5.4545455
  48161,   27.4214878,   45.1435394,    5.4545455
  48162,   26.5619831,   45.1435394,    5.4545455
  48163,   25.7024803,   45.1435394,    5.4545455
  48164,   24.7520657,   45.1435394,    5.4545455
  48165,   23.8016529,   45.1435394,    5.4545455
  48166,   22.8512402,   45.1435394,    5.4545455
  48167,   21.9008274,   45.1435394,    5.4545455
  48168,   20.9504128,   45.1435394,    5.4545455
  48169,   29.1404972,   44.3492813,    5.4545455
  48170,   28.2809906,   44.3492813,    5.4545455
  48171,   27.4214878,   44.3492813,    5.4545455
  48172,   26.5619831,   44.3492813,    5.4545455
  48173,   25.7024803,   44.3492813,    5.4545455
  48174,   24.7520657,   44.3492813,    5.4545455
  48175,   23.8016529,   44.3492813,    5.4545455
  48176,   22.8512402,   44.3492813,    5.4545455
  48177,   21.9008274,   44.3492813,    5.4545455
  48178,   20.9504128,   44.3492813,    5.4545455
  48179,   29.1404972,   43.5550232,    5.4545455
  48180,   28.2809906,   43.5550232,    5.4545455
  48181,   27.4214878,   43.5550232,    5.4545455
  48182,   26.5619831,   43.5550232,    5.4545455
  48183,   25.7024803,   43.5550232,    5.4545455
  48184,   24.7520657,   43.5550232,    5.4545455
  48185,   23.8016529,   43.5550232,    5.4545455
  48186,   22.8512402,   43.5550232,    5.4545455
  48187,   21.9008274,   43.5550232,    5.4545455
  48188,   20.9504128,   43.5550232,    5.4545455
  48189,   29.1404972,   42.7607651,    5.4545455
  48190,   28.2809906,   42.7607651,    5.4545455
  48191,   27.4214878,   42.7607651,    5.4545455
  48192,   26.5619831,   42.7607651,    5.4545455
  48193,   25.7024803,   42.7607651,    5.4545455
  48194,   24.7520657,   42.7607651,    5.4545455
  48195,   23.8016529,   42.7607651,    5.4545455
  48196,   22.8512402,   42.7607651,    5.4545455
  48197,   21.9008274,   42.7607651,    5.4545455
  48198,   20.9504128,   42.7607651,    5.4545455
  48199,   29.1404972,    41.966507,    5.4545455
  48200,   28.2809906,    41.966507,    5.4545455
  48201,   27.4214878,    41.966507,    5.4545455
  48202,   26.5619831,    41.966507,    5.4545455
  48203,   25.7024803,    41.966507,    5.4545455
  48204,   24.7520657,    41.966507,    5.4545455
  48205,   23.8016529,    41.966507,    5.4545455
  48206,   22.8512402,    41.966507,    5.4545455
  48207,   21.9008274,    41.966507,    5.4545455
  48208,   20.9504128,    41.966507,    5.4545455
  48209,   29.1404972,   41.1722488,    5.4545455
  48210,   28.2809906,   41.1722488,    5.4545455
  48211,   27.4214878,   41.1722488,    5.4545455
  48212,   26.5619831,   41.1722488,    5.4545455
  48213,   25.7024803,   41.1722488,    5.4545455
  48214,   24.7520657,   41.1722488,    5.4545455
  48215,   23.8016529,   41.1722488,    5.4545455
  48216,   22.8512402,   41.1722488,    5.4545455
  48217,   21.9008274,   41.1722488,    5.4545455
  48218,   20.9504128,   41.1722488,    5.4545455
  48219,   29.1404972,   40.3779907,    5.4545455
  48220,   28.2809906,   40.3779907,    5.4545455
  48221,   27.4214878,   40.3779907,    5.4545455
  48222,   26.5619831,   40.3779907,    5.4545455
  48223,   25.7024803,   40.3779907,    5.4545455
  48224,   24.7520657,   40.3779907,    5.4545455
  48225,   23.8016529,   40.3779907,    5.4545455
  48226,   22.8512402,   40.3779907,    5.4545455
  48227,   21.9008274,   40.3779907,    5.4545455
  48228,   20.9504128,   40.3779907,    5.4545455
  48229,   29.1404972,   39.5837326,    5.4545455
  48230,   28.2809906,   39.5837326,    5.4545455
  48231,   27.4214878,   39.5837326,    5.4545455
  48232,   26.5619831,   39.5837326,    5.4545455
  48233,   25.7024803,   39.5837326,    5.4545455
  48234,   24.7520657,   39.5837326,    5.4545455
  48235,   23.8016529,   39.5837326,    5.4545455
  48236,   22.8512402,   39.5837326,    5.4545455
  48237,   21.9008274,   39.5837326,    5.4545455
  48238,   20.9504128,   39.5837326,    5.4545455
  48239,   29.1404972,   38.7894745,    5.4545455
  48240,   28.2809906,   38.7894745,    5.4545455
  48241,   27.4214878,   38.7894745,    5.4545455
  48242,   26.5619831,   38.7894745,    5.4545455
  48243,   25.7024803,   38.7894745,    5.4545455
  48244,   24.7520657,   38.7894745,    5.4545455
  48245,   23.8016529,   38.7894745,    5.4545455
  48246,   22.8512402,   38.7894745,    5.4545455
  48247,   21.9008274,   38.7894745,    5.4545455
  48248,   20.9504128,   38.7894745,    5.4545455
  48249,   29.1404972,   37.9952164,    5.4545455
  48250,   28.2809906,   37.9952164,    5.4545455
  48251,   27.4214878,   37.9952164,    5.4545455
  48252,   26.5619831,   37.9952164,    5.4545455
  48253,   25.7024803,   37.9952164,    5.4545455
  48254,   24.7520657,   37.9952164,    5.4545455
  48255,   23.8016529,   37.9952164,    5.4545455
  48256,   22.8512402,   37.9952164,    5.4545455
  48257,   21.9008274,   37.9952164,    5.4545455
  48258,   20.9504128,   37.9952164,    5.4545455
  48259,   29.1404972,   37.2009583,    5.4545455
  48260,   28.2809906,   37.2009583,    5.4545455
  48261,   27.4214878,   37.2009583,    5.4545455
  48262,   26.5619831,   37.2009583,    5.4545455
  48263,   25.7024803,   37.2009583,    5.4545455
  48264,   24.7520657,   37.2009583,    5.4545455
  48265,   23.8016529,   37.2009583,    5.4545455
  48266,   22.8512402,   37.2009583,    5.4545455
  48267,   21.9008274,   37.2009583,    5.4545455
  48268,   20.9504128,   37.2009583,    5.4545455
  48269,   29.1404972,   36.4067001,    5.4545455
  48270,   28.2809906,   36.4067001,    5.4545455
  48271,   27.4214878,   36.4067001,    5.4545455
  48272,   26.5619831,   36.4067001,    5.4545455
  48273,   25.7024803,   36.4067001,    5.4545455
  48274,   24.7520657,   36.4067001,    5.4545455
  48275,   23.8016529,   36.4067001,    5.4545455
  48276,   22.8512402,   36.4067001,    5.4545455
  48277,   21.9008274,   36.4067001,    5.4545455
  48278,   20.9504128,   36.4067001,    5.4545455
  48279,   29.1404972,    35.612442,    5.4545455
  48280,   28.2809906,    35.612442,    5.4545455
  48281,   27.4214878,    35.612442,    5.4545455
  48282,   26.5619831,    35.612442,    5.4545455
  48283,   25.7024803,    35.612442,    5.4545455
  48284,   24.7520657,    35.612442,    5.4545455
  48285,   23.8016529,    35.612442,    5.4545455
  48286,   22.8512402,    35.612442,    5.4545455
  48287,   21.9008274,    35.612442,    5.4545455
  48288,   20.9504128,    35.612442,    5.4545455
  48289,   29.1404972,   34.8181801,    5.4545455
  48290,   28.2809906,   34.8181801,    5.4545455
  48291,   27.4214878,   34.8181801,    5.4545455
  48292,   26.5619831,   34.8181801,    5.4545455
  48293,   25.7024803,   34.8181801,    5.4545455
  48294,   24.7520657,   34.8181801,    5.4545455
  48295,   23.8016529,   34.8181801,    5.4545455
  48296,   22.8512402,   34.8181801,    5.4545455
  48297,   21.9008274,   34.8181801,    5.4545455
  48298,   20.9504128,   34.8181801,    5.4545455
  48299,   29.1404972,    34.023922,    5.4545455
  48300,   28.2809906,    34.023922,    5.4545455
  48301,   27.4214878,    34.023922,    5.4545455
  48302,   26.5619831,    34.023922,    5.4545455
  48303,   25.7024803,    34.023922,    5.4545455
  48304,   24.7520657,    34.023922,    5.4545455
  48305,   23.8016529,    34.023922,    5.4545455
  48306,   22.8512402,    34.023922,    5.4545455
  48307,   21.9008274,    34.023922,    5.4545455
  48308,   20.9504128,    34.023922,    5.4545455
  48309,   29.1404972,   33.2296638,    5.4545455
  48310,   28.2809906,   33.2296638,    5.4545455
  48311,   27.4214878,   33.2296638,    5.4545455
  48312,   26.5619831,   33.2296638,    5.4545455
  48313,   25.7024803,   33.2296638,    5.4545455
  48314,   24.7520657,   33.2296638,    5.4545455
  48315,   23.8016529,   33.2296638,    5.4545455
  48316,   22.8512402,   33.2296638,    5.4545455
  48317,   21.9008274,   33.2296638,    5.4545455
  48318,   20.9504128,   33.2296638,    5.4545455
  48319,   29.1404972,   32.4354057,    5.4545455
  48320,   28.2809906,   32.4354057,    5.4545455
  48321,   27.4214878,   32.4354057,    5.4545455
  48322,   26.5619831,   32.4354057,    5.4545455
  48323,   25.7024803,   32.4354057,    5.4545455
  48324,   24.7520657,   32.4354057,    5.4545455
  48325,   23.8016529,   32.4354057,    5.4545455
  48326,   22.8512402,   32.4354057,    5.4545455
  48327,   21.9008274,   32.4354057,    5.4545455
  48328,   20.9504128,   32.4354057,    5.4545455
  48329,   29.1404972,   31.6411476,    5.4545455
  48330,   28.2809906,   31.6411476,    5.4545455
  48331,   27.4214878,   31.6411476,    5.4545455
  48332,   26.5619831,   31.6411476,    5.4545455
  48333,   25.7024803,   31.6411476,    5.4545455
  48334,   24.7520657,   31.6411476,    5.4545455
  48335,   23.8016529,   31.6411476,    5.4545455
  48336,   22.8512402,   31.6411476,    5.4545455
  48337,   21.9008274,   31.6411476,    5.4545455
  48338,   20.9504128,   31.6411476,    5.4545455
  48339,   29.1404972,   30.8468895,    5.4545455
  48340,   28.2809906,   30.8468895,    5.4545455
  48341,   27.4214878,   30.8468895,    5.4545455
  48342,   26.5619831,   30.8468895,    5.4545455
  48343,   25.7024803,   30.8468895,    5.4545455
  48344,   24.7520657,   30.8468895,    5.4545455
  48345,   23.8016529,   30.8468895,    5.4545455
  48346,   22.8512402,   30.8468895,    5.4545455
  48347,   21.9008274,   30.8468895,    5.4545455
  48348,   20.9504128,   30.8468895,    5.4545455
  48349,   29.1404972,   30.0526314,    5.4545455
  48350,   28.2809906,   30.0526314,    5.4545455
  48351,   27.4214878,   30.0526314,    5.4545455
  48352,   26.5619831,   30.0526314,    5.4545455
  48353,   25.7024803,   30.0526314,    5.4545455
  48354,   24.7520657,   30.0526314,    5.4545455
  48355,   23.8016529,   30.0526314,    5.4545455
  48356,   22.8512402,   30.0526314,    5.4545455
  48357,   21.9008274,   30.0526314,    5.4545455
  48358,   20.9504128,   30.0526314,    5.4545455
  48359,   29.1404972,   29.2583733,    5.4545455
  48360,   28.2809906,   29.2583733,    5.4545455
  48361,   27.4214878,   29.2583733,    5.4545455
  48362,   26.5619831,   29.2583733,    5.4545455
  48363,   25.7024803,   29.2583733,    5.4545455
  48364,   24.7520657,   29.2583733,    5.4545455
  48365,   23.8016529,   29.2583733,    5.4545455
  48366,   22.8512402,   29.2583733,    5.4545455
  48367,   21.9008274,   29.2583733,    5.4545455
  48368,   20.9504128,   29.2583733,    5.4545455
  48369,   29.1404972,   28.4641151,    5.4545455
  48370,   28.2809906,   28.4641151,    5.4545455
  48371,   27.4214878,   28.4641151,    5.4545455
  48372,   26.5619831,   28.4641151,    5.4545455
  48373,   25.7024803,   28.4641151,    5.4545455
  48374,   24.7520657,   28.4641151,    5.4545455
  48375,   23.8016529,   28.4641151,    5.4545455
  48376,   22.8512402,   28.4641151,    5.4545455
  48377,   21.9008274,   28.4641151,    5.4545455
  48378,   20.9504128,   28.4641151,    5.4545455
  48379,   29.1404972,    27.669857,    5.4545455
  48380,   28.2809906,    27.669857,    5.4545455
  48381,   27.4214878,    27.669857,    5.4545455
  48382,   26.5619831,    27.669857,    5.4545455
  48383,   25.7024803,    27.669857,    5.4545455
  48384,   24.7520657,    27.669857,    5.4545455
  48385,   23.8016529,    27.669857,    5.4545455
  48386,   22.8512402,    27.669857,    5.4545455
  48387,   21.9008274,    27.669857,    5.4545455
  48388,   20.9504128,    27.669857,    5.4545455
  48389,   29.1404972,   26.8755989,    5.4545455
  48390,   28.2809906,   26.8755989,    5.4545455
  48391,   27.4214878,   26.8755989,    5.4545455
  48392,   26.5619831,   26.8755989,    5.4545455
  48393,   25.7024803,   26.8755989,    5.4545455
  48394,   24.7520657,   26.8755989,    5.4545455
  48395,   23.8016529,   26.8755989,    5.4545455
  48396,   22.8512402,   26.8755989,    5.4545455
  48397,   21.9008274,   26.8755989,    5.4545455
  48398,   20.9504128,   26.8755989,    5.4545455
  48399,   29.1404972,   26.0813389,    5.4545455
  48400,   28.2809906,   26.0813389,    5.4545455
  48401,   27.4214878,   26.0813389,    5.4545455
  48402,   26.5619831,   26.0813389,    5.4545455
  48403,   25.7024803,   26.0813389,    5.4545455
  48404,   24.7520657,   26.0813389,    5.4545455
  48405,   23.8016529,   26.0813389,    5.4545455
  48406,   22.8512402,   26.0813389,    5.4545455
  48407,   21.9008274,   26.0813389,    5.4545455
  48408,   20.9504128,   26.0813389,    5.4545455
  48409,   29.1404972,   25.2870808,    5.4545455
  48410,   28.2809906,   25.2870808,    5.4545455
  48411,   27.4214878,   25.2870808,    5.4545455
  48412,   26.5619831,   25.2870808,    5.4545455
  48413,   25.7024803,   25.2870808,    5.4545455
  48414,   24.7520657,   25.2870808,    5.4545455
  48415,   23.8016529,   25.2870808,    5.4545455
  48416,   22.8512402,   25.2870808,    5.4545455
  48417,   21.9008274,   25.2870808,    5.4545455
  48418,   20.9504128,   25.2870808,    5.4545455
  48419,   29.1334133,   24.5317841,    5.4545455
  48420,   28.2668247,   24.5317841,    5.4545455
  48421,   27.4002361,   24.5317841,    5.4545455
  48422,   26.5336475,   24.5317841,    5.4545455
  48423,   25.6670609,   24.5317841,    5.4545455
  48424,   24.7225494,   24.5317841,    5.4545455
  48425,   23.7780399,   24.5317841,    5.4545455
  48426,   22.8335304,   24.5317841,    5.4545455
  48427,   21.8890209,   24.5317841,    5.4545455
  48428,   20.9445095,   24.5317841,    5.4545455
  48429,   29.1263294,   23.7764874,    5.4545455
  48430,   28.2526569,   23.7764874,    5.4545455
  48431,   27.3789845,   23.7764874,    5.4545455
  48432,   26.5053139,   23.7764874,    5.4545455
  48433,   25.6316414,   23.7764874,    5.4545455
  48434,   24.6930351,   23.7764874,    5.4545455
  48435,   23.7544289,   23.7764874,    5.4545455
  48436,   22.8158207,   23.7764874,    5.4545455
  48437,   21.8772144,   23.7764874,    5.4545455
  48438,   20.9386063,   23.7764874,    5.4545455
  48439,   29.1192436,   23.0211887,    5.4545455
  48440,   28.2384892,   23.0211887,    5.4545455
  48441,   27.3577328,   23.0211887,    5.4545455
  48442,   26.4769783,   23.0211887,    5.4545455
  48443,   25.5962219,   23.0211887,    5.4545455
  48444,   24.6635189,   23.0211887,    5.4545455
  48445,   23.7308159,   23.0211887,    5.4545455
  48446,    22.798111,   23.0211887,    5.4545455
  48447,   21.8654079,   23.0211887,    5.4545455
  48448,    20.932703,   23.0211887,    5.4545455
  48449,   29.1121616,    22.265892,    5.4545455
  48450,   28.2243214,    22.265892,    5.4545455
  48451,   27.3364811,    22.265892,    5.4545455
  48452,   26.4486427,    22.265892,    5.4545455
  48453,   25.5608044,    22.265892,    5.4545455
  48454,   24.6340027,    22.265892,    5.4545455
  48455,   23.7072029,    22.265892,    5.4545455
  48456,   22.7804012,    22.265892,    5.4545455
  48457,   21.8536015,    22.265892,    5.4545455
  48458,   20.9267998,    22.265892,    5.4545455
  48459,   29.1050777,   21.5105953,    5.4545455
  48460,   28.2101536,   21.5105953,    5.4545455
  48461,   27.3152313,   21.5105953,    5.4545455
  48462,   26.4203072,   21.5105953,    5.4545455
  48463,   25.5253849,   21.5105953,    5.4545455
  48464,   24.6044865,   21.5105953,    5.4545455
  48465,   23.6835899,   21.5105953,    5.4545455
  48466,   22.7626915,   21.5105953,    5.4545455
  48467,    21.841795,   21.5105953,    5.4545455
  48468,   20.9208965,   21.5105953,    5.4545455
  48469,   29.0979939,   20.7552967,    5.4545455
  48470,   28.1959858,   20.7552967,    5.4545455
  48471,   27.2939796,   20.7552967,    5.4545455
  48472,   26.3919716,   20.7552967,    5.4545455
  48473,   25.4899654,   20.7552967,    5.4545455
  48474,   24.5749702,   20.7552967,    5.4545455
  48475,    23.659977,   20.7552967,    5.4545455
  48476,   22.7449818,   20.7552967,    5.4545455
  48477,   21.8299885,   20.7552967,    5.4545455
  48478,   20.9149933,   20.7552967,    5.4545455
  48479,   29.1008263,   49.1866035,    4.5454545
  48480,   28.2016525,   49.1866035,    4.5454545
  48481,   27.3024788,   49.1866035,    4.5454545
  48482,   26.4033051,   49.1866035,    4.5454545
  48483,   25.5041313,   49.1866035,    4.5454545
  48484,   24.5867767,   49.1866035,    4.5454545
  48485,   23.6694221,   49.1866035,    4.5454545
  48486,   22.7520657,   49.1866035,    4.5454545
  48487,   21.8347111,   49.1866035,    4.5454545
  48488,   20.9173546,   49.1866035,    4.5454545
  48489,   29.1107445,   48.3732071,    4.5454545
  48490,    28.221487,   48.3732071,    4.5454545
  48491,   27.3322315,   48.3732071,    4.5454545
  48492,   26.4429741,   48.3732071,    4.5454545
  48493,   25.5537186,   48.3732071,    4.5454545
  48494,   24.6280994,   48.3732071,    4.5454545
  48495,   23.7024803,   48.3732071,    4.5454545
  48496,   22.7768593,   48.3732071,    4.5454545
  48497,   21.8512402,   48.3732071,    4.5454545
  48498,   20.9256191,   48.3732071,    4.5454545
  48499,   29.1206608,   47.5598068,    4.5454545
  48500,   28.2413216,   47.5598068,    4.5454545
  48501,   27.3619843,   47.5598068,    4.5454545
  48502,    26.482645,   47.5598068,    4.5454545
  48503,   25.6033058,   47.5598068,    4.5454545
  48504,   24.6694221,   47.5598068,    4.5454545
  48505,   23.7355366,   47.5598068,    4.5454545
  48506,   22.8016529,   47.5598068,    4.5454545
  48507,   21.8677673,   47.5598068,    4.5454545
  48508,   20.9338837,   47.5598068,    4.5454545
  48509,    29.130579,   46.7464104,    4.5454545
  48510,   28.2611561,   46.7464104,    4.5454545
  48511,    27.391737,   46.7464104,    4.5454545
  48512,   26.5223141,   46.7464104,    4.5454545
  48513,   25.6528931,   46.7464104,    4.5454545
  48514,    24.710743,   46.7464104,    4.5454545
  48515,   23.7685947,   46.7464104,    4.5454545
  48516,   22.8264446,   46.7464104,    4.5454545
  48517,   21.8842983,   46.7464104,    4.5454545
  48518,   20.9421482,   46.7464104,    4.5454545
  48519,   29.1404953,   45.9330139,    4.5454545
  48520,   28.2809906,   45.9330139,    4.5454545
  48521,   27.4214878,   45.9330139,    4.5454545
  48522,   26.5619831,   45.9330139,    4.5454545
  48523,   25.7024784,   45.9330139,    4.5454545
  48524,   24.7520657,   45.9330139,    4.5454545
  48525,   23.8016529,   45.9330139,    4.5454545
  48526,   22.8512402,   45.9330139,    4.5454545
  48527,   21.9008255,   45.9330139,    4.5454545
  48528,   20.9504128,   45.9330139,    4.5454545
  48529,   29.1504135,   45.1196175,    4.5454545
  48530,    28.300827,   45.1196175,    4.5454545
  48531,   27.4512405,   45.1196175,    4.5454545
  48532,   26.6016521,   45.1196175,    4.5454545
  48533,   25.7520657,   45.1196175,    4.5454545
  48534,   24.7933884,   45.1196175,    4.5454545
  48535,   23.8347111,   45.1196175,    4.5454545
  48536,   22.8760319,   45.1196175,    4.5454545
  48537,   21.9173546,   45.1196175,    4.5454545
  48538,   20.9586773,   45.1196175,    4.5454545
  48539,   29.1504135,   44.3244019,    4.5454545
  48540,    28.300827,   44.3244019,    4.5454545
  48541,   27.4512405,   44.3244019,    4.5454545
  48542,   26.6016521,   44.3244019,    4.5454545
  48543,   25.7520657,   44.3244019,    4.5454545
  48544,   24.7933884,   44.3244019,    4.5454545
  48545,   23.8347111,   44.3244019,    4.5454545
  48546,   22.8760319,   44.3244019,    4.5454545
  48547,   21.9173546,   44.3244019,    4.5454545
  48548,   20.9586773,   44.3244019,    4.5454545
  48549,   29.1504135,   43.5291862,    4.5454545
  48550,    28.300827,   43.5291862,    4.5454545
  48551,   27.4512405,   43.5291862,    4.5454545
  48552,   26.6016521,   43.5291862,    4.5454545
  48553,   25.7520657,   43.5291862,    4.5454545
  48554,   24.7933884,   43.5291862,    4.5454545
  48555,   23.8347111,   43.5291862,    4.5454545
  48556,   22.8760319,   43.5291862,    4.5454545
  48557,   21.9173546,   43.5291862,    4.5454545
  48558,   20.9586773,   43.5291862,    4.5454545
  48559,   29.1504135,   42.7339706,    4.5454545
  48560,    28.300827,   42.7339706,    4.5454545
  48561,   27.4512405,   42.7339706,    4.5454545
  48562,   26.6016521,   42.7339706,    4.5454545
  48563,   25.7520657,   42.7339706,    4.5454545
  48564,   24.7933884,   42.7339706,    4.5454545
  48565,   23.8347111,   42.7339706,    4.5454545
  48566,   22.8760319,   42.7339706,    4.5454545
  48567,   21.9173546,   42.7339706,    4.5454545
  48568,   20.9586773,   42.7339706,    4.5454545
  48569,   29.1504135,    41.938755,    4.5454545
  48570,    28.300827,    41.938755,    4.5454545
  48571,   27.4512405,    41.938755,    4.5454545
  48572,   26.6016521,    41.938755,    4.5454545
  48573,   25.7520657,    41.938755,    4.5454545
  48574,   24.7933884,    41.938755,    4.5454545
  48575,   23.8347111,    41.938755,    4.5454545
  48576,   22.8760319,    41.938755,    4.5454545
  48577,   21.9173546,    41.938755,    4.5454545
  48578,   20.9586773,    41.938755,    4.5454545
  48579,   29.1504135,   41.1435394,    4.5454545
  48580,    28.300827,   41.1435394,    4.5454545
  48581,   27.4512405,   41.1435394,    4.5454545
  48582,   26.6016521,   41.1435394,    4.5454545
  48583,   25.7520657,   41.1435394,    4.5454545
  48584,   24.7933884,   41.1435394,    4.5454545
  48585,   23.8347111,   41.1435394,    4.5454545
  48586,   22.8760319,   41.1435394,    4.5454545
  48587,   21.9173546,   41.1435394,    4.5454545
  48588,   20.9586773,   41.1435394,    4.5454545
  48589,   29.1504135,   40.3483238,    4.5454545
  48590,    28.300827,   40.3483238,    4.5454545
  48591,   27.4512405,   40.3483238,    4.5454545
  48592,   26.6016521,   40.3483238,    4.5454545
  48593,   25.7520657,   40.3483238,    4.5454545
  48594,   24.7933884,   40.3483238,    4.5454545
  48595,   23.8347111,   40.3483238,    4.5454545
  48596,   22.8760319,   40.3483238,    4.5454545
  48597,   21.9173546,   40.3483238,    4.5454545
  48598,   20.9586773,   40.3483238,    4.5454545
  48599,   29.1504135,   39.5531082,    4.5454545
  48600,    28.300827,   39.5531082,    4.5454545
  48601,   27.4512405,   39.5531082,    4.5454545
  48602,   26.6016521,   39.5531082,    4.5454545
  48603,   25.7520657,   39.5531082,    4.5454545
  48604,   24.7933884,   39.5531082,    4.5454545
  48605,   23.8347111,   39.5531082,    4.5454545
  48606,   22.8760319,   39.5531082,    4.5454545
  48607,   21.9173546,   39.5531082,    4.5454545
  48608,   20.9586773,   39.5531082,    4.5454545
  48609,   29.1504135,   38.7578964,    4.5454545
  48610,    28.300827,   38.7578964,    4.5454545
  48611,   27.4512405,   38.7578964,    4.5454545
  48612,   26.6016521,   38.7578964,    4.5454545
  48613,   25.7520657,   38.7578964,    4.5454545
  48614,   24.7933884,   38.7578964,    4.5454545
  48615,   23.8347111,   38.7578964,    4.5454545
  48616,   22.8760319,   38.7578964,    4.5454545
  48617,   21.9173546,   38.7578964,    4.5454545
  48618,   20.9586773,   38.7578964,    4.5454545
  48619,   29.1504135,   37.9626808,    4.5454545
  48620,    28.300827,   37.9626808,    4.5454545
  48621,   27.4512405,   37.9626808,    4.5454545
  48622,   26.6016521,   37.9626808,    4.5454545
  48623,   25.7520657,   37.9626808,    4.5454545
  48624,   24.7933884,   37.9626808,    4.5454545
  48625,   23.8347111,   37.9626808,    4.5454545
  48626,   22.8760319,   37.9626808,    4.5454545
  48627,   21.9173546,   37.9626808,    4.5454545
  48628,   20.9586773,   37.9626808,    4.5454545
  48629,   29.1504135,   37.1674652,    4.5454545
  48630,    28.300827,   37.1674652,    4.5454545
  48631,   27.4512405,   37.1674652,    4.5454545
  48632,   26.6016521,   37.1674652,    4.5454545
  48633,   25.7520657,   37.1674652,    4.5454545
  48634,   24.7933884,   37.1674652,    4.5454545
  48635,   23.8347111,   37.1674652,    4.5454545
  48636,   22.8760319,   37.1674652,    4.5454545
  48637,   21.9173546,   37.1674652,    4.5454545
  48638,   20.9586773,   37.1674652,    4.5454545
  48639,   29.1504135,   36.3722496,    4.5454545
  48640,    28.300827,   36.3722496,    4.5454545
  48641,   27.4512405,   36.3722496,    4.5454545
  48642,   26.6016521,   36.3722496,    4.5454545
  48643,   25.7520657,   36.3722496,    4.5454545
  48644,   24.7933884,   36.3722496,    4.5454545
  48645,   23.8347111,   36.3722496,    4.5454545
  48646,   22.8760319,   36.3722496,    4.5454545
  48647,   21.9173546,   36.3722496,    4.5454545
  48648,   20.9586773,   36.3722496,    4.5454545
  48649,   29.1504135,    35.577034,    4.5454545
  48650,    28.300827,    35.577034,    4.5454545
  48651,   27.4512405,    35.577034,    4.5454545
  48652,   26.6016521,    35.577034,    4.5454545
  48653,   25.7520657,    35.577034,    4.5454545
  48654,   24.7933884,    35.577034,    4.5454545
  48655,   23.8347111,    35.577034,    4.5454545
  48656,   22.8760319,    35.577034,    4.5454545
  48657,   21.9173546,    35.577034,    4.5454545
  48658,   20.9586773,    35.577034,    4.5454545
  48659,   29.1504135,   34.7818184,    4.5454545
  48660,    28.300827,   34.7818184,    4.5454545
  48661,   27.4512405,   34.7818184,    4.5454545
  48662,   26.6016521,   34.7818184,    4.5454545
  48663,   25.7520657,   34.7818184,    4.5454545
  48664,   24.7933884,   34.7818184,    4.5454545
  48665,   23.8347111,   34.7818184,    4.5454545
  48666,   22.8760319,   34.7818184,    4.5454545
  48667,   21.9173546,   34.7818184,    4.5454545
  48668,   20.9586773,   34.7818184,    4.5454545
  48669,   29.1504135,   33.9866028,    4.5454545
  48670,    28.300827,   33.9866028,    4.5454545
  48671,   27.4512405,   33.9866028,    4.5454545
  48672,   26.6016521,   33.9866028,    4.5454545
  48673,   25.7520657,   33.9866028,    4.5454545
  48674,   24.7933884,   33.9866028,    4.5454545
  48675,   23.8347111,   33.9866028,    4.5454545
  48676,   22.8760319,   33.9866028,    4.5454545
  48677,   21.9173546,   33.9866028,    4.5454545
  48678,   20.9586773,   33.9866028,    4.5454545
  48679,   29.1504135,   33.1913872,    4.5454545
  48680,    28.300827,   33.1913872,    4.5454545
  48681,   27.4512405,   33.1913872,    4.5454545
  48682,   26.6016521,   33.1913872,    4.5454545
  48683,   25.7520657,   33.1913872,    4.5454545
  48684,   24.7933884,   33.1913872,    4.5454545
  48685,   23.8347111,   33.1913872,    4.5454545
  48686,   22.8760319,   33.1913872,    4.5454545
  48687,   21.9173546,   33.1913872,    4.5454545
  48688,   20.9586773,   33.1913872,    4.5454545
  48689,   29.1504135,   32.3961716,    4.5454545
  48690,    28.300827,   32.3961716,    4.5454545
  48691,   27.4512405,   32.3961716,    4.5454545
  48692,   26.6016521,   32.3961716,    4.5454545
  48693,   25.7520657,   32.3961716,    4.5454545
  48694,   24.7933884,   32.3961716,    4.5454545
  48695,   23.8347111,   32.3961716,    4.5454545
  48696,   22.8760319,   32.3961716,    4.5454545
  48697,   21.9173546,   32.3961716,    4.5454545
  48698,   20.9586773,   32.3961716,    4.5454545
  48699,   29.1504135,   31.6009579,    4.5454545
  48700,    28.300827,   31.6009579,    4.5454545
  48701,   27.4512405,   31.6009579,    4.5454545
  48702,   26.6016521,   31.6009579,    4.5454545
  48703,   25.7520657,   31.6009579,    4.5454545
  48704,   24.7933884,   31.6009579,    4.5454545
  48705,   23.8347111,   31.6009579,    4.5454545
  48706,   22.8760319,   31.6009579,    4.5454545
  48707,   21.9173546,   31.6009579,    4.5454545
  48708,   20.9586773,   31.6009579,    4.5454545
  48709,   29.1504135,   30.8057423,    4.5454545
  48710,    28.300827,   30.8057423,    4.5454545
  48711,   27.4512405,   30.8057423,    4.5454545
  48712,   26.6016521,   30.8057423,    4.5454545
  48713,   25.7520657,   30.8057423,    4.5454545
  48714,   24.7933884,   30.8057423,    4.5454545
  48715,   23.8347111,   30.8057423,    4.5454545
  48716,   22.8760319,   30.8057423,    4.5454545
  48717,   21.9173546,   30.8057423,    4.5454545
  48718,   20.9586773,   30.8057423,    4.5454545
  48719,   29.1504135,   30.0105267,    4.5454545
  48720,    28.300827,   30.0105267,    4.5454545
  48721,   27.4512405,   30.0105267,    4.5454545
  48722,   26.6016521,   30.0105267,    4.5454545
  48723,   25.7520657,   30.0105267,    4.5454545
  48724,   24.7933884,   30.0105267,    4.5454545
  48725,   23.8347111,   30.0105267,    4.5454545
  48726,   22.8760319,   30.0105267,    4.5454545
  48727,   21.9173546,   30.0105267,    4.5454545
  48728,   20.9586773,   30.0105267,    4.5454545
  48729,   29.1504135,   29.2153111,    4.5454545
  48730,    28.300827,   29.2153111,    4.5454545
  48731,   27.4512405,   29.2153111,    4.5454545
  48732,   26.6016521,   29.2153111,    4.5454545
  48733,   25.7520657,   29.2153111,    4.5454545
  48734,   24.7933884,   29.2153111,    4.5454545
  48735,   23.8347111,   29.2153111,    4.5454545
  48736,   22.8760319,   29.2153111,    4.5454545
  48737,   21.9173546,   29.2153111,    4.5454545
  48738,   20.9586773,   29.2153111,    4.5454545
  48739,   29.1504135,   28.4200954,    4.5454545
  48740,    28.300827,   28.4200954,    4.5454545
  48741,   27.4512405,   28.4200954,    4.5454545
  48742,   26.6016521,   28.4200954,    4.5454545
  48743,   25.7520657,   28.4200954,    4.5454545
  48744,   24.7933884,   28.4200954,    4.5454545
  48745,   23.8347111,   28.4200954,    4.5454545
  48746,   22.8760319,   28.4200954,    4.5454545
  48747,   21.9173546,   28.4200954,    4.5454545
  48748,   20.9586773,   28.4200954,    4.5454545
  48749,   29.1504135,   27.6248798,    4.5454545
  48750,    28.300827,   27.6248798,    4.5454545
  48751,   27.4512405,   27.6248798,    4.5454545
  48752,   26.6016521,   27.6248798,    4.5454545
  48753,   25.7520657,   27.6248798,    4.5454545
  48754,   24.7933884,   27.6248798,    4.5454545
  48755,   23.8347111,   27.6248798,    4.5454545
  48756,   22.8760319,   27.6248798,    4.5454545
  48757,   21.9173546,   27.6248798,    4.5454545
  48758,   20.9586773,   27.6248798,    4.5454545
  48759,   29.1504135,   26.8296642,    4.5454545
  48760,    28.300827,   26.8296642,    4.5454545
  48761,   27.4512405,   26.8296642,    4.5454545
  48762,   26.6016521,   26.8296642,    4.5454545
  48763,   25.7520657,   26.8296642,    4.5454545
  48764,   24.7933884,   26.8296642,    4.5454545
  48765,   23.8347111,   26.8296642,    4.5454545
  48766,   22.8760319,   26.8296642,    4.5454545
  48767,   21.9173546,   26.8296642,    4.5454545
  48768,   20.9586773,   26.8296642,    4.5454545
  48769,   29.1504135,   26.0344505,    4.5454545
  48770,    28.300827,   26.0344505,    4.5454545
  48771,   27.4512405,   26.0344505,    4.5454545
  48772,   26.6016521,   26.0344505,    4.5454545
  48773,   25.7520657,   26.0344505,    4.5454545
  48774,   24.7933884,   26.0344505,    4.5454545
  48775,   23.8347111,   26.0344505,    4.5454545
  48776,   22.8760319,   26.0344505,    4.5454545
  48777,   21.9173546,   26.0344505,    4.5454545
  48778,   20.9586773,   26.0344505,    4.5454545
  48779,   29.1504135,   25.2392349,    4.5454545
  48780,    28.300827,   25.2392349,    4.5454545
  48781,   27.4512405,   25.2392349,    4.5454545
  48782,   26.6016521,   25.2392349,    4.5454545
  48783,   25.7520657,   25.2392349,    4.5454545
  48784,   24.7933884,   25.2392349,    4.5454545
  48785,   23.8347111,   25.2392349,    4.5454545
  48786,   22.8760319,   25.2392349,    4.5454545
  48787,   21.9173546,   25.2392349,    4.5454545
  48788,   20.9586773,   25.2392349,    4.5454545
  48789,   29.1419125,   24.4907722,    4.5454545
  48790,   28.2838249,   24.4907722,    4.5454545
  48791,   27.4257393,   24.4907722,    4.5454545
  48792,   26.5676517,   24.4907722,    4.5454545
  48793,   25.7095623,   24.4907722,    4.5454545
  48794,   24.7579689,   24.4907722,    4.5454545
  48795,   23.8063755,   24.4907722,    4.5454545
  48796,   22.8547802,   24.4907722,    4.5454545
  48797,   21.9031868,   24.4907722,    4.5454545
  48798,   20.9515934,   24.4907722,    4.5454545
  48799,   29.1334114,   23.7423096,    4.5454545
  48800,   28.2668228,   23.7423096,    4.5454545
  48801,   27.4002361,   23.7423096,    4.5454545
  48802,   26.5336475,   23.7423096,    4.5454545
  48803,   25.6670609,   23.7423096,    4.5454545
  48804,   24.7225494,   23.7423096,    4.5454545
  48805,   23.7780399,   23.7423096,    4.5454545
  48806,   22.8335285,   23.7423096,    4.5454545
  48807,    21.889019,   23.7423096,    4.5454545
  48808,   20.9445095,   23.7423096,    4.5454545
  48809,   29.1249123,   22.9938488,    4.5454545
  48810,   28.2498226,   22.9938488,    4.5454545
  48811,   27.3747349,   22.9938488,    4.5454545
  48812,   26.4996452,   22.9938488,    4.5454545
  48813,   25.6245575,   22.9938488,    4.5454545
  48814,     24.68713,   22.9938488,    4.5454545
  48815,   23.7497044,   22.9938488,    4.5454545
  48816,   22.8122787,   22.9938488,    4.5454545
  48817,   21.8748512,   22.9938488,    4.5454545
  48818,   20.9374256,   22.9938488,    4.5454545
  48819,   29.1164112,   22.2453861,    4.5454545
  48820,   28.2328205,   22.2453861,    4.5454545
  48821,   27.3492336,   22.2453861,    4.5454545
  48822,   26.4656429,   22.2453861,    4.5454545
  48823,   25.5820541,   22.2453861,    4.5454545
  48824,   24.6517105,   22.2453861,    4.5454545
  48825,   23.7213688,   22.2453861,    4.5454545
  48826,   22.7910271,   22.2453861,    4.5454545
  48827,   21.8606853,   22.2453861,    4.5454545
  48828,   20.9303417,   22.2453861,    4.5454545
  48829,   29.1079102,   21.4969234,    4.5454545
  48830,   28.2158203,   21.4969234,    4.5454545
  48831,   27.3237305,   21.4969234,    4.5454545
  48832,   26.4316406,   21.4969234,    4.5454545
  48833,   25.5395508,   21.4969234,    4.5454545
  48834,    24.616293,   21.4969234,    4.5454545
  48835,   23.6930332,   21.4969234,    4.5454545
  48836,   22.7697754,   21.4969234,    4.5454545
  48837,   21.8465176,   21.4969234,    4.5454545
  48838,   20.9232578,   21.4969234,    4.5454545
  48839,   29.0994091,   20.7484627,    4.5454545
  48840,   28.1988201,   20.7484627,    4.5454545
  48841,   27.2982292,   20.7484627,    4.5454545
  48842,   26.3976383,   20.7484627,    4.5454545
  48843,   25.4970474,   20.7484627,    4.5454545
  48844,   24.5808735,   20.7484627,    4.5454545
  48845,   23.6646996,   20.7484627,    4.5454545
  48846,   22.7485237,   20.7484627,    4.5454545
  48847,   21.8323498,   20.7484627,    4.5454545
  48848,   20.9161739,   20.7484627,    4.5454545
  48849,   29.1024799,   49.1826172,   3.63636374
  48850,    28.204958,   49.1826172,   3.63636374
  48851,   27.3074379,   49.1826172,   3.63636374
  48852,   26.4099178,   49.1826172,   3.63636374
  48853,   25.5123959,   49.1826172,   3.63636374
  48854,   24.5936642,   49.1826172,   3.63636374
  48855,   23.6749306,   49.1826172,   3.63636374
  48856,   22.7561989,   49.1826172,   3.63636374
  48857,   21.8374653,   49.1826172,   3.63636374
  48858,   20.9187317,   49.1826172,   3.63636374
  48859,   29.1140499,   48.3652306,   3.63636374
  48860,   28.2280998,   48.3652306,   3.63636374
  48861,   27.3421497,   48.3652306,   3.63636374
  48862,   26.4561977,   48.3652306,   3.63636374
  48863,   25.5702477,   48.3652306,   3.63636374
  48864,   24.6418724,   48.3652306,   3.63636374
  48865,   23.7134991,   48.3652306,   3.63636374
  48866,   22.7851238,   48.3652306,   3.63636374
  48867,   21.8567486,   48.3652306,   3.63636374
  48868,   20.9283752,   48.3652306,   3.63636374
  48869,   29.1256199,   47.5478477,   3.63636374
  48870,   28.2512398,   47.5478477,   3.63636374
  48871,   27.3768597,   47.5478477,   3.63636374
  48872,   26.5024796,   47.5478477,   3.63636374
  48873,   25.6280994,   47.5478477,   3.63636374
  48874,   24.6900826,   47.5478477,   3.63636374
  48875,   23.7520657,   47.5478477,   3.63636374
  48876,   22.8140488,   47.5478477,   3.63636374
  48877,   21.8760319,   47.5478477,   3.63636374
  48878,   20.9380169,   47.5478477,   3.63636374
  48879,   29.1371918,   46.7304611,   3.63636374
  48880,   28.2743797,   46.7304611,   3.63636374
  48881,   27.4115715,   46.7304611,   3.63636374
  48882,   26.5487595,   46.7304611,   3.63636374
  48883,   25.6859512,   46.7304611,   3.63636374
  48884,   24.7382908,   46.7304611,   3.63636374
  48885,   23.7906342,   46.7304611,   3.63636374
  48886,   22.8429737,   46.7304611,   3.63636374
  48887,   21.8953171,   46.7304611,   3.63636374
  48888,   20.9476566,   46.7304611,   3.63636374
  48889,   29.1487598,   45.9130783,   3.63636374
  48890,   28.2975197,   45.9130783,   3.63636374
  48891,   27.4462814,   45.9130783,   3.63636374
  48892,   26.5950413,   45.9130783,   3.63636374
  48893,   25.7438011,   45.9130783,   3.63636374
  48894,   24.7865009,   45.9130783,   3.63636374
  48895,   23.8292007,   45.9130783,   3.63636374
  48896,   22.8719006,   45.9130783,   3.63636374
  48897,   21.9146004,   45.9130783,   3.63636374
  48898,   20.9573002,   45.9130783,   3.63636374
  48899,   29.1603317,   45.0956955,   3.63636374
  48900,   28.3206615,   45.0956955,   3.63636374
  48901,   27.4809914,   45.0956955,   3.63636374
  48902,   26.6413212,   45.0956955,   3.63636374
  48903,   25.8016529,   45.0956955,   3.63636374
  48904,   24.8347111,   45.0956955,   3.63636374
  48905,   23.8677692,   45.0956955,   3.63636374
  48906,   22.9008255,   45.0956955,   3.63636374
  48907,   21.9338837,   45.0956955,   3.63636374
  48908,   20.9669418,   45.0956955,   3.63636374
  48909,   29.1603317,   44.2995224,   3.63636374
  48910,   28.3206615,   44.2995224,   3.63636374
  48911,   27.4809914,   44.2995224,   3.63636374
  48912,   26.6413212,   44.2995224,   3.63636374
  48913,   25.8016529,   44.2995224,   3.63636374
  48914,   24.8347111,   44.2995224,   3.63636374
  48915,   23.8677692,   44.2995224,   3.63636374
  48916,   22.9008255,   44.2995224,   3.63636374
  48917,   21.9338837,   44.2995224,   3.63636374
  48918,   20.9669418,   44.2995224,   3.63636374
  48919,   29.1603317,   43.5033493,   3.63636374
  48920,   28.3206615,   43.5033493,   3.63636374
  48921,   27.4809914,   43.5033493,   3.63636374
  48922,   26.6413212,   43.5033493,   3.63636374
  48923,   25.8016529,   43.5033493,   3.63636374
  48924,   24.8347111,   43.5033493,   3.63636374
  48925,   23.8677692,   43.5033493,   3.63636374
  48926,   22.9008255,   43.5033493,   3.63636374
  48927,   21.9338837,   43.5033493,   3.63636374
  48928,   20.9669418,   43.5033493,   3.63636374
  48929,   29.1603317,   42.7071762,   3.63636374
  48930,   28.3206615,   42.7071762,   3.63636374
  48931,   27.4809914,   42.7071762,   3.63636374
  48932,   26.6413212,   42.7071762,   3.63636374
  48933,   25.8016529,   42.7071762,   3.63636374
  48934,   24.8347111,   42.7071762,   3.63636374
  48935,   23.8677692,   42.7071762,   3.63636374
  48936,   22.9008255,   42.7071762,   3.63636374
  48937,   21.9338837,   42.7071762,   3.63636374
  48938,   20.9669418,   42.7071762,   3.63636374
  48939,   29.1603317,   41.9110031,   3.63636374
  48940,   28.3206615,   41.9110031,   3.63636374
  48941,   27.4809914,   41.9110031,   3.63636374
  48942,   26.6413212,   41.9110031,   3.63636374
  48943,   25.8016529,   41.9110031,   3.63636374
  48944,   24.8347111,   41.9110031,   3.63636374
  48945,   23.8677692,   41.9110031,   3.63636374
  48946,   22.9008255,   41.9110031,   3.63636374
  48947,   21.9338837,   41.9110031,   3.63636374
  48948,   20.9669418,   41.9110031,   3.63636374
  48949,   29.1603317,   41.1148338,   3.63636374
  48950,   28.3206615,   41.1148338,   3.63636374
  48951,   27.4809914,   41.1148338,   3.63636374
  48952,   26.6413212,   41.1148338,   3.63636374
  48953,   25.8016529,   41.1148338,   3.63636374
  48954,   24.8347111,   41.1148338,   3.63636374
  48955,   23.8677692,   41.1148338,   3.63636374
  48956,   22.9008255,   41.1148338,   3.63636374
  48957,   21.9338837,   41.1148338,   3.63636374
  48958,   20.9669418,   41.1148338,   3.63636374
  48959,   29.1603317,   40.3186607,   3.63636374
  48960,   28.3206615,   40.3186607,   3.63636374
  48961,   27.4809914,   40.3186607,   3.63636374
  48962,   26.6413212,   40.3186607,   3.63636374
  48963,   25.8016529,   40.3186607,   3.63636374
  48964,   24.8347111,   40.3186607,   3.63636374
  48965,   23.8677692,   40.3186607,   3.63636374
  48966,   22.9008255,   40.3186607,   3.63636374
  48967,   21.9338837,   40.3186607,   3.63636374
  48968,   20.9669418,   40.3186607,   3.63636374
  48969,   29.1603317,   39.5224876,   3.63636374
  48970,   28.3206615,   39.5224876,   3.63636374
  48971,   27.4809914,   39.5224876,   3.63636374
  48972,   26.6413212,   39.5224876,   3.63636374
  48973,   25.8016529,   39.5224876,   3.63636374
  48974,   24.8347111,   39.5224876,   3.63636374
  48975,   23.8677692,   39.5224876,   3.63636374
  48976,   22.9008255,   39.5224876,   3.63636374
  48977,   21.9338837,   39.5224876,   3.63636374
  48978,   20.9669418,   39.5224876,   3.63636374
  48979,   29.1603317,   38.7263145,   3.63636374
  48980,   28.3206615,   38.7263145,   3.63636374
  48981,   27.4809914,   38.7263145,   3.63636374
  48982,   26.6413212,   38.7263145,   3.63636374
  48983,   25.8016529,   38.7263145,   3.63636374
  48984,   24.8347111,   38.7263145,   3.63636374
  48985,   23.8677692,   38.7263145,   3.63636374
  48986,   22.9008255,   38.7263145,   3.63636374
  48987,   21.9338837,   38.7263145,   3.63636374
  48988,   20.9669418,   38.7263145,   3.63636374
  48989,   29.1603317,   37.9301453,   3.63636374
  48990,   28.3206615,   37.9301453,   3.63636374
  48991,   27.4809914,   37.9301453,   3.63636374
  48992,   26.6413212,   37.9301453,   3.63636374
  48993,   25.8016529,   37.9301453,   3.63636374
  48994,   24.8347111,   37.9301453,   3.63636374
  48995,   23.8677692,   37.9301453,   3.63636374
  48996,   22.9008255,   37.9301453,   3.63636374
  48997,   21.9338837,   37.9301453,   3.63636374
  48998,   20.9669418,   37.9301453,   3.63636374
  48999,   29.1603317,   37.1339722,   3.63636374
  49000,   28.3206615,   37.1339722,   3.63636374
  49001,   27.4809914,   37.1339722,   3.63636374
  49002,   26.6413212,   37.1339722,   3.63636374
  49003,   25.8016529,   37.1339722,   3.63636374
  49004,   24.8347111,   37.1339722,   3.63636374
  49005,   23.8677692,   37.1339722,   3.63636374
  49006,   22.9008255,   37.1339722,   3.63636374
  49007,   21.9338837,   37.1339722,   3.63636374
  49008,   20.9669418,   37.1339722,   3.63636374
  49009,   29.1603317,   36.3377991,   3.63636374
  49010,   28.3206615,   36.3377991,   3.63636374
  49011,   27.4809914,   36.3377991,   3.63636374
  49012,   26.6413212,   36.3377991,   3.63636374
  49013,   25.8016529,   36.3377991,   3.63636374
  49014,   24.8347111,   36.3377991,   3.63636374
  49015,   23.8677692,   36.3377991,   3.63636374
  49016,   22.9008255,   36.3377991,   3.63636374
  49017,   21.9338837,   36.3377991,   3.63636374
  49018,   20.9669418,   36.3377991,   3.63636374
  49019,   29.1603317,    35.541626,   3.63636374
  49020,   28.3206615,    35.541626,   3.63636374
  49021,   27.4809914,    35.541626,   3.63636374
  49022,   26.6413212,    35.541626,   3.63636374
  49023,   25.8016529,    35.541626,   3.63636374
  49024,   24.8347111,    35.541626,   3.63636374
  49025,   23.8677692,    35.541626,   3.63636374
  49026,   22.9008255,    35.541626,   3.63636374
  49027,   21.9338837,    35.541626,   3.63636374
  49028,   20.9669418,    35.541626,   3.63636374
  49029,   29.1603317,   34.7454529,   3.63636374
  49030,   28.3206615,   34.7454529,   3.63636374
  49031,   27.4809914,   34.7454529,   3.63636374
  49032,   26.6413212,   34.7454529,   3.63636374
  49033,   25.8016529,   34.7454529,   3.63636374
  49034,   24.8347111,   34.7454529,   3.63636374
  49035,   23.8677692,   34.7454529,   3.63636374
  49036,   22.9008255,   34.7454529,   3.63636374
  49037,   21.9338837,   34.7454529,   3.63636374
  49038,   20.9669418,   34.7454529,   3.63636374
  49039,   29.1603317,   33.9492836,   3.63636374
  49040,   28.3206615,   33.9492836,   3.63636374
  49041,   27.4809914,   33.9492836,   3.63636374
  49042,   26.6413212,   33.9492836,   3.63636374
  49043,   25.8016529,   33.9492836,   3.63636374
  49044,   24.8347111,   33.9492836,   3.63636374
  49045,   23.8677692,   33.9492836,   3.63636374
  49046,   22.9008255,   33.9492836,   3.63636374
  49047,   21.9338837,   33.9492836,   3.63636374
  49048,   20.9669418,   33.9492836,   3.63636374
  49049,   29.1603317,   33.1531105,   3.63636374
  49050,   28.3206615,   33.1531105,   3.63636374
  49051,   27.4809914,   33.1531105,   3.63636374
  49052,   26.6413212,   33.1531105,   3.63636374
  49053,   25.8016529,   33.1531105,   3.63636374
  49054,   24.8347111,   33.1531105,   3.63636374
  49055,   23.8677692,   33.1531105,   3.63636374
  49056,   22.9008255,   33.1531105,   3.63636374
  49057,   21.9338837,   33.1531105,   3.63636374
  49058,   20.9669418,   33.1531105,   3.63636374
  49059,   29.1603317,   32.3569374,   3.63636374
  49060,   28.3206615,   32.3569374,   3.63636374
  49061,   27.4809914,   32.3569374,   3.63636374
  49062,   26.6413212,   32.3569374,   3.63636374
  49063,   25.8016529,   32.3569374,   3.63636374
  49064,   24.8347111,   32.3569374,   3.63636374
  49065,   23.8677692,   32.3569374,   3.63636374
  49066,   22.9008255,   32.3569374,   3.63636374
  49067,   21.9338837,   32.3569374,   3.63636374
  49068,   20.9669418,   32.3569374,   3.63636374
  49069,   29.1603317,   31.5607662,   3.63636374
  49070,   28.3206615,   31.5607662,   3.63636374
  49071,   27.4809914,   31.5607662,   3.63636374
  49072,   26.6413212,   31.5607662,   3.63636374
  49073,   25.8016529,   31.5607662,   3.63636374
  49074,   24.8347111,   31.5607662,   3.63636374
  49075,   23.8677692,   31.5607662,   3.63636374
  49076,   22.9008255,   31.5607662,   3.63636374
  49077,   21.9338837,   31.5607662,   3.63636374
  49078,   20.9669418,   31.5607662,   3.63636374
  49079,   29.1603317,   30.7645931,   3.63636374
  49080,   28.3206615,   30.7645931,   3.63636374
  49081,   27.4809914,   30.7645931,   3.63636374
  49082,   26.6413212,   30.7645931,   3.63636374
  49083,   25.8016529,   30.7645931,   3.63636374
  49084,   24.8347111,   30.7645931,   3.63636374
  49085,   23.8677692,   30.7645931,   3.63636374
  49086,   22.9008255,   30.7645931,   3.63636374
  49087,   21.9338837,   30.7645931,   3.63636374
  49088,   20.9669418,   30.7645931,   3.63636374
  49089,   29.1603317,   29.9684219,   3.63636374
  49090,   28.3206615,   29.9684219,   3.63636374
  49091,   27.4809914,   29.9684219,   3.63636374
  49092,   26.6413212,   29.9684219,   3.63636374
  49093,   25.8016529,   29.9684219,   3.63636374
  49094,   24.8347111,   29.9684219,   3.63636374
  49095,   23.8677692,   29.9684219,   3.63636374
  49096,   22.9008255,   29.9684219,   3.63636374
  49097,   21.9338837,   29.9684219,   3.63636374
  49098,   20.9669418,   29.9684219,   3.63636374
  49099,   29.1603317,   29.1722488,   3.63636374
  49100,   28.3206615,   29.1722488,   3.63636374
  49101,   27.4809914,   29.1722488,   3.63636374
  49102,   26.6413212,   29.1722488,   3.63636374
  49103,   25.8016529,   29.1722488,   3.63636374
  49104,   24.8347111,   29.1722488,   3.63636374
  49105,   23.8677692,   29.1722488,   3.63636374
  49106,   22.9008255,   29.1722488,   3.63636374
  49107,   21.9338837,   29.1722488,   3.63636374
  49108,   20.9669418,   29.1722488,   3.63636374
  49109,   29.1603317,   28.3760757,   3.63636374
  49110,   28.3206615,   28.3760757,   3.63636374
  49111,   27.4809914,   28.3760757,   3.63636374
  49112,   26.6413212,   28.3760757,   3.63636374
  49113,   25.8016529,   28.3760757,   3.63636374
  49114,   24.8347111,   28.3760757,   3.63636374
  49115,   23.8677692,   28.3760757,   3.63636374
  49116,   22.9008255,   28.3760757,   3.63636374
  49117,   21.9338837,   28.3760757,   3.63636374
  49118,   20.9669418,   28.3760757,   3.63636374
  49119,   29.1603317,   27.5799046,   3.63636374
  49120,   28.3206615,   27.5799046,   3.63636374
  49121,   27.4809914,   27.5799046,   3.63636374
  49122,   26.6413212,   27.5799046,   3.63636374
  49123,   25.8016529,   27.5799046,   3.63636374
  49124,   24.8347111,   27.5799046,   3.63636374
  49125,   23.8677692,   27.5799046,   3.63636374
  49126,   22.9008255,   27.5799046,   3.63636374
  49127,   21.9338837,   27.5799046,   3.63636374
  49128,   20.9669418,   27.5799046,   3.63636374
  49129,   29.1603317,   26.7837315,   3.63636374
  49130,   28.3206615,   26.7837315,   3.63636374
  49131,   27.4809914,   26.7837315,   3.63636374
  49132,   26.6413212,   26.7837315,   3.63636374
  49133,   25.8016529,   26.7837315,   3.63636374
  49134,   24.8347111,   26.7837315,   3.63636374
  49135,   23.8677692,   26.7837315,   3.63636374
  49136,   22.9008255,   26.7837315,   3.63636374
  49137,   21.9338837,   26.7837315,   3.63636374
  49138,   20.9669418,   26.7837315,   3.63636374
  49139,   29.1603317,   25.9875603,   3.63636374
  49140,   28.3206615,   25.9875603,   3.63636374
  49141,   27.4809914,   25.9875603,   3.63636374
  49142,   26.6413212,   25.9875603,   3.63636374
  49143,   25.8016529,   25.9875603,   3.63636374
  49144,   24.8347111,   25.9875603,   3.63636374
  49145,   23.8677692,   25.9875603,   3.63636374
  49146,   22.9008255,   25.9875603,   3.63636374
  49147,   21.9338837,   25.9875603,   3.63636374
  49148,   20.9669418,   25.9875603,   3.63636374
  49149,   29.1603317,   25.1913872,   3.63636374
  49150,   28.3206615,   25.1913872,   3.63636374
  49151,   27.4809914,   25.1913872,   3.63636374
  49152,   26.6413212,   25.1913872,   3.63636374
  49153,   25.8016529,   25.1913872,   3.63636374
  49154,   24.8347111,   25.1913872,   3.63636374
  49155,   23.8677692,   25.1913872,   3.63636374
  49156,   22.9008255,   25.1913872,   3.63636374
  49157,   21.9338837,   25.1913872,   3.63636374
  49158,   20.9669418,   25.1913872,   3.63636374
  49159,   29.1504135,   24.4497604,   3.63636374
  49160,    28.300827,   24.4497604,   3.63636374
  49161,   27.4512405,   24.4497604,   3.63636374
  49162,   26.6016541,   24.4497604,   3.63636374
  49163,   25.7520657,   24.4497604,   3.63636374
  49164,   24.7933884,   24.4497604,   3.63636374
  49165,   23.8347111,   24.4497604,   3.63636374
  49166,   22.8760319,   24.4497604,   3.63636374
  49167,   21.9173546,   24.4497604,   3.63636374
  49168,   20.9586773,   24.4497604,   3.63636374
  49169,   29.1404953,   23.7081337,   3.63636374
  49170,   28.2809906,   23.7081337,   3.63636374
  49171,   27.4214878,   23.7081337,   3.63636374
  49172,   26.5619831,   23.7081337,   3.63636374
  49173,   25.7024803,   23.7081337,   3.63636374
  49174,   24.7520657,   23.7081337,   3.63636374
  49175,   23.8016529,   23.7081337,   3.63636374
  49176,   22.8512383,   23.7081337,   3.63636374
  49177,   21.9008255,   23.7081337,   3.63636374
  49178,   20.9504128,   23.7081337,   3.63636374
  49179,    29.130579,    22.966507,   3.63636374
  49180,    28.261158,    22.966507,   3.63636374
  49181,   27.3917351,    22.966507,   3.63636374
  49182,   26.5223141,    22.966507,   3.63636374
  49183,   25.6528931,    22.966507,   3.63636374
  49184,    24.710743,    22.966507,   3.63636374
  49185,   23.7685947,    22.966507,   3.63636374
  49186,   22.8264465,    22.966507,   3.63636374
  49187,   21.8842964,    22.966507,   3.63636374
  49188,   20.9421482,    22.966507,   3.63636374
  49189,   29.1206627,   22.2248802,   3.63636374
  49190,   28.2413216,   22.2248802,   3.63636374
  49191,   27.3619843,   22.2248802,   3.63636374
  49192,    26.482645,   22.2248802,   3.63636374
  49193,   25.6033058,   22.2248802,   3.63636374
  49194,   24.6694202,   22.2248802,   3.63636374
  49195,   23.7355366,   22.2248802,   3.63636374
  49196,   22.8016529,   22.2248802,   3.63636374
  49197,   21.8677692,   22.2248802,   3.63636374
  49198,   20.9338837,   22.2248802,   3.63636374
  49199,   29.1107445,   21.4832535,   3.63636374
  49200,    28.221487,   21.4832535,   3.63636374
  49201,   27.3322315,   21.4832535,   3.63636374
  49202,    26.442976,   21.4832535,   3.63636374
  49203,   25.5537186,   21.4832535,   3.63636374
  49204,   24.6280994,   21.4832535,   3.63636374
  49205,   23.7024784,   21.4832535,   3.63636374
  49206,   22.7768593,   21.4832535,   3.63636374
  49207,   21.8512402,   21.4832535,   3.63636374
  49208,   20.9256191,   21.4832535,   3.63636374
  49209,   29.1008263,   20.7416267,   3.63636374
  49210,   28.2016525,   20.7416267,   3.63636374
  49211,   27.3024807,   20.7416267,   3.63636374
  49212,   26.4033051,   20.7416267,   3.63636374
  49213,   25.5041313,   20.7416267,   3.63636374
  49214,   24.5867767,   20.7416267,   3.63636374
  49215,   23.6694221,   20.7416267,   3.63636374
  49216,   22.7520657,   20.7416267,   3.63636374
  49217,   21.8347111,   20.7416267,   3.63636374
  49218,   20.9173546,   20.7416267,   3.63636374
  49219,   29.1041317,    49.178627,   2.72727275
  49220,   28.2082634,    49.178627,   2.72727275
  49221,    27.312397,    49.178627,   2.72727275
  49222,   26.4165287,    49.178627,   2.72727275
  49223,   25.5206604,    49.178627,   2.72727275
  49224,   24.6005516,    49.178627,   2.72727275
  49225,   23.6804409,    49.178627,   2.72727275
  49226,   22.7603302,    49.178627,   2.72727275
  49227,   21.8402195,    49.178627,   2.72727275
  49228,   20.9201088,    49.178627,   2.72727275
  49229,   29.1173553,   48.3572578,   2.72727275
  49230,   28.2347107,   48.3572578,   2.72727275
  49231,    27.352066,   48.3572578,   2.72727275
  49232,   26.4694214,   48.3572578,   2.72727275
  49233,   25.5867767,   48.3572578,   2.72727275
  49234,   24.6556473,   48.3572578,   2.72727275
  49235,   23.7245178,   48.3572578,   2.72727275
  49236,   22.7933884,   48.3572578,   2.72727275
  49237,   21.8622589,   48.3572578,   2.72727275
  49238,   20.9311295,   48.3572578,   2.72727275
  49239,    29.130579,   47.5358849,   2.72727275
  49240,   28.2611561,   47.5358849,   2.72727275
  49241,   27.3917351,   47.5358849,   2.72727275
  49242,   26.5223141,   47.5358849,   2.72727275
  49243,   25.6528931,   47.5358849,   2.72727275
  49244,   24.7107449,   47.5358849,   2.72727275
  49245,   23.7685947,   47.5358849,   2.72727275
  49246,   22.8264465,   47.5358849,   2.72727275
  49247,   21.8842964,   47.5358849,   2.72727275
  49248,   20.9421482,   47.5358849,   2.72727275
  49249,   29.1438026,   46.7145119,   2.72727275
  49250,   28.2876034,   46.7145119,   2.72727275
  49251,    27.431406,   46.7145119,   2.72727275
  49252,   26.5752068,   46.7145119,   2.72727275
  49253,   25.7190094,   46.7145119,   2.72727275
  49254,   24.7658386,   46.7145119,   2.72727275
  49255,   23.8126717,   46.7145119,   2.72727275
  49256,   22.8595028,   46.7145119,   2.72727275
  49257,   21.9063358,   46.7145119,   2.72727275
  49258,    20.953167,   46.7145119,   2.72727275
  49259,   29.1570244,   45.8931427,   2.72727275
  49260,   28.3140488,   45.8931427,   2.72727275
  49261,   27.4710751,   45.8931427,   2.72727275
  49262,   26.6280994,   45.8931427,   2.72727275
  49263,   25.7851238,   45.8931427,   2.72727275
  49264,   24.8209362,   45.8931427,   2.72727275
  49265,   23.8567486,   45.8931427,   2.72727275
  49266,   22.8925629,   45.8931427,   2.72727275
  49267,   21.9283733,   45.8931427,   2.72727275
  49268,   20.9641876,   45.8931427,   2.72727275
  49269,    29.170248,   45.0717697,   2.72727275
  49270,   28.3404961,   45.0717697,   2.72727275
  49271,   27.5107441,   45.0717697,   2.72727275
  49272,   26.6809902,   45.0717697,   2.72727275
  49273,   25.8512402,   45.0717697,   2.72727275
  49274,   24.8760338,   45.0717697,   2.72727275
  49275,   23.9008274,   45.0717697,   2.72727275
  49276,   22.9256191,   45.0717697,   2.72727275
  49277,   21.9504128,   45.0717697,   2.72727275
  49278,   20.9752064,   45.0717697,   2.72727275
  49279,    29.170248,   44.2746429,   2.72727275
  49280,   28.3404961,   44.2746429,   2.72727275
  49281,   27.5107441,   44.2746429,   2.72727275
  49282,   26.6809902,   44.2746429,   2.72727275
  49283,   25.8512402,   44.2746429,   2.72727275
  49284,   24.8760338,   44.2746429,   2.72727275
  49285,   23.9008274,   44.2746429,   2.72727275
  49286,   22.9256191,   44.2746429,   2.72727275
  49287,   21.9504128,   44.2746429,   2.72727275
  49288,   20.9752064,   44.2746429,   2.72727275
  49289,    29.170248,   43.4775124,   2.72727275
  49290,   28.3404961,   43.4775124,   2.72727275
  49291,   27.5107441,   43.4775124,   2.72727275
  49292,   26.6809902,   43.4775124,   2.72727275
  49293,   25.8512402,   43.4775124,   2.72727275
  49294,   24.8760338,   43.4775124,   2.72727275
  49295,   23.9008274,   43.4775124,   2.72727275
  49296,   22.9256191,   43.4775124,   2.72727275
  49297,   21.9504128,   43.4775124,   2.72727275
  49298,   20.9752064,   43.4775124,   2.72727275
  49299,    29.170248,   42.6803818,   2.72727275
  49300,   28.3404961,   42.6803818,   2.72727275
  49301,   27.5107441,   42.6803818,   2.72727275
  49302,   26.6809902,   42.6803818,   2.72727275
  49303,   25.8512402,   42.6803818,   2.72727275
  49304,   24.8760338,   42.6803818,   2.72727275
  49305,   23.9008274,   42.6803818,   2.72727275
  49306,   22.9256191,   42.6803818,   2.72727275
  49307,   21.9504128,   42.6803818,   2.72727275
  49308,   20.9752064,   42.6803818,   2.72727275
  49309,    29.170248,    41.883255,   2.72727275
  49310,   28.3404961,    41.883255,   2.72727275
  49311,   27.5107441,    41.883255,   2.72727275
  49312,   26.6809902,    41.883255,   2.72727275
  49313,   25.8512402,    41.883255,   2.72727275
  49314,   24.8760338,    41.883255,   2.72727275
  49315,   23.9008274,    41.883255,   2.72727275
  49316,   22.9256191,    41.883255,   2.72727275
  49317,   21.9504128,    41.883255,   2.72727275
  49318,   20.9752064,    41.883255,   2.72727275
  49319,    29.170248,   41.0861244,   2.72727275
  49320,   28.3404961,   41.0861244,   2.72727275
  49321,   27.5107441,   41.0861244,   2.72727275
  49322,   26.6809902,   41.0861244,   2.72727275
  49323,   25.8512402,   41.0861244,   2.72727275
  49324,   24.8760338,   41.0861244,   2.72727275
  49325,   23.9008274,   41.0861244,   2.72727275
  49326,   22.9256191,   41.0861244,   2.72727275
  49327,   21.9504128,   41.0861244,   2.72727275
  49328,   20.9752064,   41.0861244,   2.72727275
  49329,    29.170248,   40.2889938,   2.72727275
  49330,   28.3404961,   40.2889938,   2.72727275
  49331,   27.5107441,   40.2889938,   2.72727275
  49332,   26.6809902,   40.2889938,   2.72727275
  49333,   25.8512402,   40.2889938,   2.72727275
  49334,   24.8760338,   40.2889938,   2.72727275
  49335,   23.9008274,   40.2889938,   2.72727275
  49336,   22.9256191,   40.2889938,   2.72727275
  49337,   21.9504128,   40.2889938,   2.72727275
  49338,   20.9752064,   40.2889938,   2.72727275
  49339,    29.170248,   39.4918671,   2.72727275
  49340,   28.3404961,   39.4918671,   2.72727275
  49341,   27.5107441,   39.4918671,   2.72727275
  49342,   26.6809902,   39.4918671,   2.72727275
  49343,   25.8512402,   39.4918671,   2.72727275
  49344,   24.8760338,   39.4918671,   2.72727275
  49345,   23.9008274,   39.4918671,   2.72727275
  49346,   22.9256191,   39.4918671,   2.72727275
  49347,   21.9504128,   39.4918671,   2.72727275
  49348,   20.9752064,   39.4918671,   2.72727275
  49349,    29.170248,   38.6947365,   2.72727275
  49350,   28.3404961,   38.6947365,   2.72727275
  49351,   27.5107441,   38.6947365,   2.72727275
  49352,   26.6809902,   38.6947365,   2.72727275
  49353,   25.8512402,   38.6947365,   2.72727275
  49354,   24.8760338,   38.6947365,   2.72727275
  49355,   23.9008274,   38.6947365,   2.72727275
  49356,   22.9256191,   38.6947365,   2.72727275
  49357,   21.9504128,   38.6947365,   2.72727275
  49358,   20.9752064,   38.6947365,   2.72727275
  49359,    29.170248,   37.8976059,   2.72727275
  49360,   28.3404961,   37.8976059,   2.72727275
  49361,   27.5107441,   37.8976059,   2.72727275
  49362,   26.6809902,   37.8976059,   2.72727275
  49363,   25.8512402,   37.8976059,   2.72727275
  49364,   24.8760338,   37.8976059,   2.72727275
  49365,   23.9008274,   37.8976059,   2.72727275
  49366,   22.9256191,   37.8976059,   2.72727275
  49367,   21.9504128,   37.8976059,   2.72727275
  49368,   20.9752064,   37.8976059,   2.72727275
  49369,    29.170248,   37.1004791,   2.72727275
  49370,   28.3404961,   37.1004791,   2.72727275
  49371,   27.5107441,   37.1004791,   2.72727275
  49372,   26.6809902,   37.1004791,   2.72727275
  49373,   25.8512402,   37.1004791,   2.72727275
  49374,   24.8760338,   37.1004791,   2.72727275
  49375,   23.9008274,   37.1004791,   2.72727275
  49376,   22.9256191,   37.1004791,   2.72727275
  49377,   21.9504128,   37.1004791,   2.72727275
  49378,   20.9752064,   37.1004791,   2.72727275
  49379,    29.170248,   36.3033485,   2.72727275
  49380,   28.3404961,   36.3033485,   2.72727275
  49381,   27.5107441,   36.3033485,   2.72727275
  49382,   26.6809902,   36.3033485,   2.72727275
  49383,   25.8512402,   36.3033485,   2.72727275
  49384,   24.8760338,   36.3033485,   2.72727275
  49385,   23.9008274,   36.3033485,   2.72727275
  49386,   22.9256191,   36.3033485,   2.72727275
  49387,   21.9504128,   36.3033485,   2.72727275
  49388,   20.9752064,   36.3033485,   2.72727275
  49389,    29.170248,   35.5062218,   2.72727275
  49390,   28.3404961,   35.5062218,   2.72727275
  49391,   27.5107441,   35.5062218,   2.72727275
  49392,   26.6809902,   35.5062218,   2.72727275
  49393,   25.8512402,   35.5062218,   2.72727275
  49394,   24.8760338,   35.5062218,   2.72727275
  49395,   23.9008274,   35.5062218,   2.72727275
  49396,   22.9256191,   35.5062218,   2.72727275
  49397,   21.9504128,   35.5062218,   2.72727275
  49398,   20.9752064,   35.5062218,   2.72727275
  49399,    29.170248,   34.7090912,   2.72727275
  49400,   28.3404961,   34.7090912,   2.72727275
  49401,   27.5107441,   34.7090912,   2.72727275
  49402,   26.6809902,   34.7090912,   2.72727275
  49403,   25.8512402,   34.7090912,   2.72727275
  49404,   24.8760338,   34.7090912,   2.72727275
  49405,   23.9008274,   34.7090912,   2.72727275
  49406,   22.9256191,   34.7090912,   2.72727275
  49407,   21.9504128,   34.7090912,   2.72727275
  49408,   20.9752064,   34.7090912,   2.72727275
  49409,    29.170248,   33.9119606,   2.72727275
  49410,   28.3404961,   33.9119606,   2.72727275
  49411,   27.5107441,   33.9119606,   2.72727275
  49412,   26.6809902,   33.9119606,   2.72727275
  49413,   25.8512402,   33.9119606,   2.72727275
  49414,   24.8760338,   33.9119606,   2.72727275
  49415,   23.9008274,   33.9119606,   2.72727275
  49416,   22.9256191,   33.9119606,   2.72727275
  49417,   21.9504128,   33.9119606,   2.72727275
  49418,   20.9752064,   33.9119606,   2.72727275
  49419,    29.170248,   33.1148338,   2.72727275
  49420,   28.3404961,   33.1148338,   2.72727275
  49421,   27.5107441,   33.1148338,   2.72727275
  49422,   26.6809902,   33.1148338,   2.72727275
  49423,   25.8512402,   33.1148338,   2.72727275
  49424,   24.8760338,   33.1148338,   2.72727275
  49425,   23.9008274,   33.1148338,   2.72727275
  49426,   22.9256191,   33.1148338,   2.72727275
  49427,   21.9504128,   33.1148338,   2.72727275
  49428,   20.9752064,   33.1148338,   2.72727275
  49429,    29.170248,   32.3177032,   2.72727275
  49430,   28.3404961,   32.3177032,   2.72727275
  49431,   27.5107441,   32.3177032,   2.72727275
  49432,   26.6809902,   32.3177032,   2.72727275
  49433,   25.8512402,   32.3177032,   2.72727275
  49434,   24.8760338,   32.3177032,   2.72727275
  49435,   23.9008274,   32.3177032,   2.72727275
  49436,   22.9256191,   32.3177032,   2.72727275
  49437,   21.9504128,   32.3177032,   2.72727275
  49438,   20.9752064,   32.3177032,   2.72727275
  49439,    29.170248,   31.5205746,   2.72727275
  49440,   28.3404961,   31.5205746,   2.72727275
  49441,   27.5107441,   31.5205746,   2.72727275
  49442,   26.6809902,   31.5205746,   2.72727275
  49443,   25.8512402,   31.5205746,   2.72727275
  49444,   24.8760338,   31.5205746,   2.72727275
  49445,   23.9008274,   31.5205746,   2.72727275
  49446,   22.9256191,   31.5205746,   2.72727275
  49447,   21.9504128,   31.5205746,   2.72727275
  49448,   20.9752064,   31.5205746,   2.72727275
  49449,    29.170248,   30.7234459,   2.72727275
  49450,   28.3404961,   30.7234459,   2.72727275
  49451,   27.5107441,   30.7234459,   2.72727275
  49452,   26.6809902,   30.7234459,   2.72727275
  49453,   25.8512402,   30.7234459,   2.72727275
  49454,   24.8760338,   30.7234459,   2.72727275
  49455,   23.9008274,   30.7234459,   2.72727275
  49456,   22.9256191,   30.7234459,   2.72727275
  49457,   21.9504128,   30.7234459,   2.72727275
  49458,   20.9752064,   30.7234459,   2.72727275
  49459,    29.170248,   29.9263153,   2.72727275
  49460,   28.3404961,   29.9263153,   2.72727275
  49461,   27.5107441,   29.9263153,   2.72727275
  49462,   26.6809902,   29.9263153,   2.72727275
  49463,   25.8512402,   29.9263153,   2.72727275
  49464,   24.8760338,   29.9263153,   2.72727275
  49465,   23.9008274,   29.9263153,   2.72727275
  49466,   22.9256191,   29.9263153,   2.72727275
  49467,   21.9504128,   29.9263153,   2.72727275
  49468,   20.9752064,   29.9263153,   2.72727275
  49469,    29.170248,   29.1291866,   2.72727275
  49470,   28.3404961,   29.1291866,   2.72727275
  49471,   27.5107441,   29.1291866,   2.72727275
  49472,   26.6809902,   29.1291866,   2.72727275
  49473,   25.8512402,   29.1291866,   2.72727275
  49474,   24.8760338,   29.1291866,   2.72727275
  49475,   23.9008274,   29.1291866,   2.72727275
  49476,   22.9256191,   29.1291866,   2.72727275
  49477,   21.9504128,   29.1291866,   2.72727275
  49478,   20.9752064,   29.1291866,   2.72727275
  49479,    29.170248,    28.332058,   2.72727275
  49480,   28.3404961,    28.332058,   2.72727275
  49481,   27.5107441,    28.332058,   2.72727275
  49482,   26.6809902,    28.332058,   2.72727275
  49483,   25.8512402,    28.332058,   2.72727275
  49484,   24.8760338,    28.332058,   2.72727275
  49485,   23.9008274,    28.332058,   2.72727275
  49486,   22.9256191,    28.332058,   2.72727275
  49487,   21.9504128,    28.332058,   2.72727275
  49488,   20.9752064,    28.332058,   2.72727275
  49489,    29.170248,   27.5349274,   2.72727275
  49490,   28.3404961,   27.5349274,   2.72727275
  49491,   27.5107441,   27.5349274,   2.72727275
  49492,   26.6809902,   27.5349274,   2.72727275
  49493,   25.8512402,   27.5349274,   2.72727275
  49494,   24.8760338,   27.5349274,   2.72727275
  49495,   23.9008274,   27.5349274,   2.72727275
  49496,   22.9256191,   27.5349274,   2.72727275
  49497,   21.9504128,   27.5349274,   2.72727275
  49498,   20.9752064,   27.5349274,   2.72727275
  49499,    29.170248,   26.7377987,   2.72727275
  49500,   28.3404961,   26.7377987,   2.72727275
  49501,   27.5107441,   26.7377987,   2.72727275
  49502,   26.6809902,   26.7377987,   2.72727275
  49503,   25.8512402,   26.7377987,   2.72727275
  49504,   24.8760338,   26.7377987,   2.72727275
  49505,   23.9008274,   26.7377987,   2.72727275
  49506,   22.9256191,   26.7377987,   2.72727275
  49507,   21.9504128,   26.7377987,   2.72727275
  49508,   20.9752064,   26.7377987,   2.72727275
  49509,    29.170248,     25.94067,   2.72727275
  49510,   28.3404961,     25.94067,   2.72727275
  49511,   27.5107441,     25.94067,   2.72727275
  49512,   26.6809902,     25.94067,   2.72727275
  49513,   25.8512402,     25.94067,   2.72727275
  49514,   24.8760338,     25.94067,   2.72727275
  49515,   23.9008274,     25.94067,   2.72727275
  49516,   22.9256191,     25.94067,   2.72727275
  49517,   21.9504128,     25.94067,   2.72727275
  49518,   20.9752064,     25.94067,   2.72727275
  49519,    29.170248,   25.1435413,   2.72727275
  49520,   28.3404961,   25.1435413,   2.72727275
  49521,   27.5107441,   25.1435413,   2.72727275
  49522,   26.6809902,   25.1435413,   2.72727275
  49523,   25.8512402,   25.1435413,   2.72727275
  49524,   24.8760338,   25.1435413,   2.72727275
  49525,   23.9008274,   25.1435413,   2.72727275
  49526,   22.9256191,   25.1435413,   2.72727275
  49527,   21.9504128,   25.1435413,   2.72727275
  49528,   20.9752064,   25.1435413,   2.72727275
  49529,   29.1589146,   24.4087486,   2.72727275
  49530,   28.3178272,   24.4087486,   2.72727275
  49531,   27.4767418,   24.4087486,   2.72727275
  49532,   26.6356564,   24.4087486,   2.72727275
  49533,    25.794569,   24.4087486,   2.72727275
  49534,   24.8288078,   24.4087486,   2.72727275
  49535,   23.8630466,   24.4087486,   2.72727275
  49536,   22.8972836,   24.4087486,   2.72727275
  49537,   21.9315224,   24.4087486,   2.72727275
  49538,   20.9657612,   24.4087486,   2.72727275
  49539,   29.1475792,   23.6739578,   2.72727275
  49540,   28.2951584,   23.6739578,   2.72727275
  49541,   27.4427395,   23.6739578,   2.72727275
  49542,   26.5903187,   23.6739578,   2.72727275
  49543,   25.7378998,   23.6739578,   2.72727275
  49544,   24.7815819,   23.6739578,   2.72727275
  49545,   23.8252659,   23.6739578,   2.72727275
  49546,    22.868948,   23.6739578,   2.72727275
  49547,    21.912632,   23.6739578,   2.72727275
  49548,    20.956316,   23.6739578,   2.72727275
  49549,   29.1362457,    22.939167,   2.72727275
  49550,   28.2724915,    22.939167,   2.72727275
  49551,   27.4087372,    22.939167,   2.72727275
  49552,   26.5449829,    22.939167,   2.72727275
  49553,   25.6812286,    22.939167,   2.72727275
  49554,   24.7343559,    22.939167,   2.72727275
  49555,   23.7874851,    22.939167,   2.72727275
  49556,   22.8406143,    22.939167,   2.72727275
  49557,   21.8937416,    22.939167,   2.72727275
  49558,   20.9468708,    22.939167,   2.72727275
  49559,   29.1249123,   22.2043743,   2.72727275
  49560,   28.2498226,   22.2043743,   2.72727275
  49561,   27.3747349,   22.2043743,   2.72727275
  49562,   26.4996452,   22.2043743,   2.72727275
  49563,   25.6245575,   22.2043743,   2.72727275
  49564,     24.68713,   22.2043743,   2.72727275
  49565,   23.7497044,   22.2043743,   2.72727275
  49566,   22.8122787,   22.2043743,   2.72727275
  49567,   21.8748531,   22.2043743,   2.72727275
  49568,   20.9374256,   22.2043743,   2.72727275
  49569,   29.1135769,   21.4695835,   2.72727275
  49570,   28.2271538,   21.4695835,   2.72727275
  49571,   27.3407326,   21.4695835,   2.72727275
  49572,   26.4543095,   21.4695835,   2.72727275
  49573,   25.5678864,   21.4695835,   2.72727275
  49574,   24.6399059,   21.4695835,   2.72727275
  49575,   23.7119236,   21.4695835,   2.72727275
  49576,   22.7839432,   21.4695835,   2.72727275
  49577,   21.8559628,   21.4695835,   2.72727275
  49578,   20.9279804,   21.4695835,   2.72727275
  49579,   29.1022434,   20.7347908,   2.72727275
  49580,   28.2044868,   20.7347908,   2.72727275
  49581,   27.3067303,   20.7347908,   2.72727275
  49582,   26.4089718,   20.7347908,   2.72727275
  49583,   25.5112152,   20.7347908,   2.72727275
  49584,     24.59268,   20.7347908,   2.72727275
  49585,   23.6741447,   20.7347908,   2.72727275
  49586,   22.7556076,   20.7347908,   2.72727275
  49587,   21.8370724,   20.7347908,   2.72727275
  49588,   20.9185352,   20.7347908,   2.72727275
  49589,   29.1057854,   49.1746407,   1.81818187
  49590,   28.2115707,   49.1746407,   1.81818187
  49591,   27.3173561,   49.1746407,   1.81818187
  49592,   26.4231396,   49.1746407,   1.81818187
  49593,   25.5289249,   49.1746407,   1.81818187
  49594,   24.6074371,   49.1746407,   1.81818187
  49595,   23.6859512,   49.1746407,   1.81818187
  49596,   22.7644634,   49.1746407,   1.81818187
  49597,   21.8429737,   49.1746407,   1.81818187
  49598,   20.9214878,   49.1746407,   1.81818187
  49599,   29.1206627,   48.3492813,   1.81818187
  49600,   28.2413216,   48.3492813,   1.81818187
  49601,   27.3619843,   48.3492813,   1.81818187
  49602,    26.482645,   48.3492813,   1.81818187
  49603,   25.6033058,   48.3492813,   1.81818187
  49604,   24.6694221,   48.3492813,   1.81818187
  49605,   23.7355366,   48.3492813,   1.81818187
  49606,   22.8016529,   48.3492813,   1.81818187
  49607,   21.8677692,   48.3492813,   1.81818187
  49608,   20.9338837,   48.3492813,   1.81818187
  49609,   29.1355381,    47.523922,   1.81818187
  49610,   28.2710743,    47.523922,   1.81818187
  49611,   27.4066105,    47.523922,   1.81818187
  49612,   26.5421486,    47.523922,   1.81818187
  49613,   25.6776848,    47.523922,   1.81818187
  49614,   24.7314053,    47.523922,   1.81818187
  49615,   23.7851238,    47.523922,   1.81818187
  49616,   22.8388424,    47.523922,   1.81818187
  49617,    21.892561,    47.523922,   1.81818187
  49618,   20.9462814,    47.523922,   1.81818187
  49619,   29.1504135,   46.6985664,   1.81818187
  49620,    28.300827,   46.6985664,   1.81818187
  49621,   27.4512405,   46.6985664,   1.81818187
  49622,   26.6016521,   46.6985664,   1.81818187
  49623,   25.7520657,   46.6985664,   1.81818187
  49624,   24.7933884,   46.6985664,   1.81818187
  49625,   23.8347111,   46.6985664,   1.81818187
  49626,   22.8760319,   46.6985664,   1.81818187
  49627,   21.9173546,   46.6985664,   1.81818187
  49628,   20.9586773,   46.6985664,   1.81818187
  49629,   29.1652889,   45.8732071,   1.81818187
  49630,   28.3305779,   45.8732071,   1.81818187
  49631,   27.4958668,   45.8732071,   1.81818187
  49632,   26.6611557,   45.8732071,   1.81818187
  49633,   25.8264465,   45.8732071,   1.81818187
  49634,   24.8553715,   45.8732071,   1.81818187
  49635,   23.8842983,   45.8732071,   1.81818187
  49636,   22.9132233,   45.8732071,   1.81818187
  49637,   21.9421482,   45.8732071,   1.81818187
  49638,   20.9710732,   45.8732071,   1.81818187
  49639,   29.1801662,   45.0478477,   1.81818187
  49640,   28.3603306,   45.0478477,   1.81818187
  49641,   27.5404968,   45.0478477,   1.81818187
  49642,   26.7206612,   45.0478477,   1.81818187
  49643,   25.9008274,   45.0478477,   1.81818187
  49644,   24.9173546,   45.0478477,   1.81818187
  49645,   23.9338837,   45.0478477,   1.81818187
  49646,   22.9504128,   45.0478477,   1.81818187
  49647,   21.9669418,   45.0478477,   1.81818187
  49648,   20.9834709,   45.0478477,   1.81818187
  49649,   29.1801662,   44.2497597,   1.81818187
  49650,   28.3603306,   44.2497597,   1.81818187
  49651,   27.5404968,   44.2497597,   1.81818187
  49652,   26.7206612,   44.2497597,   1.81818187
  49653,   25.9008274,   44.2497597,   1.81818187
  49654,   24.9173546,   44.2497597,   1.81818187
  49655,   23.9338837,   44.2497597,   1.81818187
  49656,   22.9504128,   44.2497597,   1.81818187
  49657,   21.9669418,   44.2497597,   1.81818187
  49658,   20.9834709,   44.2497597,   1.81818187
  49659,   29.1801662,   43.4516754,   1.81818187
  49660,   28.3603306,   43.4516754,   1.81818187
  49661,   27.5404968,   43.4516754,   1.81818187
  49662,   26.7206612,   43.4516754,   1.81818187
  49663,   25.9008274,   43.4516754,   1.81818187
  49664,   24.9173546,   43.4516754,   1.81818187
  49665,   23.9338837,   43.4516754,   1.81818187
  49666,   22.9504128,   43.4516754,   1.81818187
  49667,   21.9669418,   43.4516754,   1.81818187
  49668,   20.9834709,   43.4516754,   1.81818187
  49669,   29.1801662,   42.6535873,   1.81818187
  49670,   28.3603306,   42.6535873,   1.81818187
  49671,   27.5404968,   42.6535873,   1.81818187
  49672,   26.7206612,   42.6535873,   1.81818187
  49673,   25.9008274,   42.6535873,   1.81818187
  49674,   24.9173546,   42.6535873,   1.81818187
  49675,   23.9338837,   42.6535873,   1.81818187
  49676,   22.9504128,   42.6535873,   1.81818187
  49677,   21.9669418,   42.6535873,   1.81818187
  49678,   20.9834709,   42.6535873,   1.81818187
  49679,   29.1801662,   41.8555031,   1.81818187
  49680,   28.3603306,   41.8555031,   1.81818187
  49681,   27.5404968,   41.8555031,   1.81818187
  49682,   26.7206612,   41.8555031,   1.81818187
  49683,   25.9008274,   41.8555031,   1.81818187
  49684,   24.9173546,   41.8555031,   1.81818187
  49685,   23.9338837,   41.8555031,   1.81818187
  49686,   22.9504128,   41.8555031,   1.81818187
  49687,   21.9669418,   41.8555031,   1.81818187
  49688,   20.9834709,   41.8555031,   1.81818187
  49689,   29.1801662,    41.057415,   1.81818187
  49690,   28.3603306,    41.057415,   1.81818187
  49691,   27.5404968,    41.057415,   1.81818187
  49692,   26.7206612,    41.057415,   1.81818187
  49693,   25.9008274,    41.057415,   1.81818187
  49694,   24.9173546,    41.057415,   1.81818187
  49695,   23.9338837,    41.057415,   1.81818187
  49696,   22.9504128,    41.057415,   1.81818187
  49697,   21.9669418,    41.057415,   1.81818187
  49698,   20.9834709,    41.057415,   1.81818187
  49699,   29.1801662,   40.2593307,   1.81818187
  49700,   28.3603306,   40.2593307,   1.81818187
  49701,   27.5404968,   40.2593307,   1.81818187
  49702,   26.7206612,   40.2593307,   1.81818187
  49703,   25.9008274,   40.2593307,   1.81818187
  49704,   24.9173546,   40.2593307,   1.81818187
  49705,   23.9338837,   40.2593307,   1.81818187
  49706,   22.9504128,   40.2593307,   1.81818187
  49707,   21.9669418,   40.2593307,   1.81818187
  49708,   20.9834709,   40.2593307,   1.81818187
  49709,   29.1801662,   39.4612427,   1.81818187
  49710,   28.3603306,   39.4612427,   1.81818187
  49711,   27.5404968,   39.4612427,   1.81818187
  49712,   26.7206612,   39.4612427,   1.81818187
  49713,   25.9008274,   39.4612427,   1.81818187
  49714,   24.9173546,   39.4612427,   1.81818187
  49715,   23.9338837,   39.4612427,   1.81818187
  49716,   22.9504128,   39.4612427,   1.81818187
  49717,   21.9669418,   39.4612427,   1.81818187
  49718,   20.9834709,   39.4612427,   1.81818187
  49719,   29.1801662,   38.6631584,   1.81818187
  49720,   28.3603306,   38.6631584,   1.81818187
  49721,   27.5404968,   38.6631584,   1.81818187
  49722,   26.7206612,   38.6631584,   1.81818187
  49723,   25.9008274,   38.6631584,   1.81818187
  49724,   24.9173546,   38.6631584,   1.81818187
  49725,   23.9338837,   38.6631584,   1.81818187
  49726,   22.9504128,   38.6631584,   1.81818187
  49727,   21.9669418,   38.6631584,   1.81818187
  49728,   20.9834709,   38.6631584,   1.81818187
  49729,   29.1801662,   37.8650703,   1.81818187
  49730,   28.3603306,   37.8650703,   1.81818187
  49731,   27.5404968,   37.8650703,   1.81818187
  49732,   26.7206612,   37.8650703,   1.81818187
  49733,   25.9008274,   37.8650703,   1.81818187
  49734,   24.9173546,   37.8650703,   1.81818187
  49735,   23.9338837,   37.8650703,   1.81818187
  49736,   22.9504128,   37.8650703,   1.81818187
  49737,   21.9669418,   37.8650703,   1.81818187
  49738,   20.9834709,   37.8650703,   1.81818187
  49739,   29.1801662,   37.0669861,   1.81818187
  49740,   28.3603306,   37.0669861,   1.81818187
  49741,   27.5404968,   37.0669861,   1.81818187
  49742,   26.7206612,   37.0669861,   1.81818187
  49743,   25.9008274,   37.0669861,   1.81818187
  49744,   24.9173546,   37.0669861,   1.81818187
  49745,   23.9338837,   37.0669861,   1.81818187
  49746,   22.9504128,   37.0669861,   1.81818187
  49747,   21.9669418,   37.0669861,   1.81818187
  49748,   20.9834709,   37.0669861,   1.81818187
  49749,   29.1801662,    36.268898,   1.81818187
  49750,   28.3603306,    36.268898,   1.81818187
  49751,   27.5404968,    36.268898,   1.81818187
  49752,   26.7206612,    36.268898,   1.81818187
  49753,   25.9008274,    36.268898,   1.81818187
  49754,   24.9173546,    36.268898,   1.81818187
  49755,   23.9338837,    36.268898,   1.81818187
  49756,   22.9504128,    36.268898,   1.81818187
  49757,   21.9669418,    36.268898,   1.81818187
  49758,   20.9834709,    36.268898,   1.81818187
  49759,   29.1801662,   35.4708138,   1.81818187
  49760,   28.3603306,   35.4708138,   1.81818187
  49761,   27.5404968,   35.4708138,   1.81818187
  49762,   26.7206612,   35.4708138,   1.81818187
  49763,   25.9008274,   35.4708138,   1.81818187
  49764,   24.9173546,   35.4708138,   1.81818187
  49765,   23.9338837,   35.4708138,   1.81818187
  49766,   22.9504128,   35.4708138,   1.81818187
  49767,   21.9669418,   35.4708138,   1.81818187
  49768,   20.9834709,   35.4708138,   1.81818187
  49769,   29.1801662,   34.6727257,   1.81818187
  49770,   28.3603306,   34.6727257,   1.81818187
  49771,   27.5404968,   34.6727257,   1.81818187
  49772,   26.7206612,   34.6727257,   1.81818187
  49773,   25.9008274,   34.6727257,   1.81818187
  49774,   24.9173546,   34.6727257,   1.81818187
  49775,   23.9338837,   34.6727257,   1.81818187
  49776,   22.9504128,   34.6727257,   1.81818187
  49777,   21.9669418,   34.6727257,   1.81818187
  49778,   20.9834709,   34.6727257,   1.81818187
  49779,   29.1801662,   33.8746414,   1.81818187
  49780,   28.3603306,   33.8746414,   1.81818187
  49781,   27.5404968,   33.8746414,   1.81818187
  49782,   26.7206612,   33.8746414,   1.81818187
  49783,   25.9008274,   33.8746414,   1.81818187
  49784,   24.9173546,   33.8746414,   1.81818187
  49785,   23.9338837,   33.8746414,   1.81818187
  49786,   22.9504128,   33.8746414,   1.81818187
  49787,   21.9669418,   33.8746414,   1.81818187
  49788,   20.9834709,   33.8746414,   1.81818187
  49789,   29.1801662,   33.0765533,   1.81818187
  49790,   28.3603306,   33.0765533,   1.81818187
  49791,   27.5404968,   33.0765533,   1.81818187
  49792,   26.7206612,   33.0765533,   1.81818187
  49793,   25.9008274,   33.0765533,   1.81818187
  49794,   24.9173546,   33.0765533,   1.81818187
  49795,   23.9338837,   33.0765533,   1.81818187
  49796,   22.9504128,   33.0765533,   1.81818187
  49797,   21.9669418,   33.0765533,   1.81818187
  49798,   20.9834709,   33.0765533,   1.81818187
  49799,   29.1801662,   32.2784691,   1.81818187
  49800,   28.3603306,   32.2784691,   1.81818187
  49801,   27.5404968,   32.2784691,   1.81818187
  49802,   26.7206612,   32.2784691,   1.81818187
  49803,   25.9008274,   32.2784691,   1.81818187
  49804,   24.9173546,   32.2784691,   1.81818187
  49805,   23.9338837,   32.2784691,   1.81818187
  49806,   22.9504128,   32.2784691,   1.81818187
  49807,   21.9669418,   32.2784691,   1.81818187
  49808,   20.9834709,   32.2784691,   1.81818187
  49809,   29.1801662,   31.4803829,   1.81818187
  49810,   28.3603306,   31.4803829,   1.81818187
  49811,   27.5404968,   31.4803829,   1.81818187
  49812,   26.7206612,   31.4803829,   1.81818187
  49813,   25.9008274,   31.4803829,   1.81818187
  49814,   24.9173546,   31.4803829,   1.81818187
  49815,   23.9338837,   31.4803829,   1.81818187
  49816,   22.9504128,   31.4803829,   1.81818187
  49817,   21.9669418,   31.4803829,   1.81818187
  49818,   20.9834709,   31.4803829,   1.81818187
  49819,   29.1801662,   30.6822968,   1.81818187
  49820,   28.3603306,   30.6822968,   1.81818187
  49821,   27.5404968,   30.6822968,   1.81818187
  49822,   26.7206612,   30.6822968,   1.81818187
  49823,   25.9008274,   30.6822968,   1.81818187
  49824,   24.9173546,   30.6822968,   1.81818187
  49825,   23.9338837,   30.6822968,   1.81818187
  49826,   22.9504128,   30.6822968,   1.81818187
  49827,   21.9669418,   30.6822968,   1.81818187
  49828,   20.9834709,   30.6822968,   1.81818187
  49829,   29.1801662,   29.8842106,   1.81818187
  49830,   28.3603306,   29.8842106,   1.81818187
  49831,   27.5404968,   29.8842106,   1.81818187
  49832,   26.7206612,   29.8842106,   1.81818187
  49833,   25.9008274,   29.8842106,   1.81818187
  49834,   24.9173546,   29.8842106,   1.81818187
  49835,   23.9338837,   29.8842106,   1.81818187
  49836,   22.9504128,   29.8842106,   1.81818187
  49837,   21.9669418,   29.8842106,   1.81818187
  49838,   20.9834709,   29.8842106,   1.81818187
  49839,   29.1801662,   29.0861244,   1.81818187
  49840,   28.3603306,   29.0861244,   1.81818187
  49841,   27.5404968,   29.0861244,   1.81818187
  49842,   26.7206612,   29.0861244,   1.81818187
  49843,   25.9008274,   29.0861244,   1.81818187
  49844,   24.9173546,   29.0861244,   1.81818187
  49845,   23.9338837,   29.0861244,   1.81818187
  49846,   22.9504128,   29.0861244,   1.81818187
  49847,   21.9669418,   29.0861244,   1.81818187
  49848,   20.9834709,   29.0861244,   1.81818187
  49849,   29.1801662,   28.2880383,   1.81818187
  49850,   28.3603306,   28.2880383,   1.81818187
  49851,   27.5404968,   28.2880383,   1.81818187
  49852,   26.7206612,   28.2880383,   1.81818187
  49853,   25.9008274,   28.2880383,   1.81818187
  49854,   24.9173546,   28.2880383,   1.81818187
  49855,   23.9338837,   28.2880383,   1.81818187
  49856,   22.9504128,   28.2880383,   1.81818187
  49857,   21.9669418,   28.2880383,   1.81818187
  49858,   20.9834709,   28.2880383,   1.81818187
  49859,   29.1801662,   27.4899521,   1.81818187
  49860,   28.3603306,   27.4899521,   1.81818187
  49861,   27.5404968,   27.4899521,   1.81818187
  49862,   26.7206612,   27.4899521,   1.81818187
  49863,   25.9008274,   27.4899521,   1.81818187
  49864,   24.9173546,   27.4899521,   1.81818187
  49865,   23.9338837,   27.4899521,   1.81818187
  49866,   22.9504128,   27.4899521,   1.81818187
  49867,   21.9669418,   27.4899521,   1.81818187
  49868,   20.9834709,   27.4899521,   1.81818187
  49869,   29.1801662,   26.6918659,   1.81818187
  49870,   28.3603306,   26.6918659,   1.81818187
  49871,   27.5404968,   26.6918659,   1.81818187
  49872,   26.7206612,   26.6918659,   1.81818187
  49873,   25.9008274,   26.6918659,   1.81818187
  49874,   24.9173546,   26.6918659,   1.81818187
  49875,   23.9338837,   26.6918659,   1.81818187
  49876,   22.9504128,   26.6918659,   1.81818187
  49877,   21.9669418,   26.6918659,   1.81818187
  49878,   20.9834709,   26.6918659,   1.81818187
  49879,   29.1801662,   25.8937798,   1.81818187
  49880,   28.3603306,   25.8937798,   1.81818187
  49881,   27.5404968,   25.8937798,   1.81818187
  49882,   26.7206612,   25.8937798,   1.81818187
  49883,   25.9008274,   25.8937798,   1.81818187
  49884,   24.9173546,   25.8937798,   1.81818187
  49885,   23.9338837,   25.8937798,   1.81818187
  49886,   22.9504128,   25.8937798,   1.81818187
  49887,   21.9669418,   25.8937798,   1.81818187
  49888,   20.9834709,   25.8937798,   1.81818187
  49889,   29.1801662,   25.0956936,   1.81818187
  49890,   28.3603306,   25.0956936,   1.81818187
  49891,   27.5404968,   25.0956936,   1.81818187
  49892,   26.7206612,   25.0956936,   1.81818187
  49893,   25.9008274,   25.0956936,   1.81818187
  49894,   24.9173546,   25.0956936,   1.81818187
  49895,   23.9338837,   25.0956936,   1.81818187
  49896,   22.9504128,   25.0956936,   1.81818187
  49897,   21.9669418,   25.0956936,   1.81818187
  49898,   20.9834709,   25.0956936,   1.81818187
  49899,   29.1674156,   24.3677368,   1.81818187
  49900,   28.3348293,   24.3677368,   1.81818187
  49901,    27.502243,   24.3677368,   1.81818187
  49902,   26.6696587,   24.3677368,   1.81818187
  49903,   25.8370724,   24.3677368,   1.81818187
  49904,   24.8642254,   24.3677368,   1.81818187
  49905,   23.8913803,   24.3677368,   1.81818187
  49906,   22.9185352,   24.3677368,   1.81818187
  49907,   21.9456902,   24.3677368,   1.81818187
  49908,   20.9728451,   24.3677368,   1.81818187
  49909,   29.1546631,    23.639782,   1.81818187
  49910,   28.3093262,    23.639782,   1.81818187
  49911,   27.4639893,    23.639782,   1.81818187
  49912,   26.6186543,    23.639782,   1.81818187
  49913,   25.7733173,    23.639782,   1.81818187
  49914,   24.8110981,    23.639782,   1.81818187
  49915,   23.8488789,    23.639782,   1.81818187
  49916,   22.8866577,    23.639782,   1.81818187
  49917,   21.9244385,    23.639782,   1.81818187
  49918,   20.9622192,    23.639782,   1.81818187
  49919,   29.1419125,   22.9118252,   1.81818187
  49920,   28.2838249,   22.9118252,   1.81818187
  49921,   27.4257374,   22.9118252,   1.81818187
  49922,   26.5676517,   22.9118252,   1.81818187
  49923,   25.7095623,   22.9118252,   1.81818187
  49924,   24.7579689,   22.9118252,   1.81818187
  49925,   23.8063755,   22.9118252,   1.81818187
  49926,   22.8547821,   22.9118252,   1.81818187
  49927,   21.9031868,   22.9118252,   1.81818187
  49928,   20.9515934,   22.9118252,   1.81818187
  49929,   29.1291618,   22.1838684,   1.81818187
  49930,   28.2583237,   22.1838684,   1.81818187
  49931,   27.3874855,   22.1838684,   1.81818187
  49932,   26.5166473,   22.1838684,   1.81818187
  49933,   25.6458092,   22.1838684,   1.81818187
  49934,   24.7048397,   22.1838684,   1.81818187
  49935,   23.7638721,   22.1838684,   1.81818187
  49936,   22.8229046,   22.1838684,   1.81818187
  49937,    21.881937,   22.1838684,   1.81818187
  49938,   20.9409676,   22.1838684,   1.81818187
  49939,   29.1164112,   21.4559116,   1.81818187
  49940,   28.2328224,   21.4559116,   1.81818187
  49941,   27.3492336,   21.4559116,   1.81818187
  49942,   26.4656429,   21.4559116,   1.81818187
  49943,   25.5820541,   21.4559116,   1.81818187
  49944,   24.6517124,   21.4559116,   1.81818187
  49945,   23.7213688,   21.4559116,   1.81818187
  49946,   22.7910271,   21.4559116,   1.81818187
  49947,   21.8606853,   21.4559116,   1.81818187
  49948,   20.9303417,   21.4559116,   1.81818187
  49949,   29.1036606,   20.7279568,   1.81818187
  49950,   28.2073212,   20.7279568,   1.81818187
  49951,   27.3109798,   20.7279568,   1.81818187
  49952,   26.4146404,   20.7279568,   1.81818187
  49953,   25.5182991,   20.7279568,   1.81818187
  49954,   24.5985832,   20.7279568,   1.81818187
  49955,   23.6788673,   20.7279568,   1.81818187
  49956,   22.7591496,   20.7279568,   1.81818187
  49957,   21.8394337,   20.7279568,   1.81818187
  49958,   20.9197159,   20.7279568,   1.81818187
  49959,   29.1074371,   49.1706543,  0.909090936
  49960,   28.2148762,   49.1706543,  0.909090936
  49961,   27.3223133,   49.1706543,  0.909090936
  49962,   26.4297523,   49.1706543,  0.909090936
  49963,   25.5371895,   49.1706543,  0.909090936
  49964,   24.6143246,   49.1706543,  0.909090936
  49965,   23.6914597,   49.1706543,  0.909090936
  49966,   22.7685947,   49.1706543,  0.909090936
  49967,   21.8457298,   49.1706543,  0.909090936
  49968,   20.9228649,   49.1706543,  0.909090936
  49969,   29.1239681,   48.3413086,  0.909090936
  49970,   28.2479343,   48.3413086,  0.909090936
  49971,   27.3719006,   48.3413086,  0.909090936
  49972,   26.4958668,   48.3413086,  0.909090936
  49973,   25.6198349,   48.3413086,  0.909090936
  49974,   24.6831951,   48.3413086,  0.909090936
  49975,   23.7465572,   48.3413086,  0.909090936
  49976,   22.8099174,   48.3413086,  0.909090936
  49977,   21.8732777,   48.3413086,  0.909090936
  49978,   20.9366398,   48.3413086,  0.909090936
  49979,   29.1404953,   47.5119629,  0.909090936
  49980,   28.2809906,   47.5119629,  0.909090936
  49981,   27.4214878,   47.5119629,  0.909090936
  49982,   26.5619831,   47.5119629,  0.909090936
  49983,   25.7024784,   47.5119629,  0.909090936
  49984,   24.7520676,   47.5119629,  0.909090936
  49985,   23.8016529,   47.5119629,  0.909090936
  49986,   22.8512402,   47.5119629,  0.909090936
  49987,   21.9008255,   47.5119629,  0.909090936
  49988,   20.9504128,   47.5119629,  0.909090936
  49989,   29.1570263,   46.6826172,  0.909090936
  49990,   28.3140488,   46.6826172,  0.909090936
  49991,   27.4710751,   46.6826172,  0.909090936
  49992,   26.6280994,   46.6826172,  0.909090936
  49993,   25.7851238,   46.6826172,  0.909090936
  49994,   24.8209362,   46.6826172,  0.909090936
