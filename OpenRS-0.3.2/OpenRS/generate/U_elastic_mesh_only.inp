  23995,  -26.1983471,   23.7081337,  -3.63636374
  23996,  -27.1487617,   23.7081337,  -3.63636374
  23997,  -28.0991745,   23.7081337,  -3.63636374
  23998,  -29.0495872,   23.7081337,  -3.63636374
  23999,  -20.8821049,   23.6739578,  -2.72727275
  24000,  -21.7642097,   23.6739578,  -2.72727275
  24001,  -22.6463146,   23.6739578,  -2.72727275
  24002,  -23.5284195,   23.6739578,  -2.72727275
  24003,  -24.4105244,   23.6739578,  -2.72727275
  24004,  -25.2926292,   23.6739578,  -2.72727275
  24005,  -26.1747341,   23.6739578,  -2.72727275
  24006,   -27.131052,   23.6739578,  -2.72727275
  24007,   -28.087368,   23.6739578,  -2.72727275
  24008,   -29.043684,   23.6739578,  -2.72727275
  24009,  -20.8787308,    23.639782,  -1.81818187
  24010,  -21.7574635,    23.639782,  -1.81818187
  24011,  -22.6361942,    23.639782,  -1.81818187
  24012,  -23.5149269,    23.639782,  -1.81818187
  24013,  -24.3936577,    23.639782,  -1.81818187
  24014,  -25.2723904,    23.639782,  -1.81818187
  24015,  -26.1511211,    23.639782,  -1.81818187
  24016,  -27.1133423,    23.639782,  -1.81818187
  24017,  -28.0755615,    23.639782,  -1.81818187
  24018,  -29.0377808,    23.639782,  -1.81818187
  24019,  -20.8753586,   23.6056042, -0.909090936
  24020,  -21.7507172,   23.6056042, -0.909090936
  24021,  -22.6260757,   23.6056042, -0.909090936
  24022,  -23.5014324,   23.6056042, -0.909090936
  24023,  -24.3767929,   23.6056042, -0.909090936
  24024,  -25.2521496,   23.6056042, -0.909090936
  24025,  -26.1275082,   23.6056042, -0.909090936
  24026,  -27.0956326,   23.6056042, -0.909090936
  24027,   -28.063755,   23.6056042, -0.909090936
  24028,  -29.0318775,   23.6056042, -0.909090936
  24029,  -20.9050426,   24.6958313,    -9.090909
  24030,  -21.8100853,   24.6958313,    -9.090909
  24031,  -22.7151279,   24.6958313,    -9.090909
  24032,  -23.6201725,   24.6958313,    -9.090909
  24033,  -24.5252151,   24.6958313,    -9.090909
  24034,  -25.4302578,   24.6958313,    -9.090909
  24035,  -26.3353004,   24.6958313,    -9.090909
  24036,  -27.2514763,   24.6958313,    -9.090909
  24037,  -28.1676502,   24.6958313,    -9.090909
  24038,  -29.0838261,   24.6958313,    -9.090909
  24039,  -20.9009953,   24.6548195,  -8.18181801
  24040,  -21.8019905,   24.6548195,  -8.18181801
  24041,  -22.7029858,   24.6548195,  -8.18181801
  24042,   -23.603981,   24.6548195,  -8.18181801
  24043,  -24.5049744,   24.6548195,  -8.18181801
  24044,  -25.4059715,   24.6548195,  -8.18181801
  24045,  -26.3069649,   24.6548195,  -8.18181801
  24046,  -27.2302246,   24.6548195,  -8.18181801
  24047,  -28.1534824,   24.6548195,  -8.18181801
  24048,  -29.0767422,   24.6548195,  -8.18181801
  24049,   -20.896946,   24.6138077,  -7.27272749
  24050,  -21.7938938,   24.6138077,  -7.27272749
  24051,  -22.6908417,   24.6138077,  -7.27272749
  24052,  -23.5877895,   24.6138077,  -7.27272749
  24053,  -24.4847355,   24.6138077,  -7.27272749
  24054,  -25.3816833,   24.6138077,  -7.27272749
  24055,  -26.2786312,   24.6138077,  -7.27272749
  24056,  -27.2089729,   24.6138077,  -7.27272749
  24057,  -28.1393147,   24.6138077,  -7.27272749
  24058,  -29.0696583,   24.6138077,  -7.27272749
  24059,  -20.8928986,   24.5727959,  -6.36363649
  24060,   -21.785799,   24.5727959,  -6.36363649
  24061,  -22.6786976,   24.5727959,  -6.36363649
  24062,  -23.5715981,   24.5727959,  -6.36363649
  24063,  -24.4644966,   24.5727959,  -6.36363649
  24064,  -25.3573952,   24.5727959,  -6.36363649
  24065,  -26.2502956,   24.5727959,  -6.36363649
  24066,  -27.1877213,   24.5727959,  -6.36363649
  24067,  -28.1251469,   24.5727959,  -6.36363649
  24068,  -29.0625744,   24.5727959,  -6.36363649
  24069,  -20.8888512,   24.5317841,   -5.4545455
  24070,  -21.7777023,   24.5317841,   -5.4545455
  24071,  -22.6665535,   24.5317841,   -5.4545455
  24072,  -23.5554066,   24.5317841,   -5.4545455
  24073,  -24.4442577,   24.5317841,   -5.4545455
  24074,  -25.3331089,   24.5317841,   -5.4545455
  24075,  -26.2219601,   24.5317841,   -5.4545455
  24076,  -27.1664696,   24.5317841,   -5.4545455
  24077,  -28.1109791,   24.5317841,   -5.4545455
  24078,  -29.0554905,   24.5317841,   -5.4545455
  24079,  -20.8848038,   24.4907722,   -4.5454545
  24080,  -21.7696075,   24.4907722,   -4.5454545
  24081,  -22.6544113,   24.4907722,   -4.5454545
  24082,  -23.5392132,   24.4907722,   -4.5454545
  24083,   -24.424017,   24.4907722,   -4.5454545
  24084,  -25.3088207,   24.4907722,   -4.5454545
  24085,  -26.1936245,   24.4907722,   -4.5454545
  24086,  -27.1452198,   24.4907722,   -4.5454545
  24087,  -28.0968132,   24.4907722,   -4.5454545
  24088,  -29.0484066,   24.4907722,   -4.5454545
  24089,  -20.8807564,   24.4497604,  -3.63636374
  24090,  -21.7615108,   24.4497604,  -3.63636374
  24091,  -22.6422672,   24.4497604,  -3.63636374
  24092,  -23.5230217,   24.4497604,  -3.63636374
  24093,  -24.4037781,   24.4497604,  -3.63636374
  24094,  -25.2845345,   24.4497604,  -3.63636374
  24095,  -26.1652889,   24.4497604,  -3.63636374
  24096,  -27.1239681,   24.4497604,  -3.63636374
  24097,  -28.0826454,   24.4497604,  -3.63636374
  24098,  -29.0413227,   24.4497604,  -3.63636374
  24099,   -20.876709,   24.4087486,  -2.72727275
  24100,  -21.7534161,   24.4087486,  -2.72727275
  24101,  -22.6301231,   24.4087486,  -2.72727275
  24102,  -23.5068302,   24.4087486,  -2.72727275
  24103,  -24.3835392,   24.4087486,  -2.72727275
  24104,  -25.2602463,   24.4087486,  -2.72727275
  24105,  -26.1369534,   24.4087486,  -2.72727275
  24106,  -27.1027164,   24.4087486,  -2.72727275
  24107,  -28.0684776,   24.4087486,  -2.72727275
  24108,  -29.0342388,   24.4087486,  -2.72727275
  24109,  -20.8726597,   24.3677368,  -1.81818187
  24110,  -21.7453194,   24.3677368,  -1.81818187
  24111,   -22.617979,   24.3677368,  -1.81818187
  24112,  -23.4906387,   24.3677368,  -1.81818187
  24113,  -24.3633003,   24.3677368,  -1.81818187
  24114,  -25.2359581,   24.3677368,  -1.81818187
  24115,  -26.1086197,   24.3677368,  -1.81818187
  24116,  -27.0814648,   24.3677368,  -1.81818187
  24117,  -28.0543098,   24.3677368,  -1.81818187
  24118,  -29.0271549,   24.3677368,  -1.81818187
  24119,  -20.8686123,    24.326725, -0.909090936
  24120,  -21.7372246,    24.326725, -0.909090936
  24121,  -22.6058369,    24.326725, -0.909090936
  24122,  -23.4744473,    24.326725, -0.909090936
  24123,  -24.3430595,    24.326725, -0.909090936
  24124,  -25.2116718,    24.326725, -0.909090936
  24125,  -26.0802841,    24.326725, -0.909090936
  24126,  -27.0602131,    24.326725, -0.909090936
  24127,  -28.0401421,    24.326725, -0.909090936
  24128,   -29.020071,    24.326725, -0.909090936
  24129,  -20.9043674,   25.4784698,    -9.090909
  24130,  -21.8087368,   25.4784698,    -9.090909
  24131,  -22.7131042,   25.4784698,    -9.090909
  24132,  -23.6174736,   25.4784698,    -9.090909
  24133,   -24.521841,   25.4784698,    -9.090909
  24134,  -25.4262104,   25.4784698,    -9.090909
  24135,  -26.3305779,   25.4784698,    -9.090909
  24136,  -27.2479343,   25.4784698,    -9.090909
  24137,  -28.1652889,   25.4784698,    -9.090909
  24138,  -29.0826454,   25.4784698,    -9.090909
  24139,  -20.8996449,   25.4306221,  -8.18181801
  24140,  -21.7992916,   25.4306221,  -8.18181801
  24141,  -22.6989365,   25.4306221,  -8.18181801
  24142,  -23.5985832,   25.4306221,  -8.18181801
  24143,  -24.4982281,   25.4306221,  -8.18181801
  24144,  -25.3978748,   25.4306221,  -8.18181801
  24145,  -26.2975197,   25.4306221,  -8.18181801
  24146,  -27.2231407,   25.4306221,  -8.18181801
  24147,  -28.1487598,   25.4306221,  -8.18181801
  24148,  -29.0743809,   25.4306221,  -8.18181801
  24149,  -20.8949223,   25.3827744,  -7.27272749
  24150,  -21.7898464,   25.3827744,  -7.27272749
  24151,  -22.6847687,   25.3827744,  -7.27272749
  24152,  -23.5796928,   25.3827744,  -7.27272749
  24153,   -24.474617,   25.3827744,  -7.27272749
  24154,  -25.3695393,   25.3827744,  -7.27272749
  24155,  -26.2644634,   25.3827744,  -7.27272749
  24156,  -27.1983471,   25.3827744,  -7.27272749
  24157,  -28.1322308,   25.3827744,  -7.27272749
  24158,  -29.0661163,   25.3827744,  -7.27272749
  24159,  -20.8901997,   25.3349285,  -6.36363649
  24160,  -21.7804012,   25.3349285,  -6.36363649
  24161,  -22.6706009,   25.3349285,  -6.36363649
  24162,  -23.5608025,   25.3349285,  -6.36363649
  24163,   -24.451004,   25.3349285,  -6.36363649
  24164,  -25.3412037,   25.3349285,  -6.36363649
  24165,  -26.2314053,   25.3349285,  -6.36363649
  24166,  -27.1735535,   25.3349285,  -6.36363649
  24167,  -28.1157017,   25.3349285,  -6.36363649
  24168,  -29.0578518,   25.3349285,  -6.36363649
  24169,  -20.8854771,   25.2870808,   -5.4545455
  24170,   -21.770956,   25.2870808,   -5.4545455
  24171,  -22.6564331,   25.2870808,   -5.4545455
  24172,  -23.5419121,   25.2870808,   -5.4545455
  24173,  -24.4273911,   25.2870808,   -5.4545455
  24174,  -25.3128681,   25.2870808,   -5.4545455
  24175,  -26.1983471,   25.2870808,   -5.4545455
  24176,  -27.1487598,   25.2870808,   -5.4545455
  24177,  -28.0991726,   25.2870808,   -5.4545455
  24178,  -29.0495872,   25.2870808,   -5.4545455
  24179,  -20.8807564,   25.2392349,   -4.5454545
  24180,  -21.7615108,   25.2392349,   -4.5454545
  24181,  -22.6422672,   25.2392349,   -4.5454545
  24182,  -23.5230236,   25.2392349,   -4.5454545
  24183,  -24.4037781,   25.2392349,   -4.5454545
  24184,  -25.2845345,   25.2392349,   -4.5454545
  24185,  -26.1652889,   25.2392349,   -4.5454545
  24186,  -27.1239681,   25.2392349,   -4.5454545
  24187,  -28.0826454,   25.2392349,   -4.5454545
  24188,  -29.0413227,   25.2392349,   -4.5454545
  24189,  -20.8760338,   25.1913872,  -3.63636374
  24190,  -21.7520657,   25.1913872,  -3.63636374
  24191,  -22.6280994,   25.1913872,  -3.63636374
  24192,  -23.5041332,   25.1913872,  -3.63636374
  24193,  -24.3801651,   25.1913872,  -3.63636374
  24194,  -25.2561989,   25.1913872,  -3.63636374
  24195,  -26.1322308,   25.1913872,  -3.63636374
  24196,  -27.0991745,   25.1913872,  -3.63636374
  24197,  -28.0661163,   25.1913872,  -3.63636374
  24198,  -29.0330582,   25.1913872,  -3.63636374
  24199,  -20.8713112,   25.1435413,  -2.72727275
  24200,  -21.7426205,   25.1435413,  -2.72727275
  24201,  -22.6139317,   25.1435413,  -2.72727275
  24202,  -23.4852428,   25.1435413,  -2.72727275
  24203,  -24.3565521,   25.1435413,  -2.72727275
  24204,  -25.2278633,   25.1435413,  -2.72727275
  24205,  -26.0991726,   25.1435413,  -2.72727275
  24206,  -27.0743809,   25.1435413,  -2.72727275
  24207,  -28.0495872,   25.1435413,  -2.72727275
  24208,  -29.0247936,   25.1435413,  -2.72727275
  24209,  -20.8665886,   25.0956936,  -1.81818187
  24210,  -21.7331753,   25.0956936,  -1.81818187
  24211,  -22.5997639,   25.0956936,  -1.81818187
  24212,  -23.4663525,   25.0956936,  -1.81818187
  24213,  -24.3329411,   25.0956936,  -1.81818187
  24214,  -25.1995277,   25.0956936,  -1.81818187
  24215,  -26.0661163,   25.0956936,  -1.81818187
  24216,  -27.0495872,   25.0956936,  -1.81818187
  24217,  -28.0330582,   25.0956936,  -1.81818187
  24218,  -29.0165291,   25.0956936,  -1.81818187
  24219,   -20.861866,   25.0478477, -0.909090936
  24220,  -21.7237301,   25.0478477, -0.909090936
  24221,  -22.5855961,   25.0478477, -0.909090936
  24222,  -23.4474621,   25.0478477, -0.909090936
  24223,  -24.3093281,   25.0478477, -0.909090936
  24224,  -25.1711922,   25.0478477, -0.909090936
  24225,  -26.0330582,   25.0478477, -0.909090936
  24226,  -27.0247936,   25.0478477, -0.909090936
  24227,  -28.0165291,   25.0478477, -0.909090936
  24228,  -29.0082645,   25.0478477, -0.909090936
  24229,  -20.9043674,   26.2688999,    -9.090909
  24230,  -21.8087368,   26.2688999,    -9.090909
  24231,  -22.7131042,   26.2688999,    -9.090909
  24232,  -23.6174736,   26.2688999,    -9.090909
  24233,   -24.521841,   26.2688999,    -9.090909
  24234,  -25.4262104,   26.2688999,    -9.090909
  24235,  -26.3305779,   26.2688999,    -9.090909
  24236,  -27.2479343,   26.2688999,    -9.090909
  24237,  -28.1652889,   26.2688999,    -9.090909
  24238,  -29.0826454,   26.2688999,    -9.090909
  24239,  -20.8996449,   26.2220097,  -8.18181801
  24240,  -21.7992916,   26.2220097,  -8.18181801
  24241,  -22.6989365,   26.2220097,  -8.18181801
  24242,  -23.5985832,   26.2220097,  -8.18181801
  24243,  -24.4982281,   26.2220097,  -8.18181801
  24244,  -25.3978748,   26.2220097,  -8.18181801
  24245,  -26.2975197,   26.2220097,  -8.18181801
  24246,  -27.2231407,   26.2220097,  -8.18181801
  24247,  -28.1487598,   26.2220097,  -8.18181801
  24248,  -29.0743809,   26.2220097,  -8.18181801
  24249,  -20.8949223,   26.1751194,  -7.27272749
  24250,  -21.7898464,   26.1751194,  -7.27272749
  24251,  -22.6847687,   26.1751194,  -7.27272749
  24252,  -23.5796928,   26.1751194,  -7.27272749
  24253,   -24.474617,   26.1751194,  -7.27272749
  24254,  -25.3695393,   26.1751194,  -7.27272749
  24255,  -26.2644634,   26.1751194,  -7.27272749
  24256,  -27.1983471,   26.1751194,  -7.27272749
  24257,  -28.1322308,   26.1751194,  -7.27272749
  24258,  -29.0661163,   26.1751194,  -7.27272749
  24259,  -20.8901997,   26.1282291,  -6.36363649
  24260,  -21.7804012,   26.1282291,  -6.36363649
  24261,  -22.6706009,   26.1282291,  -6.36363649
  24262,  -23.5608025,   26.1282291,  -6.36363649
  24263,   -24.451004,   26.1282291,  -6.36363649
  24264,  -25.3412037,   26.1282291,  -6.36363649
  24265,  -26.2314053,   26.1282291,  -6.36363649
  24266,  -27.1735535,   26.1282291,  -6.36363649
  24267,  -28.1157017,   26.1282291,  -6.36363649
  24268,  -29.0578518,   26.1282291,  -6.36363649
  24269,  -20.8854771,   26.0813389,   -5.4545455
  24270,   -21.770956,   26.0813389,   -5.4545455
  24271,  -22.6564331,   26.0813389,   -5.4545455
  24272,  -23.5419121,   26.0813389,   -5.4545455
  24273,  -24.4273911,   26.0813389,   -5.4545455
  24274,  -25.3128681,   26.0813389,   -5.4545455
  24275,  -26.1983471,   26.0813389,   -5.4545455
  24276,  -27.1487598,   26.0813389,   -5.4545455
  24277,  -28.0991726,   26.0813389,   -5.4545455
  24278,  -29.0495872,   26.0813389,   -5.4545455
  24279,  -20.8807564,   26.0344505,   -4.5454545
  24280,  -21.7615108,   26.0344505,   -4.5454545
  24281,  -22.6422672,   26.0344505,   -4.5454545
  24282,  -23.5230236,   26.0344505,   -4.5454545
  24283,  -24.4037781,   26.0344505,   -4.5454545
  24284,  -25.2845345,   26.0344505,   -4.5454545
  24285,  -26.1652889,   26.0344505,   -4.5454545
  24286,  -27.1239681,   26.0344505,   -4.5454545
  24287,  -28.0826454,   26.0344505,   -4.5454545
  24288,  -29.0413227,   26.0344505,   -4.5454545
  24289,  -20.8760338,   25.9875603,  -3.63636374
  24290,  -21.7520657,   25.9875603,  -3.63636374
  24291,  -22.6280994,   25.9875603,  -3.63636374
  24292,  -23.5041332,   25.9875603,  -3.63636374
  24293,  -24.3801651,   25.9875603,  -3.63636374
  24294,  -25.2561989,   25.9875603,  -3.63636374
  24295,  -26.1322308,   25.9875603,  -3.63636374
  24296,  -27.0991745,   25.9875603,  -3.63636374
  24297,  -28.0661163,   25.9875603,  -3.63636374
  24298,  -29.0330582,   25.9875603,  -3.63636374
  24299,  -20.8713112,     25.94067,  -2.72727275
  24300,  -21.7426205,     25.94067,  -2.72727275
  24301,  -22.6139317,     25.94067,  -2.72727275
  24302,  -23.4852428,     25.94067,  -2.72727275
  24303,  -24.3565521,     25.94067,  -2.72727275
  24304,  -25.2278633,     25.94067,  -2.72727275
  24305,  -26.0991726,     25.94067,  -2.72727275
  24306,  -27.0743809,     25.94067,  -2.72727275
  24307,  -28.0495872,     25.94067,  -2.72727275
  24308,  -29.0247936,     25.94067,  -2.72727275
  24309,  -20.8665886,   25.8937798,  -1.81818187
  24310,  -21.7331753,   25.8937798,  -1.81818187
  24311,  -22.5997639,   25.8937798,  -1.81818187
  24312,  -23.4663525,   25.8937798,  -1.81818187
  24313,  -24.3329411,   25.8937798,  -1.81818187
  24314,  -25.1995277,   25.8937798,  -1.81818187
  24315,  -26.0661163,   25.8937798,  -1.81818187
  24316,  -27.0495872,   25.8937798,  -1.81818187
  24317,  -28.0330582,   25.8937798,  -1.81818187
  24318,  -29.0165291,   25.8937798,  -1.81818187
  24319,   -20.861866,   25.8468895, -0.909090936
  24320,  -21.7237301,   25.8468895, -0.909090936
  24321,  -22.5855961,   25.8468895, -0.909090936
  24322,  -23.4474621,   25.8468895, -0.909090936
  24323,  -24.3093281,   25.8468895, -0.909090936
  24324,  -25.1711922,   25.8468895, -0.909090936
  24325,  -26.0330582,   25.8468895, -0.909090936
  24326,  -27.0247936,   25.8468895, -0.909090936
  24327,  -28.0165291,   25.8468895, -0.909090936
  24328,  -29.0082645,   25.8468895, -0.909090936
  24329,  -20.9043674,     27.05933,    -9.090909
  24330,  -21.8087368,     27.05933,    -9.090909
  24331,  -22.7131042,     27.05933,    -9.090909
  24332,  -23.6174736,     27.05933,    -9.090909
  24333,   -24.521841,     27.05933,    -9.090909
  24334,  -25.4262104,     27.05933,    -9.090909
  24335,  -26.3305779,     27.05933,    -9.090909
  24336,  -27.2479343,     27.05933,    -9.090909
  24337,  -28.1652889,     27.05933,    -9.090909
  24338,  -29.0826454,     27.05933,    -9.090909
  24339,  -20.8996449,   27.0133972,  -8.18181801
  24340,  -21.7992916,   27.0133972,  -8.18181801
  24341,  -22.6989365,   27.0133972,  -8.18181801
  24342,  -23.5985832,   27.0133972,  -8.18181801
  24343,  -24.4982281,   27.0133972,  -8.18181801
  24344,  -25.3978748,   27.0133972,  -8.18181801
  24345,  -26.2975197,   27.0133972,  -8.18181801
  24346,  -27.2231407,   27.0133972,  -8.18181801
  24347,  -28.1487598,   27.0133972,  -8.18181801
  24348,  -29.0743809,   27.0133972,  -8.18181801
  24349,  -20.8949223,   26.9674644,  -7.27272749
  24350,  -21.7898464,   26.9674644,  -7.27272749
  24351,  -22.6847687,   26.9674644,  -7.27272749
  24352,  -23.5796928,   26.9674644,  -7.27272749
  24353,   -24.474617,   26.9674644,  -7.27272749
  24354,  -25.3695393,   26.9674644,  -7.27272749
  24355,  -26.2644634,   26.9674644,  -7.27272749
  24356,  -27.1983471,   26.9674644,  -7.27272749
  24357,  -28.1322308,   26.9674644,  -7.27272749
  24358,  -29.0661163,   26.9674644,  -7.27272749
  24359,  -20.8901997,   26.9215317,  -6.36363649
  24360,  -21.7804012,   26.9215317,  -6.36363649
  24361,  -22.6706009,   26.9215317,  -6.36363649
  24362,  -23.5608025,   26.9215317,  -6.36363649
  24363,   -24.451004,   26.9215317,  -6.36363649
  24364,  -25.3412037,   26.9215317,  -6.36363649
  24365,  -26.2314053,   26.9215317,  -6.36363649
  24366,  -27.1735535,   26.9215317,  -6.36363649
  24367,  -28.1157017,   26.9215317,  -6.36363649
  24368,  -29.0578518,   26.9215317,  -6.36363649
  24369,  -20.8854771,   26.8755989,   -5.4545455
  24370,   -21.770956,   26.8755989,   -5.4545455
  24371,  -22.6564331,   26.8755989,   -5.4545455
  24372,  -23.5419121,   26.8755989,   -5.4545455
  24373,  -24.4273911,   26.8755989,   -5.4545455
  24374,  -25.3128681,   26.8755989,   -5.4545455
  24375,  -26.1983471,   26.8755989,   -5.4545455
  24376,  -27.1487598,   26.8755989,   -5.4545455
  24377,  -28.0991726,   26.8755989,   -5.4545455
  24378,  -29.0495872,   26.8755989,   -5.4545455
  24379,  -20.8807564,   26.8296642,   -4.5454545
  24380,  -21.7615108,   26.8296642,   -4.5454545
  24381,  -22.6422672,   26.8296642,   -4.5454545
  24382,  -23.5230236,   26.8296642,   -4.5454545
  24383,  -24.4037781,   26.8296642,   -4.5454545
  24384,  -25.2845345,   26.8296642,   -4.5454545
  24385,  -26.1652889,   26.8296642,   -4.5454545
  24386,  -27.1239681,   26.8296642,   -4.5454545
  24387,  -28.0826454,   26.8296642,   -4.5454545
  24388,  -29.0413227,   26.8296642,   -4.5454545
  24389,  -20.8760338,   26.7837315,  -3.63636374
  24390,  -21.7520657,   26.7837315,  -3.63636374
  24391,  -22.6280994,   26.7837315,  -3.63636374
  24392,  -23.5041332,   26.7837315,  -3.63636374
  24393,  -24.3801651,   26.7837315,  -3.63636374
  24394,  -25.2561989,   26.7837315,  -3.63636374
  24395,  -26.1322308,   26.7837315,  -3.63636374
  24396,  -27.0991745,   26.7837315,  -3.63636374
  24397,  -28.0661163,   26.7837315,  -3.63636374
  24398,  -29.0330582,   26.7837315,  -3.63636374
  24399,  -20.8713112,   26.7377987,  -2.72727275
  24400,  -21.7426205,   26.7377987,  -2.72727275
  24401,  -22.6139317,   26.7377987,  -2.72727275
  24402,  -23.4852428,   26.7377987,  -2.72727275
  24403,  -24.3565521,   26.7377987,  -2.72727275
  24404,  -25.2278633,   26.7377987,  -2.72727275
  24405,  -26.0991726,   26.7377987,  -2.72727275
  24406,  -27.0743809,   26.7377987,  -2.72727275
  24407,  -28.0495872,   26.7377987,  -2.72727275
  24408,  -29.0247936,   26.7377987,  -2.72727275
  24409,  -20.8665886,   26.6918659,  -1.81818187
  24410,  -21.7331753,   26.6918659,  -1.81818187
  24411,  -22.5997639,   26.6918659,  -1.81818187
  24412,  -23.4663525,   26.6918659,  -1.81818187
  24413,  -24.3329411,   26.6918659,  -1.81818187
  24414,  -25.1995277,   26.6918659,  -1.81818187
  24415,  -26.0661163,   26.6918659,  -1.81818187
  24416,  -27.0495872,   26.6918659,  -1.81818187
  24417,  -28.0330582,   26.6918659,  -1.81818187
  24418,  -29.0165291,   26.6918659,  -1.81818187
  24419,   -20.861866,   26.6459332, -0.909090936
  24420,  -21.7237301,   26.6459332, -0.909090936
  24421,  -22.5855961,   26.6459332, -0.909090936
  24422,  -23.4474621,   26.6459332, -0.909090936
  24423,  -24.3093281,   26.6459332, -0.909090936
  24424,  -25.1711922,   26.6459332, -0.909090936
  24425,  -26.0330582,   26.6459332, -0.909090936
  24426,  -27.0247936,   26.6459332, -0.909090936
  24427,  -28.0165291,   26.6459332, -0.909090936
  24428,  -29.0082645,   26.6459332, -0.909090936
  24429,  -20.9043674,   27.8497601,    -9.090909
  24430,  -21.8087368,   27.8497601,    -9.090909
  24431,  -22.7131042,   27.8497601,    -9.090909
  24432,  -23.6174736,   27.8497601,    -9.090909
  24433,   -24.521841,   27.8497601,    -9.090909
  24434,  -25.4262104,   27.8497601,    -9.090909
  24435,  -26.3305779,   27.8497601,    -9.090909
  24436,  -27.2479343,   27.8497601,    -9.090909
  24437,  -28.1652889,   27.8497601,    -9.090909
  24438,  -29.0826454,   27.8497601,    -9.090909
  24439,  -20.8996449,   27.8047848,  -8.18181801
  24440,  -21.7992916,   27.8047848,  -8.18181801
  24441,  -22.6989365,   27.8047848,  -8.18181801
  24442,  -23.5985832,   27.8047848,  -8.18181801
  24443,  -24.4982281,   27.8047848,  -8.18181801
  24444,  -25.3978748,   27.8047848,  -8.18181801
  24445,  -26.2975197,   27.8047848,  -8.18181801
  24446,  -27.2231407,   27.8047848,  -8.18181801
  24447,  -28.1487598,   27.8047848,  -8.18181801
  24448,  -29.0743809,   27.8047848,  -8.18181801
  24449,  -20.8949223,   27.7598095,  -7.27272749
  24450,  -21.7898464,   27.7598095,  -7.27272749
  24451,  -22.6847687,   27.7598095,  -7.27272749
  24452,  -23.5796928,   27.7598095,  -7.27272749
  24453,   -24.474617,   27.7598095,  -7.27272749
  24454,  -25.3695393,   27.7598095,  -7.27272749
  24455,  -26.2644634,   27.7598095,  -7.27272749
  24456,  -27.1983471,   27.7598095,  -7.27272749
  24457,  -28.1322308,   27.7598095,  -7.27272749
  24458,  -29.0661163,   27.7598095,  -7.27272749
  24459,  -20.8901997,   27.7148323,  -6.36363649
  24460,  -21.7804012,   27.7148323,  -6.36363649
  24461,  -22.6706009,   27.7148323,  -6.36363649
  24462,  -23.5608025,   27.7148323,  -6.36363649
  24463,   -24.451004,   27.7148323,  -6.36363649
  24464,  -25.3412037,   27.7148323,  -6.36363649
  24465,  -26.2314053,   27.7148323,  -6.36363649
  24466,  -27.1735535,   27.7148323,  -6.36363649
  24467,  -28.1157017,   27.7148323,  -6.36363649
  24468,  -29.0578518,   27.7148323,  -6.36363649
  24469,  -20.8854771,    27.669857,   -5.4545455
  24470,   -21.770956,    27.669857,   -5.4545455
  24471,  -22.6564331,    27.669857,   -5.4545455
  24472,  -23.5419121,    27.669857,   -5.4545455
  24473,  -24.4273911,    27.669857,   -5.4545455
  24474,  -25.3128681,    27.669857,   -5.4545455
  24475,  -26.1983471,    27.669857,   -5.4545455
  24476,  -27.1487598,    27.669857,   -5.4545455
  24477,  -28.0991726,    27.669857,   -5.4545455
  24478,  -29.0495872,    27.669857,   -5.4545455
  24479,  -20.8807564,   27.6248798,   -4.5454545
  24480,  -21.7615108,   27.6248798,   -4.5454545
  24481,  -22.6422672,   27.6248798,   -4.5454545
  24482,  -23.5230236,   27.6248798,   -4.5454545
  24483,  -24.4037781,   27.6248798,   -4.5454545
  24484,  -25.2845345,   27.6248798,   -4.5454545
  24485,  -26.1652889,   27.6248798,   -4.5454545
  24486,  -27.1239681,   27.6248798,   -4.5454545
  24487,  -28.0826454,   27.6248798,   -4.5454545
  24488,  -29.0413227,   27.6248798,   -4.5454545
  24489,  -20.8760338,   27.5799046,  -3.63636374
  24490,  -21.7520657,   27.5799046,  -3.63636374
  24491,  -22.6280994,   27.5799046,  -3.63636374
  24492,  -23.5041332,   27.5799046,  -3.63636374
  24493,  -24.3801651,   27.5799046,  -3.63636374
  24494,  -25.2561989,   27.5799046,  -3.63636374
  24495,  -26.1322308,   27.5799046,  -3.63636374
  24496,  -27.0991745,   27.5799046,  -3.63636374
  24497,  -28.0661163,   27.5799046,  -3.63636374
  24498,  -29.0330582,   27.5799046,  -3.63636374
  24499,  -20.8713112,   27.5349274,  -2.72727275
  24500,  -21.7426205,   27.5349274,  -2.72727275
  24501,  -22.6139317,   27.5349274,  -2.72727275
  24502,  -23.4852428,   27.5349274,  -2.72727275
  24503,  -24.3565521,   27.5349274,  -2.72727275
  24504,  -25.2278633,   27.5349274,  -2.72727275
  24505,  -26.0991726,   27.5349274,  -2.72727275
  24506,  -27.0743809,   27.5349274,  -2.72727275
  24507,  -28.0495872,   27.5349274,  -2.72727275
  24508,  -29.0247936,   27.5349274,  -2.72727275
  24509,  -20.8665886,   27.4899521,  -1.81818187
  24510,  -21.7331753,   27.4899521,  -1.81818187
  24511,  -22.5997639,   27.4899521,  -1.81818187
  24512,  -23.4663525,   27.4899521,  -1.81818187
  24513,  -24.3329411,   27.4899521,  -1.81818187
  24514,  -25.1995277,   27.4899521,  -1.81818187
  24515,  -26.0661163,   27.4899521,  -1.81818187
  24516,  -27.0495872,   27.4899521,  -1.81818187
  24517,  -28.0330582,   27.4899521,  -1.81818187
  24518,  -29.0165291,   27.4899521,  -1.81818187
  24519,   -20.861866,   27.4449768, -0.909090936
  24520,  -21.7237301,   27.4449768, -0.909090936
  24521,  -22.5855961,   27.4449768, -0.909090936
  24522,  -23.4474621,   27.4449768, -0.909090936
  24523,  -24.3093281,   27.4449768, -0.909090936
  24524,  -25.1711922,   27.4449768, -0.909090936
  24525,  -26.0330582,   27.4449768, -0.909090936
  24526,  -27.0247936,   27.4449768, -0.909090936
  24527,  -28.0165291,   27.4449768, -0.909090936
  24528,  -29.0082645,   27.4449768, -0.909090936
  24529,  -20.9043674,    28.640192,    -9.090909
  24530,  -21.8087368,    28.640192,    -9.090909
  24531,  -22.7131042,    28.640192,    -9.090909
  24532,  -23.6174736,    28.640192,    -9.090909
  24533,   -24.521841,    28.640192,    -9.090909
  24534,  -25.4262104,    28.640192,    -9.090909
  24535,  -26.3305779,    28.640192,    -9.090909
  24536,  -27.2479343,    28.640192,    -9.090909
  24537,  -28.1652889,    28.640192,    -9.090909
  24538,  -29.0826454,    28.640192,    -9.090909
  24539,  -20.8996449,   28.5961723,  -8.18181801
  24540,  -21.7992916,   28.5961723,  -8.18181801
  24541,  -22.6989365,   28.5961723,  -8.18181801
  24542,  -23.5985832,   28.5961723,  -8.18181801
  24543,  -24.4982281,   28.5961723,  -8.18181801
  24544,  -25.3978748,   28.5961723,  -8.18181801
  24545,  -26.2975197,   28.5961723,  -8.18181801
  24546,  -27.2231407,   28.5961723,  -8.18181801
  24547,  -28.1487598,   28.5961723,  -8.18181801
  24548,  -29.0743809,   28.5961723,  -8.18181801
  24549,  -20.8949223,   28.5521526,  -7.27272749
  24550,  -21.7898464,   28.5521526,  -7.27272749
  24551,  -22.6847687,   28.5521526,  -7.27272749
  24552,  -23.5796928,   28.5521526,  -7.27272749
  24553,   -24.474617,   28.5521526,  -7.27272749
  24554,  -25.3695393,   28.5521526,  -7.27272749
  24555,  -26.2644634,   28.5521526,  -7.27272749
  24556,  -27.1983471,   28.5521526,  -7.27272749
  24557,  -28.1322308,   28.5521526,  -7.27272749
  24558,  -29.0661163,   28.5521526,  -7.27272749
  24559,  -20.8901997,   28.5081348,  -6.36363649
  24560,  -21.7804012,   28.5081348,  -6.36363649
  24561,  -22.6706009,   28.5081348,  -6.36363649
  24562,  -23.5608025,   28.5081348,  -6.36363649
  24563,   -24.451004,   28.5081348,  -6.36363649
  24564,  -25.3412037,   28.5081348,  -6.36363649
  24565,  -26.2314053,   28.5081348,  -6.36363649
  24566,  -27.1735535,   28.5081348,  -6.36363649
  24567,  -28.1157017,   28.5081348,  -6.36363649
  24568,  -29.0578518,   28.5081348,  -6.36363649
  24569,  -20.8854771,   28.4641151,   -5.4545455
  24570,   -21.770956,   28.4641151,   -5.4545455
  24571,  -22.6564331,   28.4641151,   -5.4545455
  24572,  -23.5419121,   28.4641151,   -5.4545455
  24573,  -24.4273911,   28.4641151,   -5.4545455
  24574,  -25.3128681,   28.4641151,   -5.4545455
  24575,  -26.1983471,   28.4641151,   -5.4545455
  24576,  -27.1487598,   28.4641151,   -5.4545455
  24577,  -28.0991726,   28.4641151,   -5.4545455
  24578,  -29.0495872,   28.4641151,   -5.4545455
  24579,  -20.8807564,   28.4200954,   -4.5454545
  24580,  -21.7615108,   28.4200954,   -4.5454545
  24581,  -22.6422672,   28.4200954,   -4.5454545
  24582,  -23.5230236,   28.4200954,   -4.5454545
  24583,  -24.4037781,   28.4200954,   -4.5454545
  24584,  -25.2845345,   28.4200954,   -4.5454545
  24585,  -26.1652889,   28.4200954,   -4.5454545
  24586,  -27.1239681,   28.4200954,   -4.5454545
  24587,  -28.0826454,   28.4200954,   -4.5454545
  24588,  -29.0413227,   28.4200954,   -4.5454545
  24589,  -20.8760338,   28.3760757,  -3.63636374
  24590,  -21.7520657,   28.3760757,  -3.63636374
  24591,  -22.6280994,   28.3760757,  -3.63636374
  24592,  -23.5041332,   28.3760757,  -3.63636374
  24593,  -24.3801651,   28.3760757,  -3.63636374
  24594,  -25.2561989,   28.3760757,  -3.63636374
  24595,  -26.1322308,   28.3760757,  -3.63636374
  24596,  -27.0991745,   28.3760757,  -3.63636374
  24597,  -28.0661163,   28.3760757,  -3.63636374
  24598,  -29.0330582,   28.3760757,  -3.63636374
  24599,  -20.8713112,    28.332058,  -2.72727275
  24600,  -21.7426205,    28.332058,  -2.72727275
  24601,  -22.6139317,    28.332058,  -2.72727275
  24602,  -23.4852428,    28.332058,  -2.72727275
  24603,  -24.3565521,    28.332058,  -2.72727275
  24604,  -25.2278633,    28.332058,  -2.72727275
  24605,  -26.0991726,    28.332058,  -2.72727275
  24606,  -27.0743809,    28.332058,  -2.72727275
  24607,  -28.0495872,    28.332058,  -2.72727275
  24608,  -29.0247936,    28.332058,  -2.72727275
  24609,  -20.8665886,   28.2880383,  -1.81818187
  24610,  -21.7331753,   28.2880383,  -1.81818187
  24611,  -22.5997639,   28.2880383,  -1.81818187
  24612,  -23.4663525,   28.2880383,  -1.81818187
  24613,  -24.3329411,   28.2880383,  -1.81818187
  24614,  -25.1995277,   28.2880383,  -1.81818187
  24615,  -26.0661163,   28.2880383,  -1.81818187
  24616,  -27.0495872,   28.2880383,  -1.81818187
  24617,  -28.0330582,   28.2880383,  -1.81818187
  24618,  -29.0165291,   28.2880383,  -1.81818187
  24619,   -20.861866,   28.2440186, -0.909090936
  24620,  -21.7237301,   28.2440186, -0.909090936
  24621,  -22.5855961,   28.2440186, -0.909090936
  24622,  -23.4474621,   28.2440186, -0.909090936
  24623,  -24.3093281,   28.2440186, -0.909090936
  24624,  -25.1711922,   28.2440186, -0.909090936
  24625,  -26.0330582,   28.2440186, -0.909090936
  24626,  -27.0247936,   28.2440186, -0.909090936
  24627,  -28.0165291,   28.2440186, -0.909090936
  24628,  -29.0082645,   28.2440186, -0.909090936
  24629,  -20.9043674,   29.4306221,    -9.090909
  24630,  -21.8087368,   29.4306221,    -9.090909
  24631,  -22.7131042,   29.4306221,    -9.090909
  24632,  -23.6174736,   29.4306221,    -9.090909
  24633,   -24.521841,   29.4306221,    -9.090909
  24634,  -25.4262104,   29.4306221,    -9.090909
  24635,  -26.3305779,   29.4306221,    -9.090909
  24636,  -27.2479343,   29.4306221,    -9.090909
  24637,  -28.1652889,   29.4306221,    -9.090909
  24638,  -29.0826454,   29.4306221,    -9.090909
  24639,  -20.8996449,   29.3875599,  -8.18181801
  24640,  -21.7992916,   29.3875599,  -8.18181801
  24641,  -22.6989365,   29.3875599,  -8.18181801
  24642,  -23.5985832,   29.3875599,  -8.18181801
  24643,  -24.4982281,   29.3875599,  -8.18181801
  24644,  -25.3978748,   29.3875599,  -8.18181801
  24645,  -26.2975197,   29.3875599,  -8.18181801
  24646,  -27.2231407,   29.3875599,  -8.18181801
  24647,  -28.1487598,   29.3875599,  -8.18181801
  24648,  -29.0743809,   29.3875599,  -8.18181801
  24649,  -20.8949223,   29.3444977,  -7.27272749
  24650,  -21.7898464,   29.3444977,  -7.27272749
  24651,  -22.6847687,   29.3444977,  -7.27272749
  24652,  -23.5796928,   29.3444977,  -7.27272749
  24653,   -24.474617,   29.3444977,  -7.27272749
  24654,  -25.3695393,   29.3444977,  -7.27272749
  24655,  -26.2644634,   29.3444977,  -7.27272749
  24656,  -27.1983471,   29.3444977,  -7.27272749
  24657,  -28.1322308,   29.3444977,  -7.27272749
  24658,  -29.0661163,   29.3444977,  -7.27272749
  24659,  -20.8901997,   29.3014355,  -6.36363649
  24660,  -21.7804012,   29.3014355,  -6.36363649
  24661,  -22.6706009,   29.3014355,  -6.36363649
  24662,  -23.5608025,   29.3014355,  -6.36363649
  24663,   -24.451004,   29.3014355,  -6.36363649
  24664,  -25.3412037,   29.3014355,  -6.36363649
  24665,  -26.2314053,   29.3014355,  -6.36363649
  24666,  -27.1735535,   29.3014355,  -6.36363649
  24667,  -28.1157017,   29.3014355,  -6.36363649
  24668,  -29.0578518,   29.3014355,  -6.36363649
  24669,  -20.8854771,   29.2583733,   -5.4545455
  24670,   -21.770956,   29.2583733,   -5.4545455
  24671,  -22.6564331,   29.2583733,   -5.4545455
  24672,  -23.5419121,   29.2583733,   -5.4545455
  24673,  -24.4273911,   29.2583733,   -5.4545455
  24674,  -25.3128681,   29.2583733,   -5.4545455
  24675,  -26.1983471,   29.2583733,   -5.4545455
  24676,  -27.1487598,   29.2583733,   -5.4545455
  24677,  -28.0991726,   29.2583733,   -5.4545455
  24678,  -29.0495872,   29.2583733,   -5.4545455
  24679,  -20.8807564,   29.2153111,   -4.5454545
  24680,  -21.7615108,   29.2153111,   -4.5454545
  24681,  -22.6422672,   29.2153111,   -4.5454545
  24682,  -23.5230236,   29.2153111,   -4.5454545
  24683,  -24.4037781,   29.2153111,   -4.5454545
  24684,  -25.2845345,   29.2153111,   -4.5454545
  24685,  -26.1652889,   29.2153111,   -4.5454545
  24686,  -27.1239681,   29.2153111,   -4.5454545
  24687,  -28.0826454,   29.2153111,   -4.5454545
  24688,  -29.0413227,   29.2153111,   -4.5454545
  24689,  -20.8760338,   29.1722488,  -3.63636374
  24690,  -21.7520657,   29.1722488,  -3.63636374
  24691,  -22.6280994,   29.1722488,  -3.63636374
  24692,  -23.5041332,   29.1722488,  -3.63636374
  24693,  -24.3801651,   29.1722488,  -3.63636374
  24694,  -25.2561989,   29.1722488,  -3.63636374
  24695,  -26.1322308,   29.1722488,  -3.63636374
  24696,  -27.0991745,   29.1722488,  -3.63636374
  24697,  -28.0661163,   29.1722488,  -3.63636374
  24698,  -29.0330582,   29.1722488,  -3.63636374
  24699,  -20.8713112,   29.1291866,  -2.72727275
  24700,  -21.7426205,   29.1291866,  -2.72727275
  24701,  -22.6139317,   29.1291866,  -2.72727275
  24702,  -23.4852428,   29.1291866,  -2.72727275
  24703,  -24.3565521,   29.1291866,  -2.72727275
  24704,  -25.2278633,   29.1291866,  -2.72727275
  24705,  -26.0991726,   29.1291866,  -2.72727275
  24706,  -27.0743809,   29.1291866,  -2.72727275
  24707,  -28.0495872,   29.1291866,  -2.72727275
  24708,  -29.0247936,   29.1291866,  -2.72727275
  24709,  -20.8665886,   29.0861244,  -1.81818187
  24710,  -21.7331753,   29.0861244,  -1.81818187
  24711,  -22.5997639,   29.0861244,  -1.81818187
  24712,  -23.4663525,   29.0861244,  -1.81818187
  24713,  -24.3329411,   29.0861244,  -1.81818187
  24714,  -25.1995277,   29.0861244,  -1.81818187
  24715,  -26.0661163,   29.0861244,  -1.81818187
  24716,  -27.0495872,   29.0861244,  -1.81818187
  24717,  -28.0330582,   29.0861244,  -1.81818187
  24718,  -29.0165291,   29.0861244,  -1.81818187
  24719,   -20.861866,   29.0430622, -0.909090936
  24720,  -21.7237301,   29.0430622, -0.909090936
  24721,  -22.5855961,   29.0430622, -0.909090936
  24722,  -23.4474621,   29.0430622, -0.909090936
  24723,  -24.3093281,   29.0430622, -0.909090936
  24724,  -25.1711922,   29.0430622, -0.909090936
  24725,  -26.0330582,   29.0430622, -0.909090936
  24726,  -27.0247936,   29.0430622, -0.909090936
  24727,  -28.0165291,   29.0430622, -0.909090936
  24728,  -29.0082645,   29.0430622, -0.909090936
  24729,  -20.9043674,   30.2210522,    -9.090909
  24730,  -21.8087368,   30.2210522,    -9.090909
  24731,  -22.7131042,   30.2210522,    -9.090909
  24732,  -23.6174736,   30.2210522,    -9.090909
  24733,   -24.521841,   30.2210522,    -9.090909
  24734,  -25.4262104,   30.2210522,    -9.090909
  24735,  -26.3305779,   30.2210522,    -9.090909
  24736,  -27.2479343,   30.2210522,    -9.090909
  24737,  -28.1652889,   30.2210522,    -9.090909
  24738,  -29.0826454,   30.2210522,    -9.090909
  24739,  -20.8996449,   30.1789474,  -8.18181801
  24740,  -21.7992916,   30.1789474,  -8.18181801
  24741,  -22.6989365,   30.1789474,  -8.18181801
  24742,  -23.5985832,   30.1789474,  -8.18181801
  24743,  -24.4982281,   30.1789474,  -8.18181801
  24744,  -25.3978748,   30.1789474,  -8.18181801
  24745,  -26.2975197,   30.1789474,  -8.18181801
  24746,  -27.2231407,   30.1789474,  -8.18181801
  24747,  -28.1487598,   30.1789474,  -8.18181801
  24748,  -29.0743809,   30.1789474,  -8.18181801
  24749,  -20.8949223,   30.1368427,  -7.27272749
  24750,  -21.7898464,   30.1368427,  -7.27272749
  24751,  -22.6847687,   30.1368427,  -7.27272749
  24752,  -23.5796928,   30.1368427,  -7.27272749
  24753,   -24.474617,   30.1368427,  -7.27272749
  24754,  -25.3695393,   30.1368427,  -7.27272749
  24755,  -26.2644634,   30.1368427,  -7.27272749
  24756,  -27.1983471,   30.1368427,  -7.27272749
  24757,  -28.1322308,   30.1368427,  -7.27272749
  24758,  -29.0661163,   30.1368427,  -7.27272749
  24759,  -20.8901997,   30.0947361,  -6.36363649
  24760,  -21.7804012,   30.0947361,  -6.36363649
  24761,  -22.6706009,   30.0947361,  -6.36363649
  24762,  -23.5608025,   30.0947361,  -6.36363649
  24763,   -24.451004,   30.0947361,  -6.36363649
  24764,  -25.3412037,   30.0947361,  -6.36363649
  24765,  -26.2314053,   30.0947361,  -6.36363649
  24766,  -27.1735535,   30.0947361,  -6.36363649
  24767,  -28.1157017,   30.0947361,  -6.36363649
  24768,  -29.0578518,   30.0947361,  -6.36363649
  24769,  -20.8854771,   30.0526314,   -5.4545455
  24770,   -21.770956,   30.0526314,   -5.4545455
  24771,  -22.6564331,   30.0526314,   -5.4545455
  24772,  -23.5419121,   30.0526314,   -5.4545455
  24773,  -24.4273911,   30.0526314,   -5.4545455
  24774,  -25.3128681,   30.0526314,   -5.4545455
  24775,  -26.1983471,   30.0526314,   -5.4545455
  24776,  -27.1487598,   30.0526314,   -5.4545455
  24777,  -28.0991726,   30.0526314,   -5.4545455
  24778,  -29.0495872,   30.0526314,   -5.4545455
  24779,  -20.8807564,   30.0105267,   -4.5454545
  24780,  -21.7615108,   30.0105267,   -4.5454545
  24781,  -22.6422672,   30.0105267,   -4.5454545
  24782,  -23.5230236,   30.0105267,   -4.5454545
  24783,  -24.4037781,   30.0105267,   -4.5454545
  24784,  -25.2845345,   30.0105267,   -4.5454545
  24785,  -26.1652889,   30.0105267,   -4.5454545
  24786,  -27.1239681,   30.0105267,   -4.5454545
  24787,  -28.0826454,   30.0105267,   -4.5454545
  24788,  -29.0413227,   30.0105267,   -4.5454545
  24789,  -20.8760338,   29.9684219,  -3.63636374
  24790,  -21.7520657,   29.9684219,  -3.63636374
  24791,  -22.6280994,   29.9684219,  -3.63636374
  24792,  -23.5041332,   29.9684219,  -3.63636374
  24793,  -24.3801651,   29.9684219,  -3.63636374
  24794,  -25.2561989,   29.9684219,  -3.63636374
  24795,  -26.1322308,   29.9684219,  -3.63636374
  24796,  -27.0991745,   29.9684219,  -3.63636374
  24797,  -28.0661163,   29.9684219,  -3.63636374
  24798,  -29.0330582,   29.9684219,  -3.63636374
  24799,  -20.8713112,   29.9263153,  -2.72727275
  24800,  -21.7426205,   29.9263153,  -2.72727275
  24801,  -22.6139317,   29.9263153,  -2.72727275
  24802,  -23.4852428,   29.9263153,  -2.72727275
  24803,  -24.3565521,   29.9263153,  -2.72727275
  24804,  -25.2278633,   29.9263153,  -2.72727275
  24805,  -26.0991726,   29.9263153,  -2.72727275
  24806,  -27.0743809,   29.9263153,  -2.72727275
  24807,  -28.0495872,   29.9263153,  -2.72727275
  24808,  -29.0247936,   29.9263153,  -2.72727275
  24809,  -20.8665886,   29.8842106,  -1.81818187
  24810,  -21.7331753,   29.8842106,  -1.81818187
  24811,  -22.5997639,   29.8842106,  -1.81818187
  24812,  -23.4663525,   29.8842106,  -1.81818187
  24813,  -24.3329411,   29.8842106,  -1.81818187
  24814,  -25.1995277,   29.8842106,  -1.81818187
  24815,  -26.0661163,   29.8842106,  -1.81818187
  24816,  -27.0495872,   29.8842106,  -1.81818187
  24817,  -28.0330582,   29.8842106,  -1.81818187
  24818,  -29.0165291,   29.8842106,  -1.81818187
  24819,   -20.861866,   29.8421059, -0.909090936
  24820,  -21.7237301,   29.8421059, -0.909090936
  24821,  -22.5855961,   29.8421059, -0.909090936
  24822,  -23.4474621,   29.8421059, -0.909090936
  24823,  -24.3093281,   29.8421059, -0.909090936
  24824,  -25.1711922,   29.8421059, -0.909090936
  24825,  -26.0330582,   29.8421059, -0.909090936
  24826,  -27.0247936,   29.8421059, -0.909090936
  24827,  -28.0165291,   29.8421059, -0.909090936
  24828,  -29.0082645,   29.8421059, -0.909090936
  24829,  -20.9043674,   31.0114841,    -9.090909
  24830,  -21.8087368,   31.0114841,    -9.090909
  24831,  -22.7131042,   31.0114841,    -9.090909
  24832,  -23.6174736,   31.0114841,    -9.090909
  24833,   -24.521841,   31.0114841,    -9.090909
  24834,  -25.4262104,   31.0114841,    -9.090909
  24835,  -26.3305779,   31.0114841,    -9.090909
  24836,  -27.2479343,   31.0114841,    -9.090909
  24837,  -28.1652889,   31.0114841,    -9.090909
  24838,  -29.0826454,   31.0114841,    -9.090909
  24839,  -20.8996449,    30.970335,  -8.18181801
  24840,  -21.7992916,    30.970335,  -8.18181801
  24841,  -22.6989365,    30.970335,  -8.18181801
  24842,  -23.5985832,    30.970335,  -8.18181801
  24843,  -24.4982281,    30.970335,  -8.18181801
  24844,  -25.3978748,    30.970335,  -8.18181801
  24845,  -26.2975197,    30.970335,  -8.18181801
  24846,  -27.2231407,    30.970335,  -8.18181801
  24847,  -28.1487598,    30.970335,  -8.18181801
  24848,  -29.0743809,    30.970335,  -8.18181801
  24849,  -20.8949223,   30.9291859,  -7.27272749
  24850,  -21.7898464,   30.9291859,  -7.27272749
  24851,  -22.6847687,   30.9291859,  -7.27272749
  24852,  -23.5796928,   30.9291859,  -7.27272749
  24853,   -24.474617,   30.9291859,  -7.27272749
  24854,  -25.3695393,   30.9291859,  -7.27272749
  24855,  -26.2644634,   30.9291859,  -7.27272749
  24856,  -27.1983471,   30.9291859,  -7.27272749
  24857,  -28.1322308,   30.9291859,  -7.27272749
  24858,  -29.0661163,   30.9291859,  -7.27272749
  24859,  -20.8901997,   30.8880386,  -6.36363649
  24860,  -21.7804012,   30.8880386,  -6.36363649
  24861,  -22.6706009,   30.8880386,  -6.36363649
  24862,  -23.5608025,   30.8880386,  -6.36363649
  24863,   -24.451004,   30.8880386,  -6.36363649
  24864,  -25.3412037,   30.8880386,  -6.36363649
  24865,  -26.2314053,   30.8880386,  -6.36363649
  24866,  -27.1735535,   30.8880386,  -6.36363649
  24867,  -28.1157017,   30.8880386,  -6.36363649
  24868,  -29.0578518,   30.8880386,  -6.36363649
  24869,  -20.8854771,   30.8468895,   -5.4545455
  24870,   -21.770956,   30.8468895,   -5.4545455
  24871,  -22.6564331,   30.8468895,   -5.4545455
  24872,  -23.5419121,   30.8468895,   -5.4545455
  24873,  -24.4273911,   30.8468895,   -5.4545455
  24874,  -25.3128681,   30.8468895,   -5.4545455
  24875,  -26.1983471,   30.8468895,   -5.4545455
  24876,  -27.1487598,   30.8468895,   -5.4545455
  24877,  -28.0991726,   30.8468895,   -5.4545455
  24878,  -29.0495872,   30.8468895,   -5.4545455
  24879,  -20.8807564,   30.8057423,   -4.5454545
  24880,  -21.7615108,   30.8057423,   -4.5454545
  24881,  -22.6422672,   30.8057423,   -4.5454545
  24882,  -23.5230236,   30.8057423,   -4.5454545
  24883,  -24.4037781,   30.8057423,   -4.5454545
  24884,  -25.2845345,   30.8057423,   -4.5454545
  24885,  -26.1652889,   30.8057423,   -4.5454545
  24886,  -27.1239681,   30.8057423,   -4.5454545
  24887,  -28.0826454,   30.8057423,   -4.5454545
  24888,  -29.0413227,   30.8057423,   -4.5454545
  24889,  -20.8760338,   30.7645931,  -3.63636374
  24890,  -21.7520657,   30.7645931,  -3.63636374
  24891,  -22.6280994,   30.7645931,  -3.63636374
  24892,  -23.5041332,   30.7645931,  -3.63636374
  24893,  -24.3801651,   30.7645931,  -3.63636374
  24894,  -25.2561989,   30.7645931,  -3.63636374
  24895,  -26.1322308,   30.7645931,  -3.63636374
  24896,  -27.0991745,   30.7645931,  -3.63636374
  24897,  -28.0661163,   30.7645931,  -3.63636374
  24898,  -29.0330582,   30.7645931,  -3.63636374
  24899,  -20.8713112,   30.7234459,  -2.72727275
  24900,  -21.7426205,   30.7234459,  -2.72727275
  24901,  -22.6139317,   30.7234459,  -2.72727275
  24902,  -23.4852428,   30.7234459,  -2.72727275
  24903,  -24.3565521,   30.7234459,  -2.72727275
  24904,  -25.2278633,   30.7234459,  -2.72727275
  24905,  -26.0991726,   30.7234459,  -2.72727275
  24906,  -27.0743809,   30.7234459,  -2.72727275
  24907,  -28.0495872,   30.7234459,  -2.72727275
  24908,  -29.0247936,   30.7234459,  -2.72727275
  24909,  -20.8665886,   30.6822968,  -1.81818187
  24910,  -21.7331753,   30.6822968,  -1.81818187
  24911,  -22.5997639,   30.6822968,  -1.81818187
  24912,  -23.4663525,   30.6822968,  -1.81818187
  24913,  -24.3329411,   30.6822968,  -1.81818187
  24914,  -25.1995277,   30.6822968,  -1.81818187
  24915,  -26.0661163,   30.6822968,  -1.81818187
  24916,  -27.0495872,   30.6822968,  -1.81818187
  24917,  -28.0330582,   30.6822968,  -1.81818187
  24918,  -29.0165291,   30.6822968,  -1.81818187
  24919,   -20.861866,   30.6411476, -0.909090936
  24920,  -21.7237301,   30.6411476, -0.909090936
  24921,  -22.5855961,   30.6411476, -0.909090936
  24922,  -23.4474621,   30.6411476, -0.909090936
  24923,  -24.3093281,   30.6411476, -0.909090936
  24924,  -25.1711922,   30.6411476, -0.909090936
  24925,  -26.0330582,   30.6411476, -0.909090936
  24926,  -27.0247936,   30.6411476, -0.909090936
  24927,  -28.0165291,   30.6411476, -0.909090936
  24928,  -29.0082645,   30.6411476, -0.909090936
  24929,  -20.9043674,   31.8019142,    -9.090909
  24930,  -21.8087368,   31.8019142,    -9.090909
  24931,  -22.7131042,   31.8019142,    -9.090909
  24932,  -23.6174736,   31.8019142,    -9.090909
  24933,   -24.521841,   31.8019142,    -9.090909
  24934,  -25.4262104,   31.8019142,    -9.090909
  24935,  -26.3305779,   31.8019142,    -9.090909
  24936,  -27.2479343,   31.8019142,    -9.090909
  24937,  -28.1652889,   31.8019142,    -9.090909
  24938,  -29.0826454,   31.8019142,    -9.090909
  24939,  -20.8996449,   31.7617226,  -8.18181801
  24940,  -21.7992916,   31.7617226,  -8.18181801
  24941,  -22.6989365,   31.7617226,  -8.18181801
  24942,  -23.5985832,   31.7617226,  -8.18181801
  24943,  -24.4982281,   31.7617226,  -8.18181801
  24944,  -25.3978748,   31.7617226,  -8.18181801
  24945,  -26.2975197,   31.7617226,  -8.18181801
  24946,  -27.2231407,   31.7617226,  -8.18181801
  24947,  -28.1487598,   31.7617226,  -8.18181801
  24948,  -29.0743809,   31.7617226,  -8.18181801
  24949,  -20.8949223,   31.7215309,  -7.27272749
  24950,  -21.7898464,   31.7215309,  -7.27272749
  24951,  -22.6847687,   31.7215309,  -7.27272749
  24952,  -23.5796928,   31.7215309,  -7.27272749
  24953,   -24.474617,   31.7215309,  -7.27272749
  24954,  -25.3695393,   31.7215309,  -7.27272749
  24955,  -26.2644634,   31.7215309,  -7.27272749
  24956,  -27.1983471,   31.7215309,  -7.27272749
  24957,  -28.1322308,   31.7215309,  -7.27272749
  24958,  -29.0661163,   31.7215309,  -7.27272749
  24959,  -20.8901997,   31.6813393,  -6.36363649
  24960,  -21.7804012,   31.6813393,  -6.36363649
  24961,  -22.6706009,   31.6813393,  -6.36363649
  24962,  -23.5608025,   31.6813393,  -6.36363649
  24963,   -24.451004,   31.6813393,  -6.36363649
  24964,  -25.3412037,   31.6813393,  -6.36363649
  24965,  -26.2314053,   31.6813393,  -6.36363649
  24966,  -27.1735535,   31.6813393,  -6.36363649
  24967,  -28.1157017,   31.6813393,  -6.36363649
  24968,  -29.0578518,   31.6813393,  -6.36363649
  24969,  -20.8854771,   31.6411476,   -5.4545455
  24970,   -21.770956,   31.6411476,   -5.4545455
  24971,  -22.6564331,   31.6411476,   -5.4545455
  24972,  -23.5419121,   31.6411476,   -5.4545455
  24973,  -24.4273911,   31.6411476,   -5.4545455
  24974,  -25.3128681,   31.6411476,   -5.4545455
  24975,  -26.1983471,   31.6411476,   -5.4545455
  24976,  -27.1487598,   31.6411476,   -5.4545455
  24977,  -28.0991726,   31.6411476,   -5.4545455
  24978,  -29.0495872,   31.6411476,   -5.4545455
  24979,  -20.8807564,   31.6009579,   -4.5454545
  24980,  -21.7615108,   31.6009579,   -4.5454545
  24981,  -22.6422672,   31.6009579,   -4.5454545
  24982,  -23.5230236,   31.6009579,   -4.5454545
  24983,  -24.4037781,   31.6009579,   -4.5454545
  24984,  -25.2845345,   31.6009579,   -4.5454545
  24985,  -26.1652889,   31.6009579,   -4.5454545
  24986,  -27.1239681,   31.6009579,   -4.5454545
  24987,  -28.0826454,   31.6009579,   -4.5454545
  24988,  -29.0413227,   31.6009579,   -4.5454545
  24989,  -20.8760338,   31.5607662,  -3.63636374
  24990,  -21.7520657,   31.5607662,  -3.63636374
  24991,  -22.6280994,   31.5607662,  -3.63636374
  24992,  -23.5041332,   31.5607662,  -3.63636374
  24993,  -24.3801651,   31.5607662,  -3.63636374
  24994,  -25.2561989,   31.5607662,  -3.63636374
  24995,  -26.1322308,   31.5607662,  -3.63636374
  24996,  -27.0991745,   31.5607662,  -3.63636374
  24997,  -28.0661163,   31.5607662,  -3.63636374
  24998,  -29.0330582,   31.5607662,  -3.63636374
  24999,  -20.8713112,   31.5205746,  -2.72727275
  25000,  -21.7426205,   31.5205746,  -2.72727275
  25001,  -22.6139317,   31.5205746,  -2.72727275
  25002,  -23.4852428,   31.5205746,  -2.72727275
  25003,  -24.3565521,   31.5205746,  -2.72727275
  25004,  -25.2278633,   31.5205746,  -2.72727275
  25005,  -26.0991726,   31.5205746,  -2.72727275
  25006,  -27.0743809,   31.5205746,  -2.72727275
  25007,  -28.0495872,   31.5205746,  -2.72727275
  25008,  -29.0247936,   31.5205746,  -2.72727275
  25009,  -20.8665886,   31.4803829,  -1.81818187
  25010,  -21.7331753,   31.4803829,  -1.81818187
  25011,  -22.5997639,   31.4803829,  -1.81818187
  25012,  -23.4663525,   31.4803829,  -1.81818187
  25013,  -24.3329411,   31.4803829,  -1.81818187
  25014,  -25.1995277,   31.4803829,  -1.81818187
  25015,  -26.0661163,   31.4803829,  -1.81818187
  25016,  -27.0495872,   31.4803829,  -1.81818187
  25017,  -28.0330582,   31.4803829,  -1.81818187
  25018,  -29.0165291,   31.4803829,  -1.81818187
  25019,   -20.861866,   31.4401913, -0.909090936
  25020,  -21.7237301,   31.4401913, -0.909090936
  25021,  -22.5855961,   31.4401913, -0.909090936
  25022,  -23.4474621,   31.4401913, -0.909090936
  25023,  -24.3093281,   31.4401913, -0.909090936
  25024,  -25.1711922,   31.4401913, -0.909090936
  25025,  -26.0330582,   31.4401913, -0.909090936
  25026,  -27.0247936,   31.4401913, -0.909090936
  25027,  -28.0165291,   31.4401913, -0.909090936
  25028,  -29.0082645,   31.4401913, -0.909090936
  25029,  -20.9043674,   32.5923462,    -9.090909
  25030,  -21.8087368,   32.5923462,    -9.090909
  25031,  -22.7131042,   32.5923462,    -9.090909
  25032,  -23.6174736,   32.5923462,    -9.090909
  25033,   -24.521841,   32.5923462,    -9.090909
  25034,  -25.4262104,   32.5923462,    -9.090909
  25035,  -26.3305779,   32.5923462,    -9.090909
  25036,  -27.2479343,   32.5923462,    -9.090909
  25037,  -28.1652889,   32.5923462,    -9.090909
  25038,  -29.0826454,   32.5923462,    -9.090909
  25039,  -20.8996449,   32.5531082,  -8.18181801
  25040,  -21.7992916,   32.5531082,  -8.18181801
  25041,  -22.6989365,   32.5531082,  -8.18181801
  25042,  -23.5985832,   32.5531082,  -8.18181801
  25043,  -24.4982281,   32.5531082,  -8.18181801
  25044,  -25.3978748,   32.5531082,  -8.18181801
  25045,  -26.2975197,   32.5531082,  -8.18181801
  25046,  -27.2231407,   32.5531082,  -8.18181801
  25047,  -28.1487598,   32.5531082,  -8.18181801
  25048,  -29.0743809,   32.5531082,  -8.18181801
  25049,  -20.8949223,   32.5138741,  -7.27272749
  25050,  -21.7898464,   32.5138741,  -7.27272749
  25051,  -22.6847687,   32.5138741,  -7.27272749
  25052,  -23.5796928,   32.5138741,  -7.27272749
  25053,   -24.474617,   32.5138741,  -7.27272749
  25054,  -25.3695393,   32.5138741,  -7.27272749
  25055,  -26.2644634,   32.5138741,  -7.27272749
  25056,  -27.1983471,   32.5138741,  -7.27272749
  25057,  -28.1322308,   32.5138741,  -7.27272749
  25058,  -29.0661163,   32.5138741,  -7.27272749
  25059,  -20.8901997,   32.4746399,  -6.36363649
  25060,  -21.7804012,   32.4746399,  -6.36363649
  25061,  -22.6706009,   32.4746399,  -6.36363649
  25062,  -23.5608025,   32.4746399,  -6.36363649
  25063,   -24.451004,   32.4746399,  -6.36363649
  25064,  -25.3412037,   32.4746399,  -6.36363649
  25065,  -26.2314053,   32.4746399,  -6.36363649
  25066,  -27.1735535,   32.4746399,  -6.36363649
  25067,  -28.1157017,   32.4746399,  -6.36363649
  25068,  -29.0578518,   32.4746399,  -6.36363649
  25069,  -20.8854771,   32.4354057,   -5.4545455
  25070,   -21.770956,   32.4354057,   -5.4545455
  25071,  -22.6564331,   32.4354057,   -5.4545455
  25072,  -23.5419121,   32.4354057,   -5.4545455
  25073,  -24.4273911,   32.4354057,   -5.4545455
  25074,  -25.3128681,   32.4354057,   -5.4545455
  25075,  -26.1983471,   32.4354057,   -5.4545455
  25076,  -27.1487598,   32.4354057,   -5.4545455
  25077,  -28.0991726,   32.4354057,   -5.4545455
  25078,  -29.0495872,   32.4354057,   -5.4545455
  25079,  -20.8807564,   32.3961716,   -4.5454545
  25080,  -21.7615108,   32.3961716,   -4.5454545
  25081,  -22.6422672,   32.3961716,   -4.5454545
  25082,  -23.5230236,   32.3961716,   -4.5454545
  25083,  -24.4037781,   32.3961716,   -4.5454545
  25084,  -25.2845345,   32.3961716,   -4.5454545
  25085,  -26.1652889,   32.3961716,   -4.5454545
  25086,  -27.1239681,   32.3961716,   -4.5454545
  25087,  -28.0826454,   32.3961716,   -4.5454545
  25088,  -29.0413227,   32.3961716,   -4.5454545
  25089,  -20.8760338,   32.3569374,  -3.63636374
  25090,  -21.7520657,   32.3569374,  -3.63636374
  25091,  -22.6280994,   32.3569374,  -3.63636374
  25092,  -23.5041332,   32.3569374,  -3.63636374
  25093,  -24.3801651,   32.3569374,  -3.63636374
  25094,  -25.2561989,   32.3569374,  -3.63636374
  25095,  -26.1322308,   32.3569374,  -3.63636374
  25096,  -27.0991745,   32.3569374,  -3.63636374
  25097,  -28.0661163,   32.3569374,  -3.63636374
  25098,  -29.0330582,   32.3569374,  -3.63636374
  25099,  -20.8713112,   32.3177032,  -2.72727275
  25100,  -21.7426205,   32.3177032,  -2.72727275
  25101,  -22.6139317,   32.3177032,  -2.72727275
  25102,  -23.4852428,   32.3177032,  -2.72727275
  25103,  -24.3565521,   32.3177032,  -2.72727275
  25104,  -25.2278633,   32.3177032,  -2.72727275
  25105,  -26.0991726,   32.3177032,  -2.72727275
  25106,  -27.0743809,   32.3177032,  -2.72727275
  25107,  -28.0495872,   32.3177032,  -2.72727275
  25108,  -29.0247936,   32.3177032,  -2.72727275
  25109,  -20.8665886,   32.2784691,  -1.81818187
  25110,  -21.7331753,   32.2784691,  -1.81818187
  25111,  -22.5997639,   32.2784691,  -1.81818187
  25112,  -23.4663525,   32.2784691,  -1.81818187
  25113,  -24.3329411,   32.2784691,  -1.81818187
  25114,  -25.1995277,   32.2784691,  -1.81818187
  25115,  -26.0661163,   32.2784691,  -1.81818187
  25116,  -27.0495872,   32.2784691,  -1.81818187
  25117,  -28.0330582,   32.2784691,  -1.81818187
  25118,  -29.0165291,   32.2784691,  -1.81818187
  25119,   -20.861866,   32.2392349, -0.909090936
  25120,  -21.7237301,   32.2392349, -0.909090936
  25121,  -22.5855961,   32.2392349, -0.909090936
  25122,  -23.4474621,   32.2392349, -0.909090936
  25123,  -24.3093281,   32.2392349, -0.909090936
  25124,  -25.1711922,   32.2392349, -0.909090936
  25125,  -26.0330582,   32.2392349, -0.909090936
  25126,  -27.0247936,   32.2392349, -0.909090936
  25127,  -28.0165291,   32.2392349, -0.909090936
  25128,  -29.0082645,   32.2392349, -0.909090936
  25129,  -20.9043674,   33.3827744,    -9.090909
  25130,  -21.8087368,   33.3827744,    -9.090909
  25131,  -22.7131042,   33.3827744,    -9.090909
  25132,  -23.6174736,   33.3827744,    -9.090909
  25133,   -24.521841,   33.3827744,    -9.090909
  25134,  -25.4262104,   33.3827744,    -9.090909
  25135,  -26.3305779,   33.3827744,    -9.090909
  25136,  -27.2479343,   33.3827744,    -9.090909
  25137,  -28.1652889,   33.3827744,    -9.090909
  25138,  -29.0826454,   33.3827744,    -9.090909
  25139,  -20.8996449,   33.3444977,  -8.18181801
  25140,  -21.7992916,   33.3444977,  -8.18181801
  25141,  -22.6989365,   33.3444977,  -8.18181801
  25142,  -23.5985832,   33.3444977,  -8.18181801
  25143,  -24.4982281,   33.3444977,  -8.18181801
  25144,  -25.3978748,   33.3444977,  -8.18181801
  25145,  -26.2975197,   33.3444977,  -8.18181801
  25146,  -27.2231407,   33.3444977,  -8.18181801
  25147,  -28.1487598,   33.3444977,  -8.18181801
  25148,  -29.0743809,   33.3444977,  -8.18181801
  25149,  -20.8949223,    33.306221,  -7.27272749
  25150,  -21.7898464,    33.306221,  -7.27272749
  25151,  -22.6847687,    33.306221,  -7.27272749
  25152,  -23.5796928,    33.306221,  -7.27272749
  25153,   -24.474617,    33.306221,  -7.27272749
  25154,  -25.3695393,    33.306221,  -7.27272749
  25155,  -26.2644634,    33.306221,  -7.27272749
  25156,  -27.1983471,    33.306221,  -7.27272749
  25157,  -28.1322308,    33.306221,  -7.27272749
  25158,  -29.0661163,    33.306221,  -7.27272749
  25159,  -20.8901997,   33.2679443,  -6.36363649
  25160,  -21.7804012,   33.2679443,  -6.36363649
  25161,  -22.6706009,   33.2679443,  -6.36363649
  25162,  -23.5608025,   33.2679443,  -6.36363649
  25163,   -24.451004,   33.2679443,  -6.36363649
  25164,  -25.3412037,   33.2679443,  -6.36363649
  25165,  -26.2314053,   33.2679443,  -6.36363649
  25166,  -27.1735535,   33.2679443,  -6.36363649
  25167,  -28.1157017,   33.2679443,  -6.36363649
  25168,  -29.0578518,   33.2679443,  -6.36363649
  25169,  -20.8854771,   33.2296638,   -5.4545455
  25170,   -21.770956,   33.2296638,   -5.4545455
  25171,  -22.6564331,   33.2296638,   -5.4545455
  25172,  -23.5419121,   33.2296638,   -5.4545455
  25173,  -24.4273911,   33.2296638,   -5.4545455
  25174,  -25.3128681,   33.2296638,   -5.4545455
  25175,  -26.1983471,   33.2296638,   -5.4545455
  25176,  -27.1487598,   33.2296638,   -5.4545455
  25177,  -28.0991726,   33.2296638,   -5.4545455
  25178,  -29.0495872,   33.2296638,   -5.4545455
  25179,  -20.8807564,   33.1913872,   -4.5454545
  25180,  -21.7615108,   33.1913872,   -4.5454545
  25181,  -22.6422672,   33.1913872,   -4.5454545
  25182,  -23.5230236,   33.1913872,   -4.5454545
  25183,  -24.4037781,   33.1913872,   -4.5454545
  25184,  -25.2845345,   33.1913872,   -4.5454545
  25185,  -26.1652889,   33.1913872,   -4.5454545
  25186,  -27.1239681,   33.1913872,   -4.5454545
  25187,  -28.0826454,   33.1913872,   -4.5454545
  25188,  -29.0413227,   33.1913872,   -4.5454545
  25189,  -20.8760338,   33.1531105,  -3.63636374
  25190,  -21.7520657,   33.1531105,  -3.63636374
  25191,  -22.6280994,   33.1531105,  -3.63636374
  25192,  -23.5041332,   33.1531105,  -3.63636374
  25193,  -24.3801651,   33.1531105,  -3.63636374
  25194,  -25.2561989,   33.1531105,  -3.63636374
  25195,  -26.1322308,   33.1531105,  -3.63636374
  25196,  -27.0991745,   33.1531105,  -3.63636374
  25197,  -28.0661163,   33.1531105,  -3.63636374
  25198,  -29.0330582,   33.1531105,  -3.63636374
  25199,  -20.8713112,   33.1148338,  -2.72727275
  25200,  -21.7426205,   33.1148338,  -2.72727275
  25201,  -22.6139317,   33.1148338,  -2.72727275
  25202,  -23.4852428,   33.1148338,  -2.72727275
  25203,  -24.3565521,   33.1148338,  -2.72727275
  25204,  -25.2278633,   33.1148338,  -2.72727275
  25205,  -26.0991726,   33.1148338,  -2.72727275
  25206,  -27.0743809,   33.1148338,  -2.72727275
  25207,  -28.0495872,   33.1148338,  -2.72727275
  25208,  -29.0247936,   33.1148338,  -2.72727275
  25209,  -20.8665886,   33.0765533,  -1.81818187
  25210,  -21.7331753,   33.0765533,  -1.81818187
  25211,  -22.5997639,   33.0765533,  -1.81818187
  25212,  -23.4663525,   33.0765533,  -1.81818187
  25213,  -24.3329411,   33.0765533,  -1.81818187
  25214,  -25.1995277,   33.0765533,  -1.81818187
  25215,  -26.0661163,   33.0765533,  -1.81818187
  25216,  -27.0495872,   33.0765533,  -1.81818187
  25217,  -28.0330582,   33.0765533,  -1.81818187
  25218,  -29.0165291,   33.0765533,  -1.81818187
  25219,   -20.861866,   33.0382767, -0.909090936
  25220,  -21.7237301,   33.0382767, -0.909090936
  25221,  -22.5855961,   33.0382767, -0.909090936
  25222,  -23.4474621,   33.0382767, -0.909090936
  25223,  -24.3093281,   33.0382767, -0.909090936
  25224,  -25.1711922,   33.0382767, -0.909090936
  25225,  -26.0330582,   33.0382767, -0.909090936
  25226,  -27.0247936,   33.0382767, -0.909090936
  25227,  -28.0165291,   33.0382767, -0.909090936
  25228,  -29.0082645,   33.0382767, -0.909090936
  25229,  -20.9043674,   34.1732063,    -9.090909
  25230,  -21.8087368,   34.1732063,    -9.090909
  25231,  -22.7131042,   34.1732063,    -9.090909
  25232,  -23.6174736,   34.1732063,    -9.090909
  25233,   -24.521841,   34.1732063,    -9.090909
  25234,  -25.4262104,   34.1732063,    -9.090909
  25235,  -26.3305779,   34.1732063,    -9.090909
  25236,  -27.2479343,   34.1732063,    -9.090909
  25237,  -28.1652889,   34.1732063,    -9.090909
  25238,  -29.0826454,   34.1732063,    -9.090909
  25239,  -20.8996449,   34.1358833,  -8.18181801
  25240,  -21.7992916,   34.1358833,  -8.18181801
  25241,  -22.6989365,   34.1358833,  -8.18181801
  25242,  -23.5985832,   34.1358833,  -8.18181801
  25243,  -24.4982281,   34.1358833,  -8.18181801
  25244,  -25.3978748,   34.1358833,  -8.18181801
  25245,  -26.2975197,   34.1358833,  -8.18181801
  25246,  -27.2231407,   34.1358833,  -8.18181801
  25247,  -28.1487598,   34.1358833,  -8.18181801
  25248,  -29.0743809,   34.1358833,  -8.18181801
  25249,  -20.8949223,   34.0985641,  -7.27272749
  25250,  -21.7898464,   34.0985641,  -7.27272749
  25251,  -22.6847687,   34.0985641,  -7.27272749
  25252,  -23.5796928,   34.0985641,  -7.27272749
  25253,   -24.474617,   34.0985641,  -7.27272749
  25254,  -25.3695393,   34.0985641,  -7.27272749
  25255,  -26.2644634,   34.0985641,  -7.27272749
  25256,  -27.1983471,   34.0985641,  -7.27272749
  25257,  -28.1322308,   34.0985641,  -7.27272749
  25258,  -29.0661163,   34.0985641,  -7.27272749
  25259,  -20.8901997,    34.061245,  -6.36363649
  25260,  -21.7804012,    34.061245,  -6.36363649
  25261,  -22.6706009,    34.061245,  -6.36363649
  25262,  -23.5608025,    34.061245,  -6.36363649
  25263,   -24.451004,    34.061245,  -6.36363649
  25264,  -25.3412037,    34.061245,  -6.36363649
  25265,  -26.2314053,    34.061245,  -6.36363649
  25266,  -27.1735535,    34.061245,  -6.36363649
  25267,  -28.1157017,    34.061245,  -6.36363649
  25268,  -29.0578518,    34.061245,  -6.36363649
  25269,  -20.8854771,    34.023922,   -5.4545455
  25270,   -21.770956,    34.023922,   -5.4545455
  25271,  -22.6564331,    34.023922,   -5.4545455
  25272,  -23.5419121,    34.023922,   -5.4545455
  25273,  -24.4273911,    34.023922,   -5.4545455
  25274,  -25.3128681,    34.023922,   -5.4545455
  25275,  -26.1983471,    34.023922,   -5.4545455
  25276,  -27.1487598,    34.023922,   -5.4545455
  25277,  -28.0991726,    34.023922,   -5.4545455
  25278,  -29.0495872,    34.023922,   -5.4545455
  25279,  -20.8807564,   33.9866028,   -4.5454545
  25280,  -21.7615108,   33.9866028,   -4.5454545
  25281,  -22.6422672,   33.9866028,   -4.5454545
  25282,  -23.5230236,   33.9866028,   -4.5454545
  25283,  -24.4037781,   33.9866028,   -4.5454545
  25284,  -25.2845345,   33.9866028,   -4.5454545
  25285,  -26.1652889,   33.9866028,   -4.5454545
  25286,  -27.1239681,   33.9866028,   -4.5454545
  25287,  -28.0826454,   33.9866028,   -4.5454545
  25288,  -29.0413227,   33.9866028,   -4.5454545
  25289,  -20.8760338,   33.9492836,  -3.63636374
  25290,  -21.7520657,   33.9492836,  -3.63636374
  25291,  -22.6280994,   33.9492836,  -3.63636374
  25292,  -23.5041332,   33.9492836,  -3.63636374
  25293,  -24.3801651,   33.9492836,  -3.63636374
  25294,  -25.2561989,   33.9492836,  -3.63636374
  25295,  -26.1322308,   33.9492836,  -3.63636374
  25296,  -27.0991745,   33.9492836,  -3.63636374
  25297,  -28.0661163,   33.9492836,  -3.63636374
  25298,  -29.0330582,   33.9492836,  -3.63636374
  25299,  -20.8713112,   33.9119606,  -2.72727275
  25300,  -21.7426205,   33.9119606,  -2.72727275
  25301,  -22.6139317,   33.9119606,  -2.72727275
  25302,  -23.4852428,   33.9119606,  -2.72727275
  25303,  -24.3565521,   33.9119606,  -2.72727275
  25304,  -25.2278633,   33.9119606,  -2.72727275
  25305,  -26.0991726,   33.9119606,  -2.72727275
  25306,  -27.0743809,   33.9119606,  -2.72727275
  25307,  -28.0495872,   33.9119606,  -2.72727275
  25308,  -29.0247936,   33.9119606,  -2.72727275
  25309,  -20.8665886,   33.8746414,  -1.81818187
  25310,  -21.7331753,   33.8746414,  -1.81818187
  25311,  -22.5997639,   33.8746414,  -1.81818187
  25312,  -23.4663525,   33.8746414,  -1.81818187
  25313,  -24.3329411,   33.8746414,  -1.81818187
  25314,  -25.1995277,   33.8746414,  -1.81818187
  25315,  -26.0661163,   33.8746414,  -1.81818187
  25316,  -27.0495872,   33.8746414,  -1.81818187
  25317,  -28.0330582,   33.8746414,  -1.81818187
  25318,  -29.0165291,   33.8746414,  -1.81818187
  25319,   -20.861866,   33.8373222, -0.909090936
  25320,  -21.7237301,   33.8373222, -0.909090936
  25321,  -22.5855961,   33.8373222, -0.909090936
  25322,  -23.4474621,   33.8373222, -0.909090936
  25323,  -24.3093281,   33.8373222, -0.909090936
  25324,  -25.1711922,   33.8373222, -0.909090936
  25325,  -26.0330582,   33.8373222, -0.909090936
  25326,  -27.0247936,   33.8373222, -0.909090936
  25327,  -28.0165291,   33.8373222, -0.909090936
  25328,  -29.0082645,   33.8373222, -0.909090936
  25329,  -20.9043674,   34.9636345,    -9.090909
  25330,  -21.8087368,   34.9636345,    -9.090909
  25331,  -22.7131042,   34.9636345,    -9.090909
  25332,  -23.6174736,   34.9636345,    -9.090909
  25333,   -24.521841,   34.9636345,    -9.090909
  25334,  -25.4262104,   34.9636345,    -9.090909
  25335,  -26.3305779,   34.9636345,    -9.090909
  25336,  -27.2479343,   34.9636345,    -9.090909
  25337,  -28.1652889,   34.9636345,    -9.090909
  25338,  -29.0826454,   34.9636345,    -9.090909
  25339,  -20.8996449,   34.9272728,  -8.18181801
  25340,  -21.7992916,   34.9272728,  -8.18181801
  25341,  -22.6989365,   34.9272728,  -8.18181801
  25342,  -23.5985832,   34.9272728,  -8.18181801
  25343,  -24.4982281,   34.9272728,  -8.18181801
  25344,  -25.3978748,   34.9272728,  -8.18181801
  25345,  -26.2975197,   34.9272728,  -8.18181801
  25346,  -27.2231407,   34.9272728,  -8.18181801
  25347,  -28.1487598,   34.9272728,  -8.18181801
  25348,  -29.0743809,   34.9272728,  -8.18181801
  25349,  -20.8949223,   34.8909073,  -7.27272749
  25350,  -21.7898464,   34.8909073,  -7.27272749
  25351,  -22.6847687,   34.8909073,  -7.27272749
  25352,  -23.5796928,   34.8909073,  -7.27272749
  25353,   -24.474617,   34.8909073,  -7.27272749
  25354,  -25.3695393,   34.8909073,  -7.27272749
  25355,  -26.2644634,   34.8909073,  -7.27272749
  25356,  -27.1983471,   34.8909073,  -7.27272749
  25357,  -28.1322308,   34.8909073,  -7.27272749
  25358,  -29.0661163,   34.8909073,  -7.27272749
  25359,  -20.8901997,   34.8545456,  -6.36363649
  25360,  -21.7804012,   34.8545456,  -6.36363649
  25361,  -22.6706009,   34.8545456,  -6.36363649
  25362,  -23.5608025,   34.8545456,  -6.36363649
  25363,   -24.451004,   34.8545456,  -6.36363649
  25364,  -25.3412037,   34.8545456,  -6.36363649
  25365,  -26.2314053,   34.8545456,  -6.36363649
  25366,  -27.1735535,   34.8545456,  -6.36363649
  25367,  -28.1157017,   34.8545456,  -6.36363649
  25368,  -29.0578518,   34.8545456,  -6.36363649
  25369,  -20.8854771,   34.8181801,   -5.4545455
  25370,   -21.770956,   34.8181801,   -5.4545455
  25371,  -22.6564331,   34.8181801,   -5.4545455
  25372,  -23.5419121,   34.8181801,   -5.4545455
  25373,  -24.4273911,   34.8181801,   -5.4545455
  25374,  -25.3128681,   34.8181801,   -5.4545455
  25375,  -26.1983471,   34.8181801,   -5.4545455
  25376,  -27.1487598,   34.8181801,   -5.4545455
  25377,  -28.0991726,   34.8181801,   -5.4545455
  25378,  -29.0495872,   34.8181801,   -5.4545455
  25379,  -20.8807564,   34.7818184,   -4.5454545
  25380,  -21.7615108,   34.7818184,   -4.5454545
  25381,  -22.6422672,   34.7818184,   -4.5454545
  25382,  -23.5230236,   34.7818184,   -4.5454545
  25383,  -24.4037781,   34.7818184,   -4.5454545
  25384,  -25.2845345,   34.7818184,   -4.5454545
  25385,  -26.1652889,   34.7818184,   -4.5454545
  25386,  -27.1239681,   34.7818184,   -4.5454545
  25387,  -28.0826454,   34.7818184,   -4.5454545
  25388,  -29.0413227,   34.7818184,   -4.5454545
  25389,  -20.8760338,   34.7454529,  -3.63636374
  25390,  -21.7520657,   34.7454529,  -3.63636374
  25391,  -22.6280994,   34.7454529,  -3.63636374
  25392,  -23.5041332,   34.7454529,  -3.63636374
  25393,  -24.3801651,   34.7454529,  -3.63636374
  25394,  -25.2561989,   34.7454529,  -3.63636374
  25395,  -26.1322308,   34.7454529,  -3.63636374
  25396,  -27.0991745,   34.7454529,  -3.63636374
  25397,  -28.0661163,   34.7454529,  -3.63636374
  25398,  -29.0330582,   34.7454529,  -3.63636374
  25399,  -20.8713112,   34.7090912,  -2.72727275
  25400,  -21.7426205,   34.7090912,  -2.72727275
  25401,  -22.6139317,   34.7090912,  -2.72727275
  25402,  -23.4852428,   34.7090912,  -2.72727275
  25403,  -24.3565521,   34.7090912,  -2.72727275
  25404,  -25.2278633,   34.7090912,  -2.72727275
  25405,  -26.0991726,   34.7090912,  -2.72727275
  25406,  -27.0743809,   34.7090912,  -2.72727275
  25407,  -28.0495872,   34.7090912,  -2.72727275
  25408,  -29.0247936,   34.7090912,  -2.72727275
  25409,  -20.8665886,   34.6727257,  -1.81818187
  25410,  -21.7331753,   34.6727257,  -1.81818187
  25411,  -22.5997639,   34.6727257,  -1.81818187
  25412,  -23.4663525,   34.6727257,  -1.81818187
  25413,  -24.3329411,   34.6727257,  -1.81818187
  25414,  -25.1995277,   34.6727257,  -1.81818187
  25415,  -26.0661163,   34.6727257,  -1.81818187
  25416,  -27.0495872,   34.6727257,  -1.81818187
  25417,  -28.0330582,   34.6727257,  -1.81818187
  25418,  -29.0165291,   34.6727257,  -1.81818187
  25419,   -20.861866,    34.636364, -0.909090936
  25420,  -21.7237301,    34.636364, -0.909090936
  25421,  -22.5855961,    34.636364, -0.909090936
  25422,  -23.4474621,    34.636364, -0.909090936
  25423,  -24.3093281,    34.636364, -0.909090936
  25424,  -25.1711922,    34.636364, -0.909090936
  25425,  -26.0330582,    34.636364, -0.909090936
  25426,  -27.0247936,    34.636364, -0.909090936
  25427,  -28.0165291,    34.636364, -0.909090936
  25428,  -29.0082645,    34.636364, -0.909090936
  25429,  -20.9043674,   35.7540665,    -9.090909
  25430,  -21.8087368,   35.7540665,    -9.090909
  25431,  -22.7131042,   35.7540665,    -9.090909
  25432,  -23.6174736,   35.7540665,    -9.090909
  25433,   -24.521841,   35.7540665,    -9.090909
  25434,  -25.4262104,   35.7540665,    -9.090909
  25435,  -26.3305779,   35.7540665,    -9.090909
  25436,  -27.2479343,   35.7540665,    -9.090909
  25437,  -28.1652889,   35.7540665,    -9.090909
  25438,  -29.0826454,   35.7540665,    -9.090909
  25439,  -20.8996449,   35.7186584,  -8.18181801
  25440,  -21.7992916,   35.7186584,  -8.18181801
  25441,  -22.6989365,   35.7186584,  -8.18181801
  25442,  -23.5985832,   35.7186584,  -8.18181801
  25443,  -24.4982281,   35.7186584,  -8.18181801
  25444,  -25.3978748,   35.7186584,  -8.18181801
  25445,  -26.2975197,   35.7186584,  -8.18181801
  25446,  -27.2231407,   35.7186584,  -8.18181801
  25447,  -28.1487598,   35.7186584,  -8.18181801
  25448,  -29.0743809,   35.7186584,  -8.18181801
  25449,  -20.8949223,   35.6832542,  -7.27272749
  25450,  -21.7898464,   35.6832542,  -7.27272749
  25451,  -22.6847687,   35.6832542,  -7.27272749
  25452,  -23.5796928,   35.6832542,  -7.27272749
  25453,   -24.474617,   35.6832542,  -7.27272749
  25454,  -25.3695393,   35.6832542,  -7.27272749
  25455,  -26.2644634,   35.6832542,  -7.27272749
  25456,  -27.1983471,   35.6832542,  -7.27272749
  25457,  -28.1322308,   35.6832542,  -7.27272749
  25458,  -29.0661163,   35.6832542,  -7.27272749
  25459,  -20.8901997,   35.6478462,  -6.36363649
  25460,  -21.7804012,   35.6478462,  -6.36363649
  25461,  -22.6706009,   35.6478462,  -6.36363649
  25462,  -23.5608025,   35.6478462,  -6.36363649
  25463,   -24.451004,   35.6478462,  -6.36363649
  25464,  -25.3412037,   35.6478462,  -6.36363649
  25465,  -26.2314053,   35.6478462,  -6.36363649
  25466,  -27.1735535,   35.6478462,  -6.36363649
  25467,  -28.1157017,   35.6478462,  -6.36363649
  25468,  -29.0578518,   35.6478462,  -6.36363649
  25469,  -20.8854771,    35.612442,   -5.4545455
  25470,   -21.770956,    35.612442,   -5.4545455
  25471,  -22.6564331,    35.612442,   -5.4545455
  25472,  -23.5419121,    35.612442,   -5.4545455
  25473,  -24.4273911,    35.612442,   -5.4545455
  25474,  -25.3128681,    35.612442,   -5.4545455
  25475,  -26.1983471,    35.612442,   -5.4545455
  25476,  -27.1487598,    35.612442,   -5.4545455
  25477,  -28.0991726,    35.612442,   -5.4545455
  25478,  -29.0495872,    35.612442,   -5.4545455
  25479,  -20.8807564,    35.577034,   -4.5454545
  25480,  -21.7615108,    35.577034,   -4.5454545
  25481,  -22.6422672,    35.577034,   -4.5454545
  25482,  -23.5230236,    35.577034,   -4.5454545
  25483,  -24.4037781,    35.577034,   -4.5454545
  25484,  -25.2845345,    35.577034,   -4.5454545
  25485,  -26.1652889,    35.577034,   -4.5454545
  25486,  -27.1239681,    35.577034,   -4.5454545
  25487,  -28.0826454,    35.577034,   -4.5454545
  25488,  -29.0413227,    35.577034,   -4.5454545
  25489,  -20.8760338,    35.541626,  -3.63636374
  25490,  -21.7520657,    35.541626,  -3.63636374
  25491,  -22.6280994,    35.541626,  -3.63636374
  25492,  -23.5041332,    35.541626,  -3.63636374
  25493,  -24.3801651,    35.541626,  -3.63636374
  25494,  -25.2561989,    35.541626,  -3.63636374
  25495,  -26.1322308,    35.541626,  -3.63636374
  25496,  -27.0991745,    35.541626,  -3.63636374
  25497,  -28.0661163,    35.541626,  -3.63636374
  25498,  -29.0330582,    35.541626,  -3.63636374
  25499,  -20.8713112,   35.5062218,  -2.72727275
  25500,  -21.7426205,   35.5062218,  -2.72727275
  25501,  -22.6139317,   35.5062218,  -2.72727275
  25502,  -23.4852428,   35.5062218,  -2.72727275
  25503,  -24.3565521,   35.5062218,  -2.72727275
  25504,  -25.2278633,   35.5062218,  -2.72727275
  25505,  -26.0991726,   35.5062218,  -2.72727275
  25506,  -27.0743809,   35.5062218,  -2.72727275
  25507,  -28.0495872,   35.5062218,  -2.72727275
  25508,  -29.0247936,   35.5062218,  -2.72727275
  25509,  -20.8665886,   35.4708138,  -1.81818187
  25510,  -21.7331753,   35.4708138,  -1.81818187
  25511,  -22.5997639,   35.4708138,  -1.81818187
  25512,  -23.4663525,   35.4708138,  -1.81818187
  25513,  -24.3329411,   35.4708138,  -1.81818187
  25514,  -25.1995277,   35.4708138,  -1.81818187
  25515,  -26.0661163,   35.4708138,  -1.81818187
  25516,  -27.0495872,   35.4708138,  -1.81818187
  25517,  -28.0330582,   35.4708138,  -1.81818187
  25518,  -29.0165291,   35.4708138,  -1.81818187
  25519,   -20.861866,   35.4354057, -0.909090936
  25520,  -21.7237301,   35.4354057, -0.909090936
  25521,  -22.5855961,   35.4354057, -0.909090936
  25522,  -23.4474621,   35.4354057, -0.909090936
  25523,  -24.3093281,   35.4354057, -0.909090936
  25524,  -25.1711922,   35.4354057, -0.909090936
  25525,  -26.0330582,   35.4354057, -0.909090936
  25526,  -27.0247936,   35.4354057, -0.909090936
  25527,  -28.0165291,   35.4354057, -0.909090936
  25528,  -29.0082645,   35.4354057, -0.909090936
  25529,  -20.9043674,   36.5444984,    -9.090909
  25530,  -21.8087368,   36.5444984,    -9.090909
  25531,  -22.7131042,   36.5444984,    -9.090909
  25532,  -23.6174736,   36.5444984,    -9.090909
  25533,   -24.521841,   36.5444984,    -9.090909
  25534,  -25.4262104,   36.5444984,    -9.090909
  25535,  -26.3305779,   36.5444984,    -9.090909
  25536,  -27.2479343,   36.5444984,    -9.090909
  25537,  -28.1652889,   36.5444984,    -9.090909
  25538,  -29.0826454,   36.5444984,    -9.090909
  25539,  -20.8996449,   36.5100479,  -8.18181801
  25540,  -21.7992916,   36.5100479,  -8.18181801
  25541,  -22.6989365,   36.5100479,  -8.18181801
  25542,  -23.5985832,   36.5100479,  -8.18181801
  25543,  -24.4982281,   36.5100479,  -8.18181801
  25544,  -25.3978748,   36.5100479,  -8.18181801
  25545,  -26.2975197,   36.5100479,  -8.18181801
  25546,  -27.2231407,   36.5100479,  -8.18181801
  25547,  -28.1487598,   36.5100479,  -8.18181801
  25548,  -29.0743809,   36.5100479,  -8.18181801
  25549,  -20.8949223,   36.4755974,  -7.27272749
  25550,  -21.7898464,   36.4755974,  -7.27272749
  25551,  -22.6847687,   36.4755974,  -7.27272749
  25552,  -23.5796928,   36.4755974,  -7.27272749
  25553,   -24.474617,   36.4755974,  -7.27272749
  25554,  -25.3695393,   36.4755974,  -7.27272749
  25555,  -26.2644634,   36.4755974,  -7.27272749
  25556,  -27.1983471,   36.4755974,  -7.27272749
  25557,  -28.1322308,   36.4755974,  -7.27272749
  25558,  -29.0661163,   36.4755974,  -7.27272749
  25559,  -20.8901997,   36.4411469,  -6.36363649
  25560,  -21.7804012,   36.4411469,  -6.36363649
  25561,  -22.6706009,   36.4411469,  -6.36363649
  25562,  -23.5608025,   36.4411469,  -6.36363649
  25563,   -24.451004,   36.4411469,  -6.36363649
  25564,  -25.3412037,   36.4411469,  -6.36363649
  25565,  -26.2314053,   36.4411469,  -6.36363649
  25566,  -27.1735535,   36.4411469,  -6.36363649
  25567,  -28.1157017,   36.4411469,  -6.36363649
  25568,  -29.0578518,   36.4411469,  -6.36363649
  25569,  -20.8854771,   36.4067001,   -5.4545455
  25570,   -21.770956,   36.4067001,   -5.4545455
  25571,  -22.6564331,   36.4067001,   -5.4545455
  25572,  -23.5419121,   36.4067001,   -5.4545455
  25573,  -24.4273911,   36.4067001,   -5.4545455
  25574,  -25.3128681,   36.4067001,   -5.4545455
  25575,  -26.1983471,   36.4067001,   -5.4545455
  25576,  -27.1487598,   36.4067001,   -5.4545455
  25577,  -28.0991726,   36.4067001,   -5.4545455
  25578,  -29.0495872,   36.4067001,   -5.4545455
  25579,  -20.8807564,   36.3722496,   -4.5454545
  25580,  -21.7615108,   36.3722496,   -4.5454545
  25581,  -22.6422672,   36.3722496,   -4.5454545
  25582,  -23.5230236,   36.3722496,   -4.5454545
  25583,  -24.4037781,   36.3722496,   -4.5454545
  25584,  -25.2845345,   36.3722496,   -4.5454545
  25585,  -26.1652889,   36.3722496,   -4.5454545
  25586,  -27.1239681,   36.3722496,   -4.5454545
  25587,  -28.0826454,   36.3722496,   -4.5454545
  25588,  -29.0413227,   36.3722496,   -4.5454545
  25589,  -20.8760338,   36.3377991,  -3.63636374
  25590,  -21.7520657,   36.3377991,  -3.63636374
  25591,  -22.6280994,   36.3377991,  -3.63636374
  25592,  -23.5041332,   36.3377991,  -3.63636374
  25593,  -24.3801651,   36.3377991,  -3.63636374
  25594,  -25.2561989,   36.3377991,  -3.63636374
  25595,  -26.1322308,   36.3377991,  -3.63636374
  25596,  -27.0991745,   36.3377991,  -3.63636374
  25597,  -28.0661163,   36.3377991,  -3.63636374
  25598,  -29.0330582,   36.3377991,  -3.63636374
  25599,  -20.8713112,   36.3033485,  -2.72727275
  25600,  -21.7426205,   36.3033485,  -2.72727275
  25601,  -22.6139317,   36.3033485,  -2.72727275
  25602,  -23.4852428,   36.3033485,  -2.72727275
  25603,  -24.3565521,   36.3033485,  -2.72727275
  25604,  -25.2278633,   36.3033485,  -2.72727275
  25605,  -26.0991726,   36.3033485,  -2.72727275
  25606,  -27.0743809,   36.3033485,  -2.72727275
  25607,  -28.0495872,   36.3033485,  -2.72727275
  25608,  -29.0247936,   36.3033485,  -2.72727275
  25609,  -20.8665886,    36.268898,  -1.81818187
  25610,  -21.7331753,    36.268898,  -1.81818187
  25611,  -22.5997639,    36.268898,  -1.81818187
  25612,  -23.4663525,    36.268898,  -1.81818187
  25613,  -24.3329411,    36.268898,  -1.81818187
  25614,  -25.1995277,    36.268898,  -1.81818187
  25615,  -26.0661163,    36.268898,  -1.81818187
  25616,  -27.0495872,    36.268898,  -1.81818187
  25617,  -28.0330582,    36.268898,  -1.81818187
  25618,  -29.0165291,    36.268898,  -1.81818187
  25619,   -20.861866,   36.2344513, -0.909090936
  25620,  -21.7237301,   36.2344513, -0.909090936
  25621,  -22.5855961,   36.2344513, -0.909090936
  25622,  -23.4474621,   36.2344513, -0.909090936
  25623,  -24.3093281,   36.2344513, -0.909090936
  25624,  -25.1711922,   36.2344513, -0.909090936
  25625,  -26.0330582,   36.2344513, -0.909090936
  25626,  -27.0247936,   36.2344513, -0.909090936
  25627,  -28.0165291,   36.2344513, -0.909090936
  25628,  -29.0082645,   36.2344513, -0.909090936
  25629,  -20.9043674,   37.3349266,    -9.090909
  25630,  -21.8087368,   37.3349266,    -9.090909
  25631,  -22.7131042,   37.3349266,    -9.090909
  25632,  -23.6174736,   37.3349266,    -9.090909
  25633,   -24.521841,   37.3349266,    -9.090909
  25634,  -25.4262104,   37.3349266,    -9.090909
  25635,  -26.3305779,   37.3349266,    -9.090909
  25636,  -27.2479343,   37.3349266,    -9.090909
  25637,  -28.1652889,   37.3349266,    -9.090909
  25638,  -29.0826454,   37.3349266,    -9.090909
  25639,  -20.8996449,   37.3014336,  -8.18181801
  25640,  -21.7992916,   37.3014336,  -8.18181801
  25641,  -22.6989365,   37.3014336,  -8.18181801
  25642,  -23.5985832,   37.3014336,  -8.18181801
  25643,  -24.4982281,   37.3014336,  -8.18181801
  25644,  -25.3978748,   37.3014336,  -8.18181801
  25645,  -26.2975197,   37.3014336,  -8.18181801
  25646,  -27.2231407,   37.3014336,  -8.18181801
  25647,  -28.1487598,   37.3014336,  -8.18181801
  25648,  -29.0743809,   37.3014336,  -8.18181801
  25649,  -20.8949223,   37.2679443,  -7.27272749
  25650,  -21.7898464,   37.2679443,  -7.27272749
  25651,  -22.6847687,   37.2679443,  -7.27272749
  25652,  -23.5796928,   37.2679443,  -7.27272749
  25653,   -24.474617,   37.2679443,  -7.27272749
  25654,  -25.3695393,   37.2679443,  -7.27272749
  25655,  -26.2644634,   37.2679443,  -7.27272749
  25656,  -27.1983471,   37.2679443,  -7.27272749
  25657,  -28.1322308,   37.2679443,  -7.27272749
  25658,  -29.0661163,   37.2679443,  -7.27272749
  25659,  -20.8901997,   37.2344513,  -6.36363649
  25660,  -21.7804012,   37.2344513,  -6.36363649
  25661,  -22.6706009,   37.2344513,  -6.36363649
  25662,  -23.5608025,   37.2344513,  -6.36363649
  25663,   -24.451004,   37.2344513,  -6.36363649
  25664,  -25.3412037,   37.2344513,  -6.36363649
  25665,  -26.2314053,   37.2344513,  -6.36363649
  25666,  -27.1735535,   37.2344513,  -6.36363649
  25667,  -28.1157017,   37.2344513,  -6.36363649
  25668,  -29.0578518,   37.2344513,  -6.36363649
  25669,  -20.8854771,   37.2009583,   -5.4545455
  25670,   -21.770956,   37.2009583,   -5.4545455
  25671,  -22.6564331,   37.2009583,   -5.4545455
  25672,  -23.5419121,   37.2009583,   -5.4545455
  25673,  -24.4273911,   37.2009583,   -5.4545455
  25674,  -25.3128681,   37.2009583,   -5.4545455
  25675,  -26.1983471,   37.2009583,   -5.4545455
  25676,  -27.1487598,   37.2009583,   -5.4545455
  25677,  -28.0991726,   37.2009583,   -5.4545455
  25678,  -29.0495872,   37.2009583,   -5.4545455
  25679,  -20.8807564,   37.1674652,   -4.5454545
  25680,  -21.7615108,   37.1674652,   -4.5454545
  25681,  -22.6422672,   37.1674652,   -4.5454545
  25682,  -23.5230236,   37.1674652,   -4.5454545
  25683,  -24.4037781,   37.1674652,   -4.5454545
  25684,  -25.2845345,   37.1674652,   -4.5454545
  25685,  -26.1652889,   37.1674652,   -4.5454545
  25686,  -27.1239681,   37.1674652,   -4.5454545
  25687,  -28.0826454,   37.1674652,   -4.5454545
  25688,  -29.0413227,   37.1674652,   -4.5454545
  25689,  -20.8760338,   37.1339722,  -3.63636374
  25690,  -21.7520657,   37.1339722,  -3.63636374
  25691,  -22.6280994,   37.1339722,  -3.63636374
  25692,  -23.5041332,   37.1339722,  -3.63636374
  25693,  -24.3801651,   37.1339722,  -3.63636374
  25694,  -25.2561989,   37.1339722,  -3.63636374
  25695,  -26.1322308,   37.1339722,  -3.63636374
  25696,  -27.0991745,   37.1339722,  -3.63636374
  25697,  -28.0661163,   37.1339722,  -3.63636374
  25698,  -29.0330582,   37.1339722,  -3.63636374
  25699,  -20.8713112,   37.1004791,  -2.72727275
  25700,  -21.7426205,   37.1004791,  -2.72727275
  25701,  -22.6139317,   37.1004791,  -2.72727275
  25702,  -23.4852428,   37.1004791,  -2.72727275
  25703,  -24.3565521,   37.1004791,  -2.72727275
  25704,  -25.2278633,   37.1004791,  -2.72727275
  25705,  -26.0991726,   37.1004791,  -2.72727275
  25706,  -27.0743809,   37.1004791,  -2.72727275
  25707,  -28.0495872,   37.1004791,  -2.72727275
  25708,  -29.0247936,   37.1004791,  -2.72727275
  25709,  -20.8665886,   37.0669861,  -1.81818187
  25710,  -21.7331753,   37.0669861,  -1.81818187
  25711,  -22.5997639,   37.0669861,  -1.81818187
  25712,  -23.4663525,   37.0669861,  -1.81818187
  25713,  -24.3329411,   37.0669861,  -1.81818187
  25714,  -25.1995277,   37.0669861,  -1.81818187
  25715,  -26.0661163,   37.0669861,  -1.81818187
  25716,  -27.0495872,   37.0669861,  -1.81818187
  25717,  -28.0330582,   37.0669861,  -1.81818187
  25718,  -29.0165291,   37.0669861,  -1.81818187
  25719,   -20.861866,    37.033493, -0.909090936
  25720,  -21.7237301,    37.033493, -0.909090936
  25721,  -22.5855961,    37.033493, -0.909090936
  25722,  -23.4474621,    37.033493, -0.909090936
  25723,  -24.3093281,    37.033493, -0.909090936
  25724,  -25.1711922,    37.033493, -0.909090936
  25725,  -26.0330582,    37.033493, -0.909090936
  25726,  -27.0247936,    37.033493, -0.909090936
  25727,  -28.0165291,    37.033493, -0.909090936
  25728,  -29.0082645,    37.033493, -0.909090936
  25729,  -20.9043674,   38.1253586,    -9.090909
  25730,  -21.8087368,   38.1253586,    -9.090909
  25731,  -22.7131042,   38.1253586,    -9.090909
  25732,  -23.6174736,   38.1253586,    -9.090909
  25733,   -24.521841,   38.1253586,    -9.090909
  25734,  -25.4262104,   38.1253586,    -9.090909
  25735,  -26.3305779,   38.1253586,    -9.090909
  25736,  -27.2479343,   38.1253586,    -9.090909
  25737,  -28.1652889,   38.1253586,    -9.090909
  25738,  -29.0826454,   38.1253586,    -9.090909
  25739,  -20.8996449,    38.092823,  -8.18181801
  25740,  -21.7992916,    38.092823,  -8.18181801
  25741,  -22.6989365,    38.092823,  -8.18181801
  25742,  -23.5985832,    38.092823,  -8.18181801
  25743,  -24.4982281,    38.092823,  -8.18181801
  25744,  -25.3978748,    38.092823,  -8.18181801
  25745,  -26.2975197,    38.092823,  -8.18181801
  25746,  -27.2231407,    38.092823,  -8.18181801
  25747,  -28.1487598,    38.092823,  -8.18181801
  25748,  -29.0743809,    38.092823,  -8.18181801
  25749,  -20.8949223,   38.0602875,  -7.27272749
  25750,  -21.7898464,   38.0602875,  -7.27272749
  25751,  -22.6847687,   38.0602875,  -7.27272749
  25752,  -23.5796928,   38.0602875,  -7.27272749
  25753,   -24.474617,   38.0602875,  -7.27272749
  25754,  -25.3695393,   38.0602875,  -7.27272749
  25755,  -26.2644634,   38.0602875,  -7.27272749
  25756,  -27.1983471,   38.0602875,  -7.27272749
  25757,  -28.1322308,   38.0602875,  -7.27272749
  25758,  -29.0661163,   38.0602875,  -7.27272749
  25759,  -20.8901997,   38.0277519,  -6.36363649
  25760,  -21.7804012,   38.0277519,  -6.36363649
  25761,  -22.6706009,   38.0277519,  -6.36363649
  25762,  -23.5608025,   38.0277519,  -6.36363649
  25763,   -24.451004,   38.0277519,  -6.36363649
  25764,  -25.3412037,   38.0277519,  -6.36363649
  25765,  -26.2314053,   38.0277519,  -6.36363649
  25766,  -27.1735535,   38.0277519,  -6.36363649
  25767,  -28.1157017,   38.0277519,  -6.36363649
  25768,  -29.0578518,   38.0277519,  -6.36363649
  25769,  -20.8854771,   37.9952164,   -5.4545455
  25770,   -21.770956,   37.9952164,   -5.4545455
  25771,  -22.6564331,   37.9952164,   -5.4545455
  25772,  -23.5419121,   37.9952164,   -5.4545455
  25773,  -24.4273911,   37.9952164,   -5.4545455
  25774,  -25.3128681,   37.9952164,   -5.4545455
  25775,  -26.1983471,   37.9952164,   -5.4545455
  25776,  -27.1487598,   37.9952164,   -5.4545455
  25777,  -28.0991726,   37.9952164,   -5.4545455
  25778,  -29.0495872,   37.9952164,   -5.4545455
  25779,  -20.8807564,   37.9626808,   -4.5454545
  25780,  -21.7615108,   37.9626808,   -4.5454545
  25781,  -22.6422672,   37.9626808,   -4.5454545
  25782,  -23.5230236,   37.9626808,   -4.5454545
  25783,  -24.4037781,   37.9626808,   -4.5454545
  25784,  -25.2845345,   37.9626808,   -4.5454545
  25785,  -26.1652889,   37.9626808,   -4.5454545
  25786,  -27.1239681,   37.9626808,   -4.5454545
  25787,  -28.0826454,   37.9626808,   -4.5454545
  25788,  -29.0413227,   37.9626808,   -4.5454545
  25789,  -20.8760338,   37.9301453,  -3.63636374
  25790,  -21.7520657,   37.9301453,  -3.63636374
  25791,  -22.6280994,   37.9301453,  -3.63636374
  25792,  -23.5041332,   37.9301453,  -3.63636374
  25793,  -24.3801651,   37.9301453,  -3.63636374
  25794,  -25.2561989,   37.9301453,  -3.63636374
  25795,  -26.1322308,   37.9301453,  -3.63636374
  25796,  -27.0991745,   37.9301453,  -3.63636374
  25797,  -28.0661163,   37.9301453,  -3.63636374
  25798,  -29.0330582,   37.9301453,  -3.63636374
  25799,  -20.8713112,   37.8976059,  -2.72727275
  25800,  -21.7426205,   37.8976059,  -2.72727275
  25801,  -22.6139317,   37.8976059,  -2.72727275
  25802,  -23.4852428,   37.8976059,  -2.72727275
  25803,  -24.3565521,   37.8976059,  -2.72727275
  25804,  -25.2278633,   37.8976059,  -2.72727275
  25805,  -26.0991726,   37.8976059,  -2.72727275
  25806,  -27.0743809,   37.8976059,  -2.72727275
  25807,  -28.0495872,   37.8976059,  -2.72727275
  25808,  -29.0247936,   37.8976059,  -2.72727275
  25809,  -20.8665886,   37.8650703,  -1.81818187
  25810,  -21.7331753,   37.8650703,  -1.81818187
  25811,  -22.5997639,   37.8650703,  -1.81818187
  25812,  -23.4663525,   37.8650703,  -1.81818187
  25813,  -24.3329411,   37.8650703,  -1.81818187
  25814,  -25.1995277,   37.8650703,  -1.81818187
  25815,  -26.0661163,   37.8650703,  -1.81818187
  25816,  -27.0495872,   37.8650703,  -1.81818187
  25817,  -28.0330582,   37.8650703,  -1.81818187
  25818,  -29.0165291,   37.8650703,  -1.81818187
  25819,   -20.861866,   37.8325348, -0.909090936
  25820,  -21.7237301,   37.8325348, -0.909090936
  25821,  -22.5855961,   37.8325348, -0.909090936
  25822,  -23.4474621,   37.8325348, -0.909090936
  25823,  -24.3093281,   37.8325348, -0.909090936
  25824,  -25.1711922,   37.8325348, -0.909090936
  25825,  -26.0330582,   37.8325348, -0.909090936
  25826,  -27.0247936,   37.8325348, -0.909090936
  25827,  -28.0165291,   37.8325348, -0.909090936
  25828,  -29.0082645,   37.8325348, -0.909090936
  25829,  -20.9043674,   38.9157906,    -9.090909
  25830,  -21.8087368,   38.9157906,    -9.090909
  25831,  -22.7131042,   38.9157906,    -9.090909
  25832,  -23.6174736,   38.9157906,    -9.090909
  25833,   -24.521841,   38.9157906,    -9.090909
  25834,  -25.4262104,   38.9157906,    -9.090909
  25835,  -26.3305779,   38.9157906,    -9.090909
  25836,  -27.2479343,   38.9157906,    -9.090909
  25837,  -28.1652889,   38.9157906,    -9.090909
  25838,  -29.0826454,   38.9157906,    -9.090909
  25839,  -20.8996449,   38.8842087,  -8.18181801
  25840,  -21.7992916,   38.8842087,  -8.18181801
  25841,  -22.6989365,   38.8842087,  -8.18181801
  25842,  -23.5985832,   38.8842087,  -8.18181801
  25843,  -24.4982281,   38.8842087,  -8.18181801
  25844,  -25.3978748,   38.8842087,  -8.18181801
  25845,  -26.2975197,   38.8842087,  -8.18181801
  25846,  -27.2231407,   38.8842087,  -8.18181801
  25847,  -28.1487598,   38.8842087,  -8.18181801
  25848,  -29.0743809,   38.8842087,  -8.18181801
  25849,  -20.8949223,   38.8526306,  -7.27272749
  25850,  -21.7898464,   38.8526306,  -7.27272749
  25851,  -22.6847687,   38.8526306,  -7.27272749
  25852,  -23.5796928,   38.8526306,  -7.27272749
  25853,   -24.474617,   38.8526306,  -7.27272749
  25854,  -25.3695393,   38.8526306,  -7.27272749
  25855,  -26.2644634,   38.8526306,  -7.27272749
  25856,  -27.1983471,   38.8526306,  -7.27272749
  25857,  -28.1322308,   38.8526306,  -7.27272749
  25858,  -29.0661163,   38.8526306,  -7.27272749
  25859,  -20.8901997,   38.8210526,  -6.36363649
  25860,  -21.7804012,   38.8210526,  -6.36363649
  25861,  -22.6706009,   38.8210526,  -6.36363649
  25862,  -23.5608025,   38.8210526,  -6.36363649
  25863,   -24.451004,   38.8210526,  -6.36363649
  25864,  -25.3412037,   38.8210526,  -6.36363649
  25865,  -26.2314053,   38.8210526,  -6.36363649
  25866,  -27.1735535,   38.8210526,  -6.36363649
  25867,  -28.1157017,   38.8210526,  -6.36363649
  25868,  -29.0578518,   38.8210526,  -6.36363649
  25869,  -20.8854771,   38.7894745,   -5.4545455
  25870,   -21.770956,   38.7894745,   -5.4545455
  25871,  -22.6564331,   38.7894745,   -5.4545455
  25872,  -23.5419121,   38.7894745,   -5.4545455
  25873,  -24.4273911,   38.7894745,   -5.4545455
  25874,  -25.3128681,   38.7894745,   -5.4545455
  25875,  -26.1983471,   38.7894745,   -5.4545455
  25876,  -27.1487598,   38.7894745,   -5.4545455
  25877,  -28.0991726,   38.7894745,   -5.4545455
  25878,  -29.0495872,   38.7894745,   -5.4545455
  25879,  -20.8807564,   38.7578964,   -4.5454545
  25880,  -21.7615108,   38.7578964,   -4.5454545
  25881,  -22.6422672,   38.7578964,   -4.5454545
  25882,  -23.5230236,   38.7578964,   -4.5454545
  25883,  -24.4037781,   38.7578964,   -4.5454545
  25884,  -25.2845345,   38.7578964,   -4.5454545
  25885,  -26.1652889,   38.7578964,   -4.5454545
  25886,  -27.1239681,   38.7578964,   -4.5454545
  25887,  -28.0826454,   38.7578964,   -4.5454545
  25888,  -29.0413227,   38.7578964,   -4.5454545
  25889,  -20.8760338,   38.7263145,  -3.63636374
  25890,  -21.7520657,   38.7263145,  -3.63636374
  25891,  -22.6280994,   38.7263145,  -3.63636374
  25892,  -23.5041332,   38.7263145,  -3.63636374
  25893,  -24.3801651,   38.7263145,  -3.63636374
  25894,  -25.2561989,   38.7263145,  -3.63636374
  25895,  -26.1322308,   38.7263145,  -3.63636374
  25896,  -27.0991745,   38.7263145,  -3.63636374
  25897,  -28.0661163,   38.7263145,  -3.63636374
  25898,  -29.0330582,   38.7263145,  -3.63636374
  25899,  -20.8713112,   38.6947365,  -2.72727275
  25900,  -21.7426205,   38.6947365,  -2.72727275
  25901,  -22.6139317,   38.6947365,  -2.72727275
  25902,  -23.4852428,   38.6947365,  -2.72727275
  25903,  -24.3565521,   38.6947365,  -2.72727275
  25904,  -25.2278633,   38.6947365,  -2.72727275
  25905,  -26.0991726,   38.6947365,  -2.72727275
  25906,  -27.0743809,   38.6947365,  -2.72727275
  25907,  -28.0495872,   38.6947365,  -2.72727275
  25908,  -29.0247936,   38.6947365,  -2.72727275
  25909,  -20.8665886,   38.6631584,  -1.81818187
  25910,  -21.7331753,   38.6631584,  -1.81818187
  25911,  -22.5997639,   38.6631584,  -1.81818187
  25912,  -23.4663525,   38.6631584,  -1.81818187
  25913,  -24.3329411,   38.6631584,  -1.81818187
  25914,  -25.1995277,   38.6631584,  -1.81818187
  25915,  -26.0661163,   38.6631584,  -1.81818187
  25916,  -27.0495872,   38.6631584,  -1.81818187
  25917,  -28.0330582,   38.6631584,  -1.81818187
  25918,  -29.0165291,   38.6631584,  -1.81818187
  25919,   -20.861866,   38.6315804, -0.909090936
  25920,  -21.7237301,   38.6315804, -0.909090936
  25921,  -22.5855961,   38.6315804, -0.909090936
  25922,  -23.4474621,   38.6315804, -0.909090936
  25923,  -24.3093281,   38.6315804, -0.909090936
  25924,  -25.1711922,   38.6315804, -0.909090936
  25925,  -26.0330582,   38.6315804, -0.909090936
  25926,  -27.0247936,   38.6315804, -0.909090936
  25927,  -28.0165291,   38.6315804, -0.909090936
  25928,  -29.0082645,   38.6315804, -0.909090936
  25929,  -20.9043674,   39.7062187,    -9.090909
  25930,  -21.8087368,   39.7062187,    -9.090909
  25931,  -22.7131042,   39.7062187,    -9.090909
  25932,  -23.6174736,   39.7062187,    -9.090909
  25933,   -24.521841,   39.7062187,    -9.090909
  25934,  -25.4262104,   39.7062187,    -9.090909
  25935,  -26.3305779,   39.7062187,    -9.090909
  25936,  -27.2479343,   39.7062187,    -9.090909
  25937,  -28.1652889,   39.7062187,    -9.090909
  25938,  -29.0826454,   39.7062187,    -9.090909
  25939,  -20.8996449,   39.6755981,  -8.18181801
  25940,  -21.7992916,   39.6755981,  -8.18181801
  25941,  -22.6989365,   39.6755981,  -8.18181801
  25942,  -23.5985832,   39.6755981,  -8.18181801
  25943,  -24.4982281,   39.6755981,  -8.18181801
  25944,  -25.3978748,   39.6755981,  -8.18181801
  25945,  -26.2975197,   39.6755981,  -8.18181801
  25946,  -27.2231407,   39.6755981,  -8.18181801
  25947,  -28.1487598,   39.6755981,  -8.18181801
  25948,  -29.0743809,   39.6755981,  -8.18181801
  25949,  -20.8949223,   39.6449776,  -7.27272749
  25950,  -21.7898464,   39.6449776,  -7.27272749
  25951,  -22.6847687,   39.6449776,  -7.27272749
  25952,  -23.5796928,   39.6449776,  -7.27272749
  25953,   -24.474617,   39.6449776,  -7.27272749
  25954,  -25.3695393,   39.6449776,  -7.27272749
  25955,  -26.2644634,   39.6449776,  -7.27272749
  25956,  -27.1983471,   39.6449776,  -7.27272749
  25957,  -28.1322308,   39.6449776,  -7.27272749
  25958,  -29.0661163,   39.6449776,  -7.27272749
  25959,  -20.8901997,   39.6143532,  -6.36363649
  25960,  -21.7804012,   39.6143532,  -6.36363649
  25961,  -22.6706009,   39.6143532,  -6.36363649
  25962,  -23.5608025,   39.6143532,  -6.36363649
  25963,   -24.451004,   39.6143532,  -6.36363649
  25964,  -25.3412037,   39.6143532,  -6.36363649
  25965,  -26.2314053,   39.6143532,  -6.36363649
  25966,  -27.1735535,   39.6143532,  -6.36363649
  25967,  -28.1157017,   39.6143532,  -6.36363649
  25968,  -29.0578518,   39.6143532,  -6.36363649
  25969,  -20.8854771,   39.5837326,   -5.4545455
  25970,   -21.770956,   39.5837326,   -5.4545455
  25971,  -22.6564331,   39.5837326,   -5.4545455
  25972,  -23.5419121,   39.5837326,   -5.4545455
  25973,  -24.4273911,   39.5837326,   -5.4545455
  25974,  -25.3128681,   39.5837326,   -5.4545455
  25975,  -26.1983471,   39.5837326,   -5.4545455
  25976,  -27.1487598,   39.5837326,   -5.4545455
  25977,  -28.0991726,   39.5837326,   -5.4545455
  25978,  -29.0495872,   39.5837326,   -5.4545455
  25979,  -20.8807564,   39.5531082,   -4.5454545
  25980,  -21.7615108,   39.5531082,   -4.5454545
  25981,  -22.6422672,   39.5531082,   -4.5454545
  25982,  -23.5230236,   39.5531082,   -4.5454545
  25983,  -24.4037781,   39.5531082,   -4.5454545
  25984,  -25.2845345,   39.5531082,   -4.5454545
  25985,  -26.1652889,   39.5531082,   -4.5454545
  25986,  -27.1239681,   39.5531082,   -4.5454545
  25987,  -28.0826454,   39.5531082,   -4.5454545
  25988,  -29.0413227,   39.5531082,   -4.5454545
  25989,  -20.8760338,   39.5224876,  -3.63636374
  25990,  -21.7520657,   39.5224876,  -3.63636374
  25991,  -22.6280994,   39.5224876,  -3.63636374
  25992,  -23.5041332,   39.5224876,  -3.63636374
  25993,  -24.3801651,   39.5224876,  -3.63636374
  25994,  -25.2561989,   39.5224876,  -3.63636374
