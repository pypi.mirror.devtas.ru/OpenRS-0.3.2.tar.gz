   5995,   1.28140438,   69.9589081,  -6.36363649
   5996,   1.28140438,   69.9589081,  -7.27272749
   5997,   1.28140438,   69.9589081,  -8.18181801
   5998,   1.28140438,   69.9589081,    -9.090909
   5999,  0.641031623,   69.9897232, -0.909090936
   6000,  0.641031623,   69.9897232,  -1.81818187
   6001,  0.641031623,   69.9897232,  -2.72727275
   6002,  0.641031623,   69.9897232,  -3.63636374
   6003,  0.641031623,   69.9897232,   -4.5454545
   6004,  0.641031623,   69.9897232,   -5.4545455
   6005,  0.641031623,   69.9897232,  -6.36363649
   6006,  0.641031623,   69.9897232,  -7.27272749
   6007,  0.641031623,   69.9897232,  -8.18181801
   6008,  0.641031623,   69.9897232,    -9.090909
   6009,           0.,          70., -0.909090936
   6010,           0.,          70.,  -1.81818187
   6011,           0.,          70.,  -2.72727275
   6012,           0.,          70.,  -3.63636374
   6013,           0.,          70.,   -4.5454545
   6014,           0.,          70.,   -5.4545455
   6015,           0.,          70.,  -6.36363649
   6016,           0.,          70.,  -7.27272749
   6017,           0.,          70.,  -8.18181801
   6018,           0.,          70.,    -9.090909
   6019, -0.641031623,   69.9897232, -0.909090936
   6020, -0.641031623,   69.9897232,  -1.81818187
   6021, -0.641031623,   69.9897232,  -2.72727275
   6022, -0.641031623,   69.9897232,  -3.63636374
   6023, -0.641031623,   69.9897232,   -4.5454545
   6024, -0.641031623,   69.9897232,   -5.4545455
   6025, -0.641031623,   69.9897232,  -6.36363649
   6026, -0.641031623,   69.9897232,  -7.27272749
   6027, -0.641031623,   69.9897232,  -8.18181801
   6028, -0.641031623,   69.9897232,    -9.090909
   6029,  -1.28140438,   69.9589081, -0.909090936
   6030,  -1.28140438,   69.9589081,  -1.81818187
   6031,  -1.28140438,   69.9589081,  -2.72727275
   6032,  -1.28140438,   69.9589081,  -3.63636374
   6033,  -1.28140438,   69.9589081,   -4.5454545
   6034,  -1.28140438,   69.9589081,   -5.4545455
   6035,  -1.28140438,   69.9589081,  -6.36363649
   6036,  -1.28140438,   69.9589081,  -7.27272749
   6037,  -1.28140438,   69.9589081,  -8.18181801
   6038,  -1.28140438,   69.9589081,    -9.090909
   6039,  -1.92046022,   69.9075851, -0.909090936
   6040,  -1.92046022,   69.9075851,  -1.81818187
   6041,  -1.92046022,   69.9075851,  -2.72727275
   6042,  -1.92046022,   69.9075851,  -3.63636374
   6043,  -1.92046022,   69.9075851,   -4.5454545
   6044,  -1.92046022,   69.9075851,   -5.4545455
   6045,  -1.92046022,   69.9075851,  -6.36363649
   6046,  -1.92046022,   69.9075851,  -7.27272749
   6047,  -1.92046022,   69.9075851,  -8.18181801
   6048,  -1.92046022,   69.9075851,    -9.090909
   6049,  -2.55754328,   69.8358002, -0.909090936
   6050,  -2.55754328,   69.8358002,  -1.81818187
   6051,  -2.55754328,   69.8358002,  -2.72727275
   6052,  -2.55754328,   69.8358002,  -3.63636374
   6053,  -2.55754328,   69.8358002,   -4.5454545
   6054,  -2.55754328,   69.8358002,   -5.4545455
   6055,  -2.55754328,   69.8358002,  -6.36363649
   6056,  -2.55754328,   69.8358002,  -7.27272749
   6057,  -2.55754328,   69.8358002,  -8.18181801
   6058,  -2.55754328,   69.8358002,    -9.090909
   6059,  -3.19199777,   69.7436371, -0.909090936
   6060,  -3.19199777,   69.7436371,  -1.81818187
   6061,  -3.19199777,   69.7436371,  -2.72727275
   6062,  -3.19199777,   69.7436371,  -3.63636374
   6063,  -3.19199777,   69.7436371,   -4.5454545
   6064,  -3.19199777,   69.7436371,   -5.4545455
   6065,  -3.19199777,   69.7436371,  -6.36363649
   6066,  -3.19199777,   69.7436371,  -7.27272749
   6067,  -3.19199777,   69.7436371,  -8.18181801
   6068,  -3.19199777,   69.7436371,    -9.090909
   6069,  -3.82317328,   69.6311798, -0.909090936
   6070,  -3.82317328,   69.6311798,  -1.81818187
   6071,  -3.82317328,   69.6311798,  -2.72727275
   6072,  -3.82317328,   69.6311798,  -3.63636374
   6073,  -3.82317328,   69.6311798,   -4.5454545
   6074,  -3.82317328,   69.6311798,   -5.4545455
   6075,  -3.82317328,   69.6311798,  -6.36363649
   6076,  -3.82317328,   69.6311798,  -7.27272749
   6077,  -3.82317328,   69.6311798,  -8.18181801
   6078,  -3.82317328,   69.6311798,    -9.090909
   6079,  -4.45041847,    69.498558, -0.909090936
   6080,  -4.45041847,    69.498558,  -1.81818187
   6081,  -4.45041847,    69.498558,  -2.72727275
   6082,  -4.45041847,    69.498558,  -3.63636374
   6083,  -4.45041847,    69.498558,   -4.5454545
   6084,  -4.45041847,    69.498558,   -5.4545455
   6085,  -4.45041847,    69.498558,  -6.36363649
   6086,  -4.45041847,    69.498558,  -7.27272749
   6087,  -4.45041847,    69.498558,  -8.18181801
   6088,  -4.45041847,    69.498558,    -9.090909
   6089,  -5.07309246,   69.3458939, -0.909090936
   6090,  -5.07309246,   69.3458939,  -1.81818187
   6091,  -5.07309246,   69.3458939,  -2.72727275
   6092,  -5.07309246,   69.3458939,  -3.63636374
   6093,  -5.07309246,   69.3458939,   -4.5454545
   6094,  -5.07309246,   69.3458939,   -5.4545455
   6095,  -5.07309246,   69.3458939,  -6.36363649
   6096,  -5.07309246,   69.3458939,  -7.27272749
   6097,  -5.07309246,   69.3458939,  -8.18181801
   6098,  -5.07309246,   69.3458939,    -9.090909
   6099,  -5.69055223,   69.1733551, -0.909090936
   6100,  -5.69055223,   69.1733551,  -1.81818187
   6101,  -5.69055223,   69.1733551,  -2.72727275
   6102,  -5.69055223,   69.1733551,  -3.63636374
   6103,  -5.69055223,   69.1733551,   -4.5454545
   6104,  -5.69055223,   69.1733551,   -5.4545455
   6105,  -5.69055223,   69.1733551,  -6.36363649
   6106,  -5.69055223,   69.1733551,  -7.27272749
   6107,  -5.69055223,   69.1733551,  -8.18181801
   6108,  -5.69055223,   69.1733551,    -9.090909
   6109,  -6.30216408,   68.9811172, -0.909090936
   6110,  -6.30216408,   68.9811172,  -1.81818187
   6111,  -6.30216408,   68.9811172,  -2.72727275
   6112,  -6.30216408,   68.9811172,  -3.63636374
   6113,  -6.30216408,   68.9811172,   -4.5454545
   6114,  -6.30216408,   68.9811172,   -5.4545455
   6115,  -6.30216408,   68.9811172,  -6.36363649
   6116,  -6.30216408,   68.9811172,  -7.27272749
   6117,  -6.30216408,   68.9811172,  -8.18181801
   6118,  -6.30216408,   68.9811172,    -9.090909
   6119,      -6.9073,    68.769371, -0.909090936
   6120,      -6.9073,    68.769371,  -1.81818187
   6121,      -6.9073,    68.769371,  -2.72727275
   6122,      -6.9073,    68.769371,  -3.63636374
   6123,      -6.9073,    68.769371,   -4.5454545
   6124,      -6.9073,    68.769371,   -5.4545455
   6125,      -6.9073,    68.769371,  -6.36363649
   6126,      -6.9073,    68.769371,  -7.27272749
   6127,      -6.9073,    68.769371,  -8.18181801
   6128,      -6.9073,    68.769371,    -9.090909
   6129,  -7.50533915,   68.5383377, -0.909090936
   6130,  -7.50533915,   68.5383377,  -1.81818187
   6131,  -7.50533915,   68.5383377,  -2.72727275
   6132,  -7.50533915,   68.5383377,  -3.63636374
   6133,  -7.50533915,   68.5383377,   -4.5454545
   6134,  -7.50533915,   68.5383377,   -5.4545455
   6135,  -7.50533915,   68.5383377,  -6.36363649
   6136,  -7.50533915,   68.5383377,  -7.27272749
   6137,  -7.50533915,   68.5383377,  -8.18181801
   6138,  -7.50533915,   68.5383377,    -9.090909
   6139,  -8.09566593,   68.2882538, -0.909090936
   6140,  -8.09566593,   68.2882538,  -1.81818187
   6141,  -8.09566593,   68.2882538,  -2.72727275
   6142,  -8.09566593,   68.2882538,  -3.63636374
   6143,  -8.09566593,   68.2882538,   -4.5454545
   6144,  -8.09566593,   68.2882538,   -5.4545455
   6145,  -8.09566593,   68.2882538,  -6.36363649
   6146,  -8.09566593,   68.2882538,  -7.27272749
   6147,  -8.09566593,   68.2882538,  -8.18181801
   6148,  -8.09566593,   68.2882538,    -9.090909
   6149,  -8.67767429,   68.0193787, -0.909090936
   6150,  -8.67767429,   68.0193787,  -1.81818187
   6151,  -8.67767429,   68.0193787,  -2.72727275
   6152,  -8.67767429,   68.0193787,  -3.63636374
   6153,  -8.67767429,   68.0193787,   -4.5454545
   6154,  -8.67767429,   68.0193787,   -5.4545455
   6155,  -8.67767429,   68.0193787,  -6.36363649
   6156,  -8.67767429,   68.0193787,  -7.27272749
   6157,  -8.67767429,   68.0193787,  -8.18181801
   6158,  -8.67767429,   68.0193787,    -9.090909
   6159,   -9.2507658,    67.731987, -0.909090936
   6160,   -9.2507658,    67.731987,  -1.81818187
   6161,   -9.2507658,    67.731987,  -2.72727275
   6162,   -9.2507658,    67.731987,  -3.63636374
   6163,   -9.2507658,    67.731987,   -4.5454545
   6164,   -9.2507658,    67.731987,   -5.4545455
   6165,   -9.2507658,    67.731987,  -6.36363649
   6166,   -9.2507658,    67.731987,  -7.27272749
   6167,   -9.2507658,    67.731987,  -8.18181801
   6168,   -9.2507658,    67.731987,    -9.090909
   6169,  -9.81435013,   67.4263763, -0.909090936
   6170,  -9.81435013,   67.4263763,  -1.81818187
   6171,  -9.81435013,   67.4263763,  -2.72727275
   6172,  -9.81435013,   67.4263763,  -3.63636374
   6173,  -9.81435013,   67.4263763,   -4.5454545
   6174,  -9.81435013,   67.4263763,   -5.4545455
   6175,  -9.81435013,   67.4263763,  -6.36363649
   6176,  -9.81435013,   67.4263763,  -7.27272749
   6177,  -9.81435013,   67.4263763,  -8.18181801
   6178,  -9.81435013,   67.4263763,    -9.090909
   6179,  -10.3678532,   67.1028519, -0.909090936
   6180,  -10.3678532,   67.1028519,  -1.81818187
   6181,  -10.3678532,   67.1028519,  -2.72727275
   6182,  -10.3678532,   67.1028519,  -3.63636374
   6183,  -10.3678532,   67.1028519,   -4.5454545
   6184,  -10.3678532,   67.1028519,   -5.4545455
   6185,  -10.3678532,   67.1028519,  -6.36363649
   6186,  -10.3678532,   67.1028519,  -7.27272749
   6187,  -10.3678532,   67.1028519,  -8.18181801
   6188,  -10.3678532,   67.1028519,    -9.090909
   6189,   -10.910697,   66.7617645, -0.909090936
   6190,   -10.910697,   66.7617645,  -1.81818187
   6191,   -10.910697,   66.7617645,  -2.72727275
   6192,   -10.910697,   66.7617645,  -3.63636374
   6193,   -10.910697,   66.7617645,   -4.5454545
   6194,   -10.910697,   66.7617645,   -5.4545455
   6195,   -10.910697,   66.7617645,  -6.36363649
   6196,   -10.910697,   66.7617645,  -7.27272749
   6197,   -10.910697,   66.7617645,  -8.18181801
   6198,   -10.910697,   66.7617645,    -9.090909
   6199,  -11.4423342,   66.4034424, -0.909090936
   6200,  -11.4423342,   66.4034424,  -1.81818187
   6201,  -11.4423342,   66.4034424,  -2.72727275
   6202,  -11.4423342,   66.4034424,  -3.63636374
   6203,  -11.4423342,   66.4034424,   -4.5454545
   6204,  -11.4423342,   66.4034424,   -5.4545455
   6205,  -11.4423342,   66.4034424,  -6.36363649
   6206,  -11.4423342,   66.4034424,  -7.27272749
   6207,  -11.4423342,   66.4034424,  -8.18181801
   6208,  -11.4423342,   66.4034424,    -9.090909
   6209,  -11.9622097,   66.0282745, -0.909090936
   6210,  -11.9622097,   66.0282745,  -1.81818187
   6211,  -11.9622097,   66.0282745,  -2.72727275
   6212,  -11.9622097,   66.0282745,  -3.63636374
   6213,  -11.9622097,   66.0282745,   -4.5454545
   6214,  -11.9622097,   66.0282745,   -5.4545455
   6215,  -11.9622097,   66.0282745,  -6.36363649
   6216,  -11.9622097,   66.0282745,  -7.27272749
   6217,  -11.9622097,   66.0282745,  -8.18181801
   6218,  -11.9622097,   66.0282745,    -9.090909
   6219,  -12.4697971,   65.6366272, -0.909090936
   6220,  -12.4697971,   65.6366272,  -1.81818187
   6221,  -12.4697971,   65.6366272,  -2.72727275
   6222,  -12.4697971,   65.6366272,  -3.63636374
   6223,  -12.4697971,   65.6366272,   -4.5454545
   6224,  -12.4697971,   65.6366272,   -5.4545455
   6225,  -12.4697971,   65.6366272,  -6.36363649
   6226,  -12.4697971,   65.6366272,  -7.27272749
   6227,  -12.4697971,   65.6366272,  -8.18181801
   6228,  -12.4697971,   65.6366272,    -9.090909
   6229,  -12.9645672,     65.22892, -0.909090936
   6230,  -12.9645672,     65.22892,  -1.81818187
   6231,  -12.9645672,     65.22892,  -2.72727275
   6232,  -12.9645672,     65.22892,  -3.63636374
   6233,  -12.9645672,     65.22892,   -4.5454545
   6234,  -12.9645672,     65.22892,   -5.4545455
   6235,  -12.9645672,     65.22892,  -6.36363649
   6236,  -12.9645672,     65.22892,  -7.27272749
   6237,  -12.9645672,     65.22892,  -8.18181801
   6238,  -12.9645672,     65.22892,    -9.090909
   6239,  -13.4460192,   64.8055573, -0.909090936
   6240,  -13.4460192,   64.8055573,  -1.81818187
   6241,  -13.4460192,   64.8055573,  -2.72727275
   6242,  -13.4460192,   64.8055573,  -3.63636374
   6243,  -13.4460192,   64.8055573,   -4.5454545
   6244,  -13.4460192,   64.8055573,   -5.4545455
   6245,  -13.4460192,   64.8055573,  -6.36363649
   6246,  -13.4460192,   64.8055573,  -7.27272749
   6247,  -13.4460192,   64.8055573,  -8.18181801
   6248,  -13.4460192,   64.8055573,    -9.090909
   6249,  -13.9136505,   64.3669891, -0.909090936
   6250,  -13.9136505,   64.3669891,  -1.81818187
   6251,  -13.9136505,   64.3669891,  -2.72727275
   6252,  -13.9136505,   64.3669891,  -3.63636374
   6253,  -13.9136505,   64.3669891,   -4.5454545
   6254,  -13.9136505,   64.3669891,   -5.4545455
   6255,  -13.9136505,   64.3669891,  -6.36363649
   6256,  -13.9136505,   64.3669891,  -7.27272749
   6257,  -13.9136505,   64.3669891,  -8.18181801
   6258,  -13.9136505,   64.3669891,    -9.090909
   6259,  -14.3669872,   63.9136505, -0.909090936
   6260,  -14.3669872,   63.9136505,  -1.81818187
   6261,  -14.3669872,   63.9136505,  -2.72727275
   6262,  -14.3669872,   63.9136505,  -3.63636374
   6263,  -14.3669872,   63.9136505,   -4.5454545
   6264,  -14.3669872,   63.9136505,   -5.4545455
   6265,  -14.3669872,   63.9136505,  -6.36363649
   6266,  -14.3669872,   63.9136505,  -7.27272749
   6267,  -14.3669872,   63.9136505,  -8.18181801
   6268,  -14.3669872,   63.9136505,    -9.090909
   6269,  -14.8055601,   63.4460182, -0.909090936
   6270,  -14.8055601,   63.4460182,  -1.81818187
   6271,  -14.8055601,   63.4460182,  -2.72727275
   6272,  -14.8055601,   63.4460182,  -3.63636374
   6273,  -14.8055601,   63.4460182,   -4.5454545
   6274,  -14.8055601,   63.4460182,   -5.4545455
   6275,  -14.8055601,   63.4460182,  -6.36363649
   6276,  -14.8055601,   63.4460182,  -7.27272749
   6277,  -14.8055601,   63.4460182,  -8.18181801
   6278,  -14.8055601,   63.4460182,    -9.090909
   6279,  -15.2289181,   62.9645691, -0.909090936
   6280,  -15.2289181,   62.9645691,  -1.81818187
   6281,  -15.2289181,   62.9645691,  -2.72727275
   6282,  -15.2289181,   62.9645691,  -3.63636374
   6283,  -15.2289181,   62.9645691,   -4.5454545
   6284,  -15.2289181,   62.9645691,   -5.4545455
   6285,  -15.2289181,   62.9645691,  -6.36363649
   6286,  -15.2289181,   62.9645691,  -7.27272749
   6287,  -15.2289181,   62.9645691,  -8.18181801
   6288,  -15.2289181,   62.9645691,    -9.090909
   6289,  -15.6366301,   62.4697952, -0.909090936
   6290,  -15.6366301,   62.4697952,  -1.81818187
   6291,  -15.6366301,   62.4697952,  -2.72727275
   6292,  -15.6366301,   62.4697952,  -3.63636374
   6293,  -15.6366301,   62.4697952,   -4.5454545
   6294,  -15.6366301,   62.4697952,   -5.4545455
   6295,  -15.6366301,   62.4697952,  -6.36363649
   6296,  -15.6366301,   62.4697952,  -7.27272749
   6297,  -15.6366301,   62.4697952,  -8.18181801
   6298,  -15.6366301,   62.4697952,    -9.090909
   6299,  -16.0282726,   61.9622116, -0.909090936
   6300,  -16.0282726,   61.9622116,  -1.81818187
   6301,  -16.0282726,   61.9622116,  -2.72727275
   6302,  -16.0282726,   61.9622116,  -3.63636374
   6303,  -16.0282726,   61.9622116,   -4.5454545
   6304,  -16.0282726,   61.9622116,   -5.4545455
   6305,  -16.0282726,   61.9622116,  -6.36363649
   6306,  -16.0282726,   61.9622116,  -7.27272749
   6307,  -16.0282726,   61.9622116,  -8.18181801
   6308,  -16.0282726,   61.9622116,    -9.090909
   6309,  -16.4034443,   61.4423332, -0.909090936
   6310,  -16.4034443,   61.4423332,  -1.81818187
   6311,  -16.4034443,   61.4423332,  -2.72727275
   6312,  -16.4034443,   61.4423332,  -3.63636374
   6313,  -16.4034443,   61.4423332,   -4.5454545
   6314,  -16.4034443,   61.4423332,   -5.4545455
   6315,  -16.4034443,   61.4423332,  -6.36363649
   6316,  -16.4034443,   61.4423332,  -7.27272749
   6317,  -16.4034443,   61.4423332,  -8.18181801
   6318,  -16.4034443,   61.4423332,    -9.090909
   6319,  -16.7617626,   60.9106979, -0.909090936
   6320,  -16.7617626,   60.9106979,  -1.81818187
   6321,  -16.7617626,   60.9106979,  -2.72727275
   6322,  -16.7617626,   60.9106979,  -3.63636374
   6323,  -16.7617626,   60.9106979,   -4.5454545
   6324,  -16.7617626,   60.9106979,   -5.4545455
   6325,  -16.7617626,   60.9106979,  -6.36363649
   6326,  -16.7617626,   60.9106979,  -7.27272749
   6327,  -16.7617626,   60.9106979,  -8.18181801
   6328,  -16.7617626,   60.9106979,    -9.090909
   6329,  -17.1028557,   60.3678513, -0.909090936
   6330,  -17.1028557,   60.3678513,  -1.81818187
   6331,  -17.1028557,   60.3678513,  -2.72727275
   6332,  -17.1028557,   60.3678513,  -3.63636374
   6333,  -17.1028557,   60.3678513,   -4.5454545
   6334,  -17.1028557,   60.3678513,   -5.4545455
   6335,  -17.1028557,   60.3678513,  -6.36363649
   6336,  -17.1028557,   60.3678513,  -7.27272749
   6337,  -17.1028557,   60.3678513,  -8.18181801
   6338,  -17.1028557,   60.3678513,    -9.090909
   6339,  -17.4263744,   59.8143501, -0.909090936
   6340,  -17.4263744,   59.8143501,  -1.81818187
   6341,  -17.4263744,   59.8143501,  -2.72727275
   6342,  -17.4263744,   59.8143501,  -3.63636374
   6343,  -17.4263744,   59.8143501,   -4.5454545
   6344,  -17.4263744,   59.8143501,   -5.4545455
   6345,  -17.4263744,   59.8143501,  -6.36363649
   6346,  -17.4263744,   59.8143501,  -7.27272749
   6347,  -17.4263744,   59.8143501,  -8.18181801
   6348,  -17.4263744,   59.8143501,    -9.090909
   6349,  -17.7319851,   59.2507668, -0.909090936
   6350,  -17.7319851,   59.2507668,  -1.81818187
   6351,  -17.7319851,   59.2507668,  -2.72727275
   6352,  -17.7319851,   59.2507668,  -3.63636374
   6353,  -17.7319851,   59.2507668,   -4.5454545
   6354,  -17.7319851,   59.2507668,   -5.4545455
   6355,  -17.7319851,   59.2507668,  -6.36363649
   6356,  -17.7319851,   59.2507668,  -7.27272749
   6357,  -17.7319851,   59.2507668,  -8.18181801
   6358,  -17.7319851,   59.2507668,    -9.090909
   6359,  -18.0193787,   58.6776733, -0.909090936
   6360,  -18.0193787,   58.6776733,  -1.81818187
   6361,  -18.0193787,   58.6776733,  -2.72727275
   6362,  -18.0193787,   58.6776733,  -3.63636374
   6363,  -18.0193787,   58.6776733,   -4.5454545
   6364,  -18.0193787,   58.6776733,   -5.4545455
   6365,  -18.0193787,   58.6776733,  -6.36363649
   6366,  -18.0193787,   58.6776733,  -7.27272749
   6367,  -18.0193787,   58.6776733,  -8.18181801
   6368,  -18.0193787,   58.6776733,    -9.090909
   6369,  -18.2882538,    58.095665, -0.909090936
   6370,  -18.2882538,    58.095665,  -1.81818187
   6371,  -18.2882538,    58.095665,  -2.72727275
   6372,  -18.2882538,    58.095665,  -3.63636374
   6373,  -18.2882538,    58.095665,   -4.5454545
   6374,  -18.2882538,    58.095665,   -5.4545455
   6375,  -18.2882538,    58.095665,  -6.36363649
   6376,  -18.2882538,    58.095665,  -7.27272749
   6377,  -18.2882538,    58.095665,  -8.18181801
   6378,  -18.2882538,    58.095665,    -9.090909
   6379,  -18.5383358,   57.5053406, -0.909090936
   6380,  -18.5383358,   57.5053406,  -1.81818187
   6381,  -18.5383358,   57.5053406,  -2.72727275
   6382,  -18.5383358,   57.5053406,  -3.63636374
   6383,  -18.5383358,   57.5053406,   -4.5454545
   6384,  -18.5383358,   57.5053406,   -5.4545455
   6385,  -18.5383358,   57.5053406,  -6.36363649
   6386,  -18.5383358,   57.5053406,  -7.27272749
   6387,  -18.5383358,   57.5053406,  -8.18181801
   6388,  -18.5383358,   57.5053406,    -9.090909
   6389,  -18.7693672,   56.9073029, -0.909090936
   6390,  -18.7693672,   56.9073029,  -1.81818187
   6391,  -18.7693672,   56.9073029,  -2.72727275
   6392,  -18.7693672,   56.9073029,  -3.63636374
   6393,  -18.7693672,   56.9073029,   -4.5454545
   6394,  -18.7693672,   56.9073029,   -5.4545455
   6395,  -18.7693672,   56.9073029,  -6.36363649
   6396,  -18.7693672,   56.9073029,  -7.27272749
   6397,  -18.7693672,   56.9073029,  -8.18181801
   6398,  -18.7693672,   56.9073029,    -9.090909
   6399,  -18.9811153,    56.302166, -0.909090936
   6400,  -18.9811153,    56.302166,  -1.81818187
   6401,  -18.9811153,    56.302166,  -2.72727275
   6402,  -18.9811153,    56.302166,  -3.63636374
   6403,  -18.9811153,    56.302166,   -4.5454545
   6404,  -18.9811153,    56.302166,   -5.4545455
   6405,  -18.9811153,    56.302166,  -6.36363649
   6406,  -18.9811153,    56.302166,  -7.27272749
   6407,  -18.9811153,    56.302166,  -8.18181801
   6408,  -18.9811153,    56.302166,    -9.090909
   6409,   -19.173357,   55.6905518, -0.909090936
   6410,   -19.173357,   55.6905518,  -1.81818187
   6411,   -19.173357,   55.6905518,  -2.72727275
   6412,   -19.173357,   55.6905518,  -3.63636374
   6413,   -19.173357,   55.6905518,   -4.5454545
   6414,   -19.173357,   55.6905518,   -5.4545455
   6415,   -19.173357,   55.6905518,  -6.36363649
   6416,   -19.173357,   55.6905518,  -7.27272749
   6417,   -19.173357,   55.6905518,  -8.18181801
   6418,   -19.173357,   55.6905518,    -9.090909
   6419,  -19.3458977,   55.0730934, -0.909090936
   6420,  -19.3458977,   55.0730934,  -1.81818187
   6421,  -19.3458977,   55.0730934,  -2.72727275
   6422,  -19.3458977,   55.0730934,  -3.63636374
   6423,  -19.3458977,   55.0730934,   -4.5454545
   6424,  -19.3458977,   55.0730934,   -5.4545455
   6425,  -19.3458977,   55.0730934,  -6.36363649
   6426,  -19.3458977,   55.0730934,  -7.27272749
   6427,  -19.3458977,   55.0730934,  -8.18181801
   6428,  -19.3458977,   55.0730934,    -9.090909
   6429,   -19.498558,   54.4504204, -0.909090936
   6430,   -19.498558,   54.4504204,  -1.81818187
   6431,   -19.498558,   54.4504204,  -2.72727275
   6432,   -19.498558,   54.4504204,  -3.63636374
   6433,   -19.498558,   54.4504204,   -4.5454545
   6434,   -19.498558,   54.4504204,   -5.4545455
   6435,   -19.498558,   54.4504204,  -6.36363649
   6436,   -19.498558,   54.4504204,  -7.27272749
   6437,   -19.498558,   54.4504204,  -8.18181801
   6438,   -19.498558,   54.4504204,    -9.090909
   6439,  -19.6311836,   53.8231735, -0.909090936
   6440,  -19.6311836,   53.8231735,  -1.81818187
   6441,  -19.6311836,   53.8231735,  -2.72727275
   6442,  -19.6311836,   53.8231735,  -3.63636374
   6443,  -19.6311836,   53.8231735,   -4.5454545
   6444,  -19.6311836,   53.8231735,   -5.4545455
   6445,  -19.6311836,   53.8231735,  -6.36363649
   6446,  -19.6311836,   53.8231735,  -7.27272749
   6447,  -19.6311836,   53.8231735,  -8.18181801
   6448,  -19.6311836,   53.8231735,    -9.090909
   6449,  -19.7436352,   53.1919975, -0.909090936
   6450,  -19.7436352,   53.1919975,  -1.81818187
   6451,  -19.7436352,   53.1919975,  -2.72727275
   6452,  -19.7436352,   53.1919975,  -3.63636374
   6453,  -19.7436352,   53.1919975,   -4.5454545
   6454,  -19.7436352,   53.1919975,   -5.4545455
   6455,  -19.7436352,   53.1919975,  -6.36363649
   6456,  -19.7436352,   53.1919975,  -7.27272749
   6457,  -19.7436352,   53.1919975,  -8.18181801
   6458,  -19.7436352,   53.1919975,    -9.090909
   6459,  -19.8358002,   52.5575447, -0.909090936
   6460,  -19.8358002,   52.5575447,  -1.81818187
   6461,  -19.8358002,   52.5575447,  -2.72727275
   6462,  -19.8358002,   52.5575447,  -3.63636374
   6463,  -19.8358002,   52.5575447,   -4.5454545
   6464,  -19.8358002,   52.5575447,   -5.4545455
   6465,  -19.8358002,   52.5575447,  -6.36363649
   6466,  -19.8358002,   52.5575447,  -7.27272749
   6467,  -19.8358002,   52.5575447,  -8.18181801
   6468,  -19.8358002,   52.5575447,    -9.090909
   6469,  -19.9075832,   51.9204597, -0.909090936
   6470,  -19.9075832,   51.9204597,  -1.81818187
   6471,  -19.9075832,   51.9204597,  -2.72727275
   6472,  -19.9075832,   51.9204597,  -3.63636374
   6473,  -19.9075832,   51.9204597,   -4.5454545
   6474,  -19.9075832,   51.9204597,   -5.4545455
   6475,  -19.9075832,   51.9204597,  -6.36363649
   6476,  -19.9075832,   51.9204597,  -7.27272749
   6477,  -19.9075832,   51.9204597,  -8.18181801
   6478,  -19.9075832,   51.9204597,    -9.090909
   6479,  -19.9589081,   51.2814026, -0.909090936
   6480,  -19.9589081,   51.2814026,  -1.81818187
   6481,  -19.9589081,   51.2814026,  -2.72727275
   6482,  -19.9589081,   51.2814026,  -3.63636374
   6483,  -19.9589081,   51.2814026,   -4.5454545
   6484,  -19.9589081,   51.2814026,   -5.4545455
   6485,  -19.9589081,   51.2814026,  -6.36363649
   6486,  -19.9589081,   51.2814026,  -7.27272749
   6487,  -19.9589081,   51.2814026,  -8.18181801
   6488,  -19.9589081,   51.2814026,    -9.090909
   6489,  -19.9897251,   50.6410332, -0.909090936
   6490,  -19.9897251,   50.6410332,  -1.81818187
   6491,  -19.9897251,   50.6410332,  -2.72727275
   6492,  -19.9897251,   50.6410332,  -3.63636374
   6493,  -19.9897251,   50.6410332,   -4.5454545
   6494,  -19.9897251,   50.6410332,   -5.4545455
   6495,  -19.9897251,   50.6410332,  -6.36363649
   6496,  -19.9897251,   50.6410332,  -7.27272749
   6497,  -19.9897251,   50.6410332,  -8.18181801
   6498,  -19.9897251,   50.6410332,    -9.090909
   6499,   29.9845867,   50.9615479, -0.909090936
   6500,   29.9845867,   50.9615479,  -1.81818187
   6501,   29.9845867,   50.9615479,  -2.72727275
   6502,   29.9845867,   50.9615479,  -3.63636374
   6503,   29.9845867,   50.9615479,   -4.5454545
   6504,   29.9845867,   50.9615479,   -5.4545455
   6505,   29.9845867,   50.9615479,  -6.36363649
   6506,   29.9845867,   50.9615479,  -7.27272749
   6507,   29.9845867,   50.9615479,  -8.18181801
   6508,   29.9845867,   50.9615479,    -9.090909
   6509,   29.9383621,   51.9221077, -0.909090936
   6510,   29.9383621,   51.9221077,  -1.81818187
   6511,   29.9383621,   51.9221077,  -2.72727275
   6512,   29.9383621,   51.9221077,  -3.63636374
   6513,   29.9383621,   51.9221077,   -4.5454545
   6514,   29.9383621,   51.9221077,   -5.4545455
   6515,   29.9383621,   51.9221077,  -6.36363649
   6516,   29.9383621,   51.9221077,  -7.27272749
   6517,   29.9383621,   51.9221077,  -8.18181801
   6518,   29.9383621,   51.9221077,    -9.090909
   6519,   29.8613739,   52.8806915, -0.909090936
   6520,   29.8613739,   52.8806915,  -1.81818187
   6521,   29.8613739,   52.8806915,  -2.72727275
   6522,   29.8613739,   52.8806915,  -3.63636374
   6523,   29.8613739,   52.8806915,   -4.5454545
   6524,   29.8613739,   52.8806915,   -5.4545455
   6525,   29.8613739,   52.8806915,  -6.36363649
   6526,   29.8613739,   52.8806915,  -7.27272749
   6527,   29.8613739,   52.8806915,  -8.18181801
   6528,   29.8613739,   52.8806915,    -9.090909
   6529,   29.7537003,   53.8363152, -0.909090936
   6530,   29.7537003,   53.8363152,  -1.81818187
   6531,   29.7537003,   53.8363152,  -2.72727275
   6532,   29.7537003,   53.8363152,  -3.63636374
   6533,   29.7537003,   53.8363152,   -4.5454545
   6534,   29.7537003,   53.8363152,   -5.4545455
   6535,   29.7537003,   53.8363152,  -6.36363649
   6536,   29.7537003,   53.8363152,  -7.27272749
   6537,   29.7537003,   53.8363152,  -8.18181801
   6538,   29.7537003,   53.8363152,    -9.090909
   6539,   29.6154537,   54.7879982, -0.909090936
   6540,   29.6154537,   54.7879982,  -1.81818187
   6541,   29.6154537,   54.7879982,  -2.72727275
   6542,   29.6154537,   54.7879982,  -3.63636374
   6543,   29.6154537,   54.7879982,   -4.5454545
   6544,   29.6154537,   54.7879982,   -5.4545455
   6545,   29.6154537,   54.7879982,  -6.36363649
   6546,   29.6154537,   54.7879982,  -7.27272749
   6547,   29.6154537,   54.7879982,  -8.18181801
   6548,   29.6154537,   54.7879982,    -9.090909
   6549,   29.4467735,   55.7347603, -0.909090936
   6550,   29.4467735,   55.7347603,  -1.81818187
   6551,   29.4467735,   55.7347603,  -2.72727275
   6552,   29.4467735,   55.7347603,  -3.63636374
   6553,   29.4467735,   55.7347603,   -4.5454545
   6554,   29.4467735,   55.7347603,   -5.4545455
   6555,   29.4467735,   55.7347603,  -6.36363649
   6556,   29.4467735,   55.7347603,  -7.27272749
   6557,   29.4467735,   55.7347603,  -8.18181801
   6558,   29.4467735,   55.7347603,    -9.090909
   6559,   29.2478371,   56.6756287, -0.909090936
   6560,   29.2478371,   56.6756287,  -1.81818187
   6561,   29.2478371,   56.6756287,  -2.72727275
   6562,   29.2478371,   56.6756287,  -3.63636374
   6563,   29.2478371,   56.6756287,   -4.5454545
   6564,   29.2478371,   56.6756287,   -5.4545455
   6565,   29.2478371,   56.6756287,  -6.36363649
   6566,   29.2478371,   56.6756287,  -7.27272749
   6567,   29.2478371,   56.6756287,  -8.18181801
   6568,   29.2478371,   56.6756287,    -9.090909
   6569,   29.0188465,   57.6096382, -0.909090936
   6570,   29.0188465,   57.6096382,  -1.81818187
   6571,   29.0188465,   57.6096382,  -2.72727275
   6572,   29.0188465,   57.6096382,  -3.63636374
   6573,   29.0188465,   57.6096382,   -4.5454545
   6574,   29.0188465,   57.6096382,   -5.4545455
   6575,   29.0188465,   57.6096382,  -6.36363649
   6576,   29.0188465,   57.6096382,  -7.27272749
   6577,   29.0188465,   57.6096382,  -8.18181801
   6578,   29.0188465,   57.6096382,    -9.090909
   6579,   28.7600365,   58.5358276, -0.909090936
   6580,   28.7600365,   58.5358276,  -1.81818187
   6581,   28.7600365,   58.5358276,  -2.72727275
   6582,   28.7600365,   58.5358276,  -3.63636374
   6583,   28.7600365,   58.5358276,   -4.5454545
   6584,   28.7600365,   58.5358276,   -5.4545455
   6585,   28.7600365,   58.5358276,  -6.36363649
   6586,   28.7600365,   58.5358276,  -7.27272749
   6587,   28.7600365,   58.5358276,  -8.18181801
   6588,   28.7600365,   58.5358276,    -9.090909
   6589,   28.4716721,   59.4532471, -0.909090936
   6590,   28.4716721,   59.4532471,  -1.81818187
   6591,   28.4716721,   59.4532471,  -2.72727275
   6592,   28.4716721,   59.4532471,  -3.63636374
   6593,   28.4716721,   59.4532471,   -4.5454545
   6594,   28.4716721,   59.4532471,   -5.4545455
   6595,   28.4716721,   59.4532471,  -6.36363649
   6596,   28.4716721,   59.4532471,  -7.27272749
   6597,   28.4716721,   59.4532471,  -8.18181801
   6598,   28.4716721,   59.4532471,    -9.090909
   6599,   28.1540527,   60.3609505, -0.909090936
   6600,   28.1540527,   60.3609505,  -1.81818187
   6601,   28.1540527,   60.3609505,  -2.72727275
   6602,   28.1540527,   60.3609505,  -3.63636374
   6603,   28.1540527,   60.3609505,   -4.5454545
   6604,   28.1540527,   60.3609505,   -5.4545455
   6605,   28.1540527,   60.3609505,  -6.36363649
   6606,   28.1540527,   60.3609505,  -7.27272749
   6607,   28.1540527,   60.3609505,  -8.18181801
   6608,   28.1540527,   60.3609505,    -9.090909
   6609,   27.8075027,   61.2580109, -0.909090936
   6610,   27.8075027,   61.2580109,  -1.81818187
   6611,   27.8075027,   61.2580109,  -2.72727275
   6612,   27.8075027,   61.2580109,  -3.63636374
   6613,   27.8075027,   61.2580109,   -4.5454545
   6614,   27.8075027,   61.2580109,   -5.4545455
   6615,   27.8075027,   61.2580109,  -6.36363649
   6616,   27.8075027,   61.2580109,  -7.27272749
   6617,   27.8075027,   61.2580109,  -8.18181801
   6618,   27.8075027,   61.2580109,    -9.090909
   6619,   27.4323788,   62.1435013, -0.909090936
   6620,   27.4323788,   62.1435013,  -1.81818187
   6621,   27.4323788,   62.1435013,  -2.72727275
   6622,   27.4323788,   62.1435013,  -3.63636374
   6623,   27.4323788,   62.1435013,   -4.5454545
   6624,   27.4323788,   62.1435013,   -5.4545455
   6625,   27.4323788,   62.1435013,  -6.36363649
   6626,   27.4323788,   62.1435013,  -7.27272749
   6627,   27.4323788,   62.1435013,  -8.18181801
   6628,   27.4323788,   62.1435013,    -9.090909
   6629,   27.0290661,   63.0165138, -0.909090936
   6630,   27.0290661,   63.0165138,  -1.81818187
   6631,   27.0290661,   63.0165138,  -2.72727275
   6632,   27.0290661,   63.0165138,  -3.63636374
   6633,   27.0290661,   63.0165138,   -4.5454545
   6634,   27.0290661,   63.0165138,   -5.4545455
   6635,   27.0290661,   63.0165138,  -6.36363649
   6636,   27.0290661,   63.0165138,  -7.27272749
   6637,   27.0290661,   63.0165138,  -8.18181801
   6638,   27.0290661,   63.0165138,    -9.090909
   6639,   26.5979786,   63.8761482, -0.909090936
   6640,   26.5979786,   63.8761482,  -1.81818187
   6641,   26.5979786,   63.8761482,  -2.72727275
   6642,   26.5979786,   63.8761482,  -3.63636374
   6643,   26.5979786,   63.8761482,   -4.5454545
   6644,   26.5979786,   63.8761482,   -5.4545455
   6645,   26.5979786,   63.8761482,  -6.36363649
   6646,   26.5979786,   63.8761482,  -7.27272749
   6647,   26.5979786,   63.8761482,  -8.18181801
   6648,   26.5979786,   63.8761482,    -9.090909
   6649,   26.1395607,   64.7215271, -0.909090936
   6650,   26.1395607,   64.7215271,  -1.81818187
   6651,   26.1395607,   64.7215271,  -2.72727275
   6652,   26.1395607,   64.7215271,  -3.63636374
   6653,   26.1395607,   64.7215271,   -4.5454545
   6654,   26.1395607,   64.7215271,   -5.4545455
   6655,   26.1395607,   64.7215271,  -6.36363649
   6656,   26.1395607,   64.7215271,  -7.27272749
   6657,   26.1395607,   64.7215271,  -8.18181801
   6658,   26.1395607,   64.7215271,    -9.090909
   6659,   25.6542816,   65.5517807, -0.909090936
   6660,   25.6542816,   65.5517807,  -1.81818187
   6661,   25.6542816,   65.5517807,  -2.72727275
   6662,   25.6542816,   65.5517807,  -3.63636374
   6663,   25.6542816,   65.5517807,   -4.5454545
   6664,   25.6542816,   65.5517807,   -5.4545455
   6665,   25.6542816,   65.5517807,  -6.36363649
   6666,   25.6542816,   65.5517807,  -7.27272749
   6667,   25.6542816,   65.5517807,  -8.18181801
   6668,   25.6542816,   65.5517807,    -9.090909
   6669,   25.1426411,   66.3660507, -0.909090936
   6670,   25.1426411,   66.3660507,  -1.81818187
   6671,   25.1426411,   66.3660507,  -2.72727275
   6672,   25.1426411,   66.3660507,  -3.63636374
   6673,   25.1426411,   66.3660507,   -4.5454545
   6674,   25.1426411,   66.3660507,   -5.4545455
   6675,   25.1426411,   66.3660507,  -6.36363649
   6676,   25.1426411,   66.3660507,  -7.27272749
   6677,   25.1426411,   66.3660507,  -8.18181801
   6678,   25.1426411,   66.3660507,    -9.090909
   6679,   24.6051693,   67.1634979, -0.909090936
   6680,   24.6051693,   67.1634979,  -1.81818187
   6681,   24.6051693,   67.1634979,  -2.72727275
   6682,   24.6051693,   67.1634979,  -3.63636374
   6683,   24.6051693,   67.1634979,   -4.5454545
   6684,   24.6051693,   67.1634979,   -5.4545455
   6685,   24.6051693,   67.1634979,  -6.36363649
   6686,   24.6051693,   67.1634979,  -7.27272749
   6687,   24.6051693,   67.1634979,  -8.18181801
   6688,   24.6051693,   67.1634979,    -9.090909
   6689,   24.0424099,   67.9433136, -0.909090936
   6690,   24.0424099,   67.9433136,  -1.81818187
   6691,   24.0424099,   67.9433136,  -2.72727275
   6692,   24.0424099,   67.9433136,  -3.63636374
   6693,   24.0424099,   67.9433136,   -4.5454545
   6694,   24.0424099,   67.9433136,   -5.4545455
   6695,   24.0424099,   67.9433136,  -6.36363649
   6696,   24.0424099,   67.9433136,  -7.27272749
   6697,   24.0424099,   67.9433136,  -8.18181801
   6698,   24.0424099,   67.9433136,    -9.090909
   6699,   23.4549427,   68.7046967, -0.909090936
   6700,   23.4549427,   68.7046967,  -1.81818187
   6701,   23.4549427,   68.7046967,  -2.72727275
   6702,   23.4549427,   68.7046967,  -3.63636374
   6703,   23.4549427,   68.7046967,   -4.5454545
   6704,   23.4549427,   68.7046967,   -5.4545455
   6705,   23.4549427,   68.7046967,  -6.36363649
   6706,   23.4549427,   68.7046967,  -7.27272749
   6707,   23.4549427,   68.7046967,  -8.18181801
   6708,   23.4549427,   68.7046967,    -9.090909
   6709,   22.8433781,   69.4468536, -0.909090936
   6710,   22.8433781,   69.4468536,  -1.81818187
   6711,   22.8433781,   69.4468536,  -2.72727275
   6712,   22.8433781,   69.4468536,  -3.63636374
   6713,   22.8433781,   69.4468536,   -4.5454545
   6714,   22.8433781,   69.4468536,   -5.4545455
   6715,   22.8433781,   69.4468536,  -6.36363649
   6716,   22.8433781,   69.4468536,  -7.27272749
   6717,   22.8433781,   69.4468536,  -8.18181801
   6718,   22.8433781,   69.4468536,    -9.090909
   6719,   22.2083378,   70.1690292, -0.909090936
   6720,   22.2083378,   70.1690292,  -1.81818187
   6721,   22.2083378,   70.1690292,  -2.72727275
   6722,   22.2083378,   70.1690292,  -3.63636374
   6723,   22.2083378,   70.1690292,   -4.5454545
   6724,   22.2083378,   70.1690292,   -5.4545455
   6725,   22.2083378,   70.1690292,  -6.36363649
   6726,   22.2083378,   70.1690292,  -7.27272749
   6727,   22.2083378,   70.1690292,  -8.18181801
   6728,   22.2083378,   70.1690292,    -9.090909
   6729,   21.5504799,   70.8704758, -0.909090936
   6730,   21.5504799,   70.8704758,  -1.81818187
   6731,   21.5504799,   70.8704758,  -2.72727275
   6732,   21.5504799,   70.8704758,  -3.63636374
   6733,   21.5504799,   70.8704758,   -4.5454545
   6734,   21.5504799,   70.8704758,   -5.4545455
   6735,   21.5504799,   70.8704758,  -6.36363649
   6736,   21.5504799,   70.8704758,  -7.27272749
   6737,   21.5504799,   70.8704758,  -8.18181801
   6738,   21.5504799,   70.8704758,    -9.090909
   6739,   20.8704739,   71.5504837, -0.909090936
   6740,   20.8704739,   71.5504837,  -1.81818187
   6741,   20.8704739,   71.5504837,  -2.72727275
   6742,   20.8704739,   71.5504837,  -3.63636374
   6743,   20.8704739,   71.5504837,   -4.5454545
   6744,   20.8704739,   71.5504837,   -5.4545455
   6745,   20.8704739,   71.5504837,  -6.36363649
   6746,   20.8704739,   71.5504837,  -7.27272749
   6747,   20.8704739,   71.5504837,  -8.18181801
   6748,   20.8704739,   71.5504837,    -9.090909
   6749,   20.1690254,   72.2083435, -0.909090936
   6750,   20.1690254,   72.2083435,  -1.81818187
   6751,   20.1690254,   72.2083435,  -2.72727275
   6752,   20.1690254,   72.2083435,  -3.63636374
   6753,   20.1690254,   72.2083435,   -4.5454545
   6754,   20.1690254,   72.2083435,   -5.4545455
   6755,   20.1690254,   72.2083435,  -6.36363649
   6756,   20.1690254,   72.2083435,  -7.27272749
   6757,   20.1690254,   72.2083435,  -8.18181801
   6758,   20.1690254,   72.2083435,    -9.090909
   6759,   19.4468536,   72.8433762, -0.909090936
   6760,   19.4468536,   72.8433762,  -1.81818187
   6761,   19.4468536,   72.8433762,  -2.72727275
   6762,   19.4468536,   72.8433762,  -3.63636374
   6763,   19.4468536,   72.8433762,   -4.5454545
   6764,   19.4468536,   72.8433762,   -5.4545455
   6765,   19.4468536,   72.8433762,  -6.36363649
   6766,   19.4468536,   72.8433762,  -7.27272749
   6767,   19.4468536,   72.8433762,  -8.18181801
   6768,   19.4468536,   72.8433762,    -9.090909
   6769,   18.7046967,   73.4549408, -0.909090936
   6770,   18.7046967,   73.4549408,  -1.81818187
   6771,   18.7046967,   73.4549408,  -2.72727275
   6772,   18.7046967,   73.4549408,  -3.63636374
   6773,   18.7046967,   73.4549408,   -4.5454545
   6774,   18.7046967,   73.4549408,   -5.4545455
   6775,   18.7046967,   73.4549408,  -6.36363649
   6776,   18.7046967,   73.4549408,  -7.27272749
   6777,   18.7046967,   73.4549408,  -8.18181801
   6778,   18.7046967,   73.4549408,    -9.090909
   6779,   17.9433136,   74.0424118, -0.909090936
   6780,   17.9433136,   74.0424118,  -1.81818187
   6781,   17.9433136,   74.0424118,  -2.72727275
   6782,   17.9433136,   74.0424118,  -3.63636374
   6783,   17.9433136,   74.0424118,   -4.5454545
   6784,   17.9433136,   74.0424118,   -5.4545455
   6785,   17.9433136,   74.0424118,  -6.36363649
   6786,   17.9433136,   74.0424118,  -7.27272749
   6787,   17.9433136,   74.0424118,  -8.18181801
   6788,   17.9433136,   74.0424118,    -9.090909
   6789,   17.1634979,   74.6051712, -0.909090936
   6790,   17.1634979,   74.6051712,  -1.81818187
   6791,   17.1634979,   74.6051712,  -2.72727275
   6792,   17.1634979,   74.6051712,  -3.63636374
   6793,   17.1634979,   74.6051712,   -4.5454545
   6794,   17.1634979,   74.6051712,   -5.4545455
   6795,   17.1634979,   74.6051712,  -6.36363649
   6796,   17.1634979,   74.6051712,  -7.27272749
   6797,   17.1634979,   74.6051712,  -8.18181801
   6798,   17.1634979,   74.6051712,    -9.090909
   6799,    16.366045,   75.1426468, -0.909090936
   6800,    16.366045,   75.1426468,  -1.81818187
   6801,    16.366045,   75.1426468,  -2.72727275
   6802,    16.366045,   75.1426468,  -3.63636374
   6803,    16.366045,   75.1426468,   -4.5454545
   6804,    16.366045,   75.1426468,   -5.4545455
   6805,    16.366045,   75.1426468,  -6.36363649
   6806,    16.366045,   75.1426468,  -7.27272749
   6807,    16.366045,   75.1426468,  -8.18181801
   6808,    16.366045,   75.1426468,    -9.090909
   6809,   15.5517778,   75.6542816, -0.909090936
   6810,   15.5517778,   75.6542816,  -1.81818187
   6811,   15.5517778,   75.6542816,  -2.72727275
   6812,   15.5517778,   75.6542816,  -3.63636374
   6813,   15.5517778,   75.6542816,   -4.5454545
   6814,   15.5517778,   75.6542816,   -5.4545455
   6815,   15.5517778,   75.6542816,  -6.36363649
   6816,   15.5517778,   75.6542816,  -7.27272749
   6817,   15.5517778,   75.6542816,  -8.18181801
   6818,   15.5517778,   75.6542816,    -9.090909
   6819,   14.7215252,   76.1395645, -0.909090936
   6820,   14.7215252,   76.1395645,  -1.81818187
   6821,   14.7215252,   76.1395645,  -2.72727275
   6822,   14.7215252,   76.1395645,  -3.63636374
   6823,   14.7215252,   76.1395645,   -4.5454545
   6824,   14.7215252,   76.1395645,   -5.4545455
   6825,   14.7215252,   76.1395645,  -6.36363649
   6826,   14.7215252,   76.1395645,  -7.27272749
   6827,   14.7215252,   76.1395645,  -8.18181801
   6828,   14.7215252,   76.1395645,    -9.090909
   6829,   13.8761501,   76.5979767, -0.909090936
   6830,   13.8761501,   76.5979767,  -1.81818187
   6831,   13.8761501,   76.5979767,  -2.72727275
   6832,   13.8761501,   76.5979767,  -3.63636374
   6833,   13.8761501,   76.5979767,   -4.5454545
   6834,   13.8761501,   76.5979767,   -5.4545455
   6835,   13.8761501,   76.5979767,  -6.36363649
   6836,   13.8761501,   76.5979767,  -7.27272749
   6837,   13.8761501,   76.5979767,  -8.18181801
   6838,   13.8761501,   76.5979767,    -9.090909
   6839,    13.016511,    77.029068, -0.909090936
   6840,    13.016511,    77.029068,  -1.81818187
   6841,    13.016511,    77.029068,  -2.72727275
   6842,    13.016511,    77.029068,  -3.63636374
   6843,    13.016511,    77.029068,   -4.5454545
   6844,    13.016511,    77.029068,   -5.4545455
   6845,    13.016511,    77.029068,  -6.36363649
   6846,    13.016511,    77.029068,  -7.27272749
   6847,    13.016511,    77.029068,  -8.18181801
   6848,    13.016511,    77.029068,    -9.090909
   6849,   12.1434994,   77.4323807, -0.909090936
   6850,   12.1434994,   77.4323807,  -1.81818187
   6851,   12.1434994,   77.4323807,  -2.72727275
   6852,   12.1434994,   77.4323807,  -3.63636374
   6853,   12.1434994,   77.4323807,   -4.5454545
   6854,   12.1434994,   77.4323807,   -5.4545455
   6855,   12.1434994,   77.4323807,  -6.36363649
   6856,   12.1434994,   77.4323807,  -7.27272749
   6857,   12.1434994,   77.4323807,  -8.18181801
   6858,   12.1434994,   77.4323807,    -9.090909
   6859,   11.2580099,   77.8075027, -0.909090936
   6860,   11.2580099,   77.8075027,  -1.81818187
   6861,   11.2580099,   77.8075027,  -2.72727275
   6862,   11.2580099,   77.8075027,  -3.63636374
   6863,   11.2580099,   77.8075027,   -4.5454545
   6864,   11.2580099,   77.8075027,   -5.4545455
   6865,   11.2580099,   77.8075027,  -6.36363649
   6866,   11.2580099,   77.8075027,  -7.27272749
   6867,   11.2580099,   77.8075027,  -8.18181801
   6868,   11.2580099,   77.8075027,    -9.090909
   6869,   10.3609514,   78.1540527, -0.909090936
   6870,   10.3609514,   78.1540527,  -1.81818187
   6871,   10.3609514,   78.1540527,  -2.72727275
   6872,   10.3609514,   78.1540527,  -3.63636374
   6873,   10.3609514,   78.1540527,   -4.5454545
   6874,   10.3609514,   78.1540527,   -5.4545455
   6875,   10.3609514,   78.1540527,  -6.36363649
   6876,   10.3609514,   78.1540527,  -7.27272749
   6877,   10.3609514,   78.1540527,  -8.18181801
   6878,   10.3609514,   78.1540527,    -9.090909
   6879,   9.45324612,   78.4716721, -0.909090936
   6880,   9.45324612,   78.4716721,  -1.81818187
   6881,   9.45324612,   78.4716721,  -2.72727275
   6882,   9.45324612,   78.4716721,  -3.63636374
   6883,   9.45324612,   78.4716721,   -4.5454545
   6884,   9.45324612,   78.4716721,   -5.4545455
   6885,   9.45324612,   78.4716721,  -6.36363649
   6886,   9.45324612,   78.4716721,  -7.27272749
   6887,   9.45324612,   78.4716721,  -8.18181801
   6888,   9.45324612,   78.4716721,    -9.090909
   6889,   8.53582859,   78.7600327, -0.909090936
   6890,   8.53582859,   78.7600327,  -1.81818187
   6891,   8.53582859,   78.7600327,  -2.72727275
   6892,   8.53582859,   78.7600327,  -3.63636374
   6893,   8.53582859,   78.7600327,   -4.5454545
   6894,   8.53582859,   78.7600327,   -5.4545455
   6895,   8.53582859,   78.7600327,  -6.36363649
   6896,   8.53582859,   78.7600327,  -7.27272749
   6897,   8.53582859,   78.7600327,  -8.18181801
   6898,   8.53582859,   78.7600327,    -9.090909
   6899,   7.60963821,   79.0188446, -0.909090936
   6900,   7.60963821,   79.0188446,  -1.81818187
   6901,   7.60963821,   79.0188446,  -2.72727275
   6902,   7.60963821,   79.0188446,  -3.63636374
   6903,   7.60963821,   79.0188446,   -4.5454545
   6904,   7.60963821,   79.0188446,   -5.4545455
   6905,   7.60963821,   79.0188446,  -6.36363649
   6906,   7.60963821,   79.0188446,  -7.27272749
   6907,   7.60963821,   79.0188446,  -8.18181801
   6908,   7.60963821,   79.0188446,    -9.090909
   6909,   6.67562723,   79.2478409, -0.909090936
   6910,   6.67562723,   79.2478409,  -1.81818187
   6911,   6.67562723,   79.2478409,  -2.72727275
   6912,   6.67562723,   79.2478409,  -3.63636374
   6913,   6.67562723,   79.2478409,   -4.5454545
   6914,   6.67562723,   79.2478409,   -5.4545455
   6915,   6.67562723,   79.2478409,  -6.36363649
   6916,   6.67562723,   79.2478409,  -7.27272749
   6917,   6.67562723,   79.2478409,  -8.18181801
   6918,   6.67562723,   79.2478409,    -9.090909
   6919,   5.73475838,   79.4467773, -0.909090936
   6920,   5.73475838,   79.4467773,  -1.81818187
   6921,   5.73475838,   79.4467773,  -2.72727275
   6922,   5.73475838,   79.4467773,  -3.63636374
   6923,   5.73475838,   79.4467773,   -4.5454545
   6924,   5.73475838,   79.4467773,   -5.4545455
   6925,   5.73475838,   79.4467773,  -6.36363649
   6926,   5.73475838,   79.4467773,  -7.27272749
   6927,   5.73475838,   79.4467773,  -8.18181801
   6928,   5.73475838,   79.4467773,    -9.090909
   6929,   4.78799629,   79.6154556, -0.909090936
   6930,   4.78799629,   79.6154556,  -1.81818187
   6931,   4.78799629,   79.6154556,  -2.72727275
   6932,   4.78799629,   79.6154556,  -3.63636374
   6933,   4.78799629,   79.6154556,   -4.5454545
   6934,   4.78799629,   79.6154556,   -5.4545455
   6935,   4.78799629,   79.6154556,  -6.36363649
   6936,   4.78799629,   79.6154556,  -7.27272749
   6937,   4.78799629,   79.6154556,  -8.18181801
   6938,   4.78799629,   79.6154556,    -9.090909
   6939,   3.83631492,   79.7537003, -0.909090936
   6940,   3.83631492,   79.7537003,  -1.81818187
   6941,   3.83631492,   79.7537003,  -2.72727275
   6942,   3.83631492,   79.7537003,  -3.63636374
   6943,   3.83631492,   79.7537003,   -4.5454545
   6944,   3.83631492,   79.7537003,   -5.4545455
   6945,   3.83631492,   79.7537003,  -6.36363649
   6946,   3.83631492,   79.7537003,  -7.27272749
   6947,   3.83631492,   79.7537003,  -8.18181801
   6948,   3.83631492,   79.7537003,    -9.090909
   6949,   2.88069081,   79.8613739, -0.909090936
   6950,   2.88069081,   79.8613739,  -1.81818187
   6951,   2.88069081,   79.8613739,  -2.72727275
   6952,   2.88069081,   79.8613739,  -3.63636374
   6953,   2.88069081,   79.8613739,   -4.5454545
   6954,   2.88069081,   79.8613739,   -5.4545455
   6955,   2.88069081,   79.8613739,  -6.36363649
   6956,   2.88069081,   79.8613739,  -7.27272749
   6957,   2.88069081,   79.8613739,  -8.18181801
   6958,   2.88069081,   79.8613739,    -9.090909
   6959,   1.92210662,   79.9383621, -0.909090936
   6960,   1.92210662,   79.9383621,  -1.81818187
   6961,   1.92210662,   79.9383621,  -2.72727275
   6962,   1.92210662,   79.9383621,  -3.63636374
   6963,   1.92210662,   79.9383621,   -4.5454545
   6964,   1.92210662,   79.9383621,   -5.4545455
   6965,   1.92210662,   79.9383621,  -6.36363649
   6966,   1.92210662,   79.9383621,  -7.27272749
   6967,   1.92210662,   79.9383621,  -8.18181801
   6968,   1.92210662,   79.9383621,    -9.090909
   6969,  0.961547256,   79.9845886, -0.909090936
   6970,  0.961547256,   79.9845886,  -1.81818187
   6971,  0.961547256,   79.9845886,  -2.72727275
   6972,  0.961547256,   79.9845886,  -3.63636374
   6973,  0.961547256,   79.9845886,   -4.5454545
   6974,  0.961547256,   79.9845886,   -5.4545455
   6975,  0.961547256,   79.9845886,  -6.36363649
   6976,  0.961547256,   79.9845886,  -7.27272749
   6977,  0.961547256,   79.9845886,  -8.18181801
   6978,  0.961547256,   79.9845886,    -9.090909
   6979,           0.,          80., -0.909090936
   6980,           0.,          80.,  -1.81818187
   6981,           0.,          80.,  -2.72727275
   6982,           0.,          80.,  -3.63636374
   6983,           0.,          80.,   -4.5454545
   6984,           0.,          80.,   -5.4545455
   6985,           0.,          80.,  -6.36363649
   6986,           0.,          80.,  -7.27272749
   6987,           0.,          80.,  -8.18181801
   6988,           0.,          80.,    -9.090909
   6989, -0.961547256,   79.9845886, -0.909090936
   6990, -0.961547256,   79.9845886,  -1.81818187
   6991, -0.961547256,   79.9845886,  -2.72727275
   6992, -0.961547256,   79.9845886,  -3.63636374
   6993, -0.961547256,   79.9845886,   -4.5454545
   6994, -0.961547256,   79.9845886,   -5.4545455
   6995, -0.961547256,   79.9845886,  -6.36363649
   6996, -0.961547256,   79.9845886,  -7.27272749
   6997, -0.961547256,   79.9845886,  -8.18181801
   6998, -0.961547256,   79.9845886,    -9.090909
   6999,  -1.92210662,   79.9383621, -0.909090936
   7000,  -1.92210662,   79.9383621,  -1.81818187
   7001,  -1.92210662,   79.9383621,  -2.72727275
   7002,  -1.92210662,   79.9383621,  -3.63636374
   7003,  -1.92210662,   79.9383621,   -4.5454545
   7004,  -1.92210662,   79.9383621,   -5.4545455
   7005,  -1.92210662,   79.9383621,  -6.36363649
   7006,  -1.92210662,   79.9383621,  -7.27272749
   7007,  -1.92210662,   79.9383621,  -8.18181801
   7008,  -1.92210662,   79.9383621,    -9.090909
   7009,  -2.88069081,   79.8613739, -0.909090936
   7010,  -2.88069081,   79.8613739,  -1.81818187
   7011,  -2.88069081,   79.8613739,  -2.72727275
   7012,  -2.88069081,   79.8613739,  -3.63636374
   7013,  -2.88069081,   79.8613739,   -4.5454545
   7014,  -2.88069081,   79.8613739,   -5.4545455
   7015,  -2.88069081,   79.8613739,  -6.36363649
   7016,  -2.88069081,   79.8613739,  -7.27272749
   7017,  -2.88069081,   79.8613739,  -8.18181801
   7018,  -2.88069081,   79.8613739,    -9.090909
   7019,  -3.83631492,   79.7537003, -0.909090936
   7020,  -3.83631492,   79.7537003,  -1.81818187
   7021,  -3.83631492,   79.7537003,  -2.72727275
   7022,  -3.83631492,   79.7537003,  -3.63636374
   7023,  -3.83631492,   79.7537003,   -4.5454545
   7024,  -3.83631492,   79.7537003,   -5.4545455
   7025,  -3.83631492,   79.7537003,  -6.36363649
   7026,  -3.83631492,   79.7537003,  -7.27272749
   7027,  -3.83631492,   79.7537003,  -8.18181801
   7028,  -3.83631492,   79.7537003,    -9.090909
   7029,  -4.78799629,   79.6154556, -0.909090936
   7030,  -4.78799629,   79.6154556,  -1.81818187
   7031,  -4.78799629,   79.6154556,  -2.72727275
   7032,  -4.78799629,   79.6154556,  -3.63636374
   7033,  -4.78799629,   79.6154556,   -4.5454545
   7034,  -4.78799629,   79.6154556,   -5.4545455
   7035,  -4.78799629,   79.6154556,  -6.36363649
   7036,  -4.78799629,   79.6154556,  -7.27272749
   7037,  -4.78799629,   79.6154556,  -8.18181801
   7038,  -4.78799629,   79.6154556,    -9.090909
   7039,  -5.73475838,   79.4467773, -0.909090936
   7040,  -5.73475838,   79.4467773,  -1.81818187
   7041,  -5.73475838,   79.4467773,  -2.72727275
   7042,  -5.73475838,   79.4467773,  -3.63636374
   7043,  -5.73475838,   79.4467773,   -4.5454545
   7044,  -5.73475838,   79.4467773,   -5.4545455
   7045,  -5.73475838,   79.4467773,  -6.36363649
   7046,  -5.73475838,   79.4467773,  -7.27272749
   7047,  -5.73475838,   79.4467773,  -8.18181801
   7048,  -5.73475838,   79.4467773,    -9.090909
   7049,  -6.67562723,   79.2478409, -0.909090936
   7050,  -6.67562723,   79.2478409,  -1.81818187
   7051,  -6.67562723,   79.2478409,  -2.72727275
   7052,  -6.67562723,   79.2478409,  -3.63636374
   7053,  -6.67562723,   79.2478409,   -4.5454545
   7054,  -6.67562723,   79.2478409,   -5.4545455
   7055,  -6.67562723,   79.2478409,  -6.36363649
   7056,  -6.67562723,   79.2478409,  -7.27272749
   7057,  -6.67562723,   79.2478409,  -8.18181801
   7058,  -6.67562723,   79.2478409,    -9.090909
   7059,  -7.60963821,   79.0188446, -0.909090936
   7060,  -7.60963821,   79.0188446,  -1.81818187
   7061,  -7.60963821,   79.0188446,  -2.72727275
   7062,  -7.60963821,   79.0188446,  -3.63636374
   7063,  -7.60963821,   79.0188446,   -4.5454545
   7064,  -7.60963821,   79.0188446,   -5.4545455
   7065,  -7.60963821,   79.0188446,  -6.36363649
   7066,  -7.60963821,   79.0188446,  -7.27272749
   7067,  -7.60963821,   79.0188446,  -8.18181801
   7068,  -7.60963821,   79.0188446,    -9.090909
   7069,  -8.53582859,   78.7600327, -0.909090936
   7070,  -8.53582859,   78.7600327,  -1.81818187
   7071,  -8.53582859,   78.7600327,  -2.72727275
   7072,  -8.53582859,   78.7600327,  -3.63636374
   7073,  -8.53582859,   78.7600327,   -4.5454545
   7074,  -8.53582859,   78.7600327,   -5.4545455
   7075,  -8.53582859,   78.7600327,  -6.36363649
   7076,  -8.53582859,   78.7600327,  -7.27272749
   7077,  -8.53582859,   78.7600327,  -8.18181801
   7078,  -8.53582859,   78.7600327,    -9.090909
   7079,  -9.45324612,   78.4716721, -0.909090936
   7080,  -9.45324612,   78.4716721,  -1.81818187
   7081,  -9.45324612,   78.4716721,  -2.72727275
   7082,  -9.45324612,   78.4716721,  -3.63636374
   7083,  -9.45324612,   78.4716721,   -4.5454545
   7084,  -9.45324612,   78.4716721,   -5.4545455
   7085,  -9.45324612,   78.4716721,  -6.36363649
   7086,  -9.45324612,   78.4716721,  -7.27272749
   7087,  -9.45324612,   78.4716721,  -8.18181801
   7088,  -9.45324612,   78.4716721,    -9.090909
   7089,  -10.3609514,   78.1540527, -0.909090936
   7090,  -10.3609514,   78.1540527,  -1.81818187
   7091,  -10.3609514,   78.1540527,  -2.72727275
   7092,  -10.3609514,   78.1540527,  -3.63636374
   7093,  -10.3609514,   78.1540527,   -4.5454545
   7094,  -10.3609514,   78.1540527,   -5.4545455
   7095,  -10.3609514,   78.1540527,  -6.36363649
   7096,  -10.3609514,   78.1540527,  -7.27272749
   7097,  -10.3609514,   78.1540527,  -8.18181801
   7098,  -10.3609514,   78.1540527,    -9.090909
   7099,  -11.2580099,   77.8075027, -0.909090936
   7100,  -11.2580099,   77.8075027,  -1.81818187
   7101,  -11.2580099,   77.8075027,  -2.72727275
   7102,  -11.2580099,   77.8075027,  -3.63636374
   7103,  -11.2580099,   77.8075027,   -4.5454545
   7104,  -11.2580099,   77.8075027,   -5.4545455
   7105,  -11.2580099,   77.8075027,  -6.36363649
   7106,  -11.2580099,   77.8075027,  -7.27272749
   7107,  -11.2580099,   77.8075027,  -8.18181801
   7108,  -11.2580099,   77.8075027,    -9.090909
   7109,  -12.1434994,   77.4323807, -0.909090936
   7110,  -12.1434994,   77.4323807,  -1.81818187
   7111,  -12.1434994,   77.4323807,  -2.72727275
   7112,  -12.1434994,   77.4323807,  -3.63636374
   7113,  -12.1434994,   77.4323807,   -4.5454545
   7114,  -12.1434994,   77.4323807,   -5.4545455
   7115,  -12.1434994,   77.4323807,  -6.36363649
   7116,  -12.1434994,   77.4323807,  -7.27272749
   7117,  -12.1434994,   77.4323807,  -8.18181801
   7118,  -12.1434994,   77.4323807,    -9.090909
   7119,   -13.016511,    77.029068, -0.909090936
   7120,   -13.016511,    77.029068,  -1.81818187
   7121,   -13.016511,    77.029068,  -2.72727275
   7122,   -13.016511,    77.029068,  -3.63636374
   7123,   -13.016511,    77.029068,   -4.5454545
   7124,   -13.016511,    77.029068,   -5.4545455
   7125,   -13.016511,    77.029068,  -6.36363649
   7126,   -13.016511,    77.029068,  -7.27272749
   7127,   -13.016511,    77.029068,  -8.18181801
   7128,   -13.016511,    77.029068,    -9.090909
   7129,  -13.8761501,   76.5979767, -0.909090936
   7130,  -13.8761501,   76.5979767,  -1.81818187
   7131,  -13.8761501,   76.5979767,  -2.72727275
   7132,  -13.8761501,   76.5979767,  -3.63636374
   7133,  -13.8761501,   76.5979767,   -4.5454545
   7134,  -13.8761501,   76.5979767,   -5.4545455
   7135,  -13.8761501,   76.5979767,  -6.36363649
   7136,  -13.8761501,   76.5979767,  -7.27272749
   7137,  -13.8761501,   76.5979767,  -8.18181801
   7138,  -13.8761501,   76.5979767,    -9.090909
   7139,  -14.7215252,   76.1395645, -0.909090936
   7140,  -14.7215252,   76.1395645,  -1.81818187
   7141,  -14.7215252,   76.1395645,  -2.72727275
   7142,  -14.7215252,   76.1395645,  -3.63636374
   7143,  -14.7215252,   76.1395645,   -4.5454545
   7144,  -14.7215252,   76.1395645,   -5.4545455
   7145,  -14.7215252,   76.1395645,  -6.36363649
   7146,  -14.7215252,   76.1395645,  -7.27272749
   7147,  -14.7215252,   76.1395645,  -8.18181801
   7148,  -14.7215252,   76.1395645,    -9.090909
   7149,  -15.5517778,   75.6542816, -0.909090936
   7150,  -15.5517778,   75.6542816,  -1.81818187
   7151,  -15.5517778,   75.6542816,  -2.72727275
   7152,  -15.5517778,   75.6542816,  -3.63636374
   7153,  -15.5517778,   75.6542816,   -4.5454545
   7154,  -15.5517778,   75.6542816,   -5.4545455
   7155,  -15.5517778,   75.6542816,  -6.36363649
   7156,  -15.5517778,   75.6542816,  -7.27272749
   7157,  -15.5517778,   75.6542816,  -8.18181801
   7158,  -15.5517778,   75.6542816,    -9.090909
   7159,   -16.366045,   75.1426468, -0.909090936
   7160,   -16.366045,   75.1426468,  -1.81818187
   7161,   -16.366045,   75.1426468,  -2.72727275
   7162,   -16.366045,   75.1426468,  -3.63636374
   7163,   -16.366045,   75.1426468,   -4.5454545
   7164,   -16.366045,   75.1426468,   -5.4545455
   7165,   -16.366045,   75.1426468,  -6.36363649
   7166,   -16.366045,   75.1426468,  -7.27272749
   7167,   -16.366045,   75.1426468,  -8.18181801
   7168,   -16.366045,   75.1426468,    -9.090909
   7169,  -17.1634979,   74.6051712, -0.909090936
   7170,  -17.1634979,   74.6051712,  -1.81818187
   7171,  -17.1634979,   74.6051712,  -2.72727275
   7172,  -17.1634979,   74.6051712,  -3.63636374
   7173,  -17.1634979,   74.6051712,   -4.5454545
   7174,  -17.1634979,   74.6051712,   -5.4545455
   7175,  -17.1634979,   74.6051712,  -6.36363649
   7176,  -17.1634979,   74.6051712,  -7.27272749
   7177,  -17.1634979,   74.6051712,  -8.18181801
   7178,  -17.1634979,   74.6051712,    -9.090909
   7179,  -17.9433136,   74.0424118, -0.909090936
   7180,  -17.9433136,   74.0424118,  -1.81818187
   7181,  -17.9433136,   74.0424118,  -2.72727275
   7182,  -17.9433136,   74.0424118,  -3.63636374
   7183,  -17.9433136,   74.0424118,   -4.5454545
   7184,  -17.9433136,   74.0424118,   -5.4545455
   7185,  -17.9433136,   74.0424118,  -6.36363649
   7186,  -17.9433136,   74.0424118,  -7.27272749
   7187,  -17.9433136,   74.0424118,  -8.18181801
   7188,  -17.9433136,   74.0424118,    -9.090909
   7189,  -18.7046967,   73.4549408, -0.909090936
   7190,  -18.7046967,   73.4549408,  -1.81818187
   7191,  -18.7046967,   73.4549408,  -2.72727275
   7192,  -18.7046967,   73.4549408,  -3.63636374
   7193,  -18.7046967,   73.4549408,   -4.5454545
   7194,  -18.7046967,   73.4549408,   -5.4545455
   7195,  -18.7046967,   73.4549408,  -6.36363649
   7196,  -18.7046967,   73.4549408,  -7.27272749
   7197,  -18.7046967,   73.4549408,  -8.18181801
   7198,  -18.7046967,   73.4549408,    -9.090909
   7199,  -19.4468536,   72.8433762, -0.909090936
   7200,  -19.4468536,   72.8433762,  -1.81818187
   7201,  -19.4468536,   72.8433762,  -2.72727275
   7202,  -19.4468536,   72.8433762,  -3.63636374
   7203,  -19.4468536,   72.8433762,   -4.5454545
   7204,  -19.4468536,   72.8433762,   -5.4545455
   7205,  -19.4468536,   72.8433762,  -6.36363649
   7206,  -19.4468536,   72.8433762,  -7.27272749
   7207,  -19.4468536,   72.8433762,  -8.18181801
   7208,  -19.4468536,   72.8433762,    -9.090909
   7209,  -20.1690254,   72.2083435, -0.909090936
   7210,  -20.1690254,   72.2083435,  -1.81818187
   7211,  -20.1690254,   72.2083435,  -2.72727275
   7212,  -20.1690254,   72.2083435,  -3.63636374
   7213,  -20.1690254,   72.2083435,   -4.5454545
   7214,  -20.1690254,   72.2083435,   -5.4545455
   7215,  -20.1690254,   72.2083435,  -6.36363649
   7216,  -20.1690254,   72.2083435,  -7.27272749
   7217,  -20.1690254,   72.2083435,  -8.18181801
   7218,  -20.1690254,   72.2083435,    -9.090909
   7219,  -20.8704739,   71.5504837, -0.909090936
   7220,  -20.8704739,   71.5504837,  -1.81818187
   7221,  -20.8704739,   71.5504837,  -2.72727275
   7222,  -20.8704739,   71.5504837,  -3.63636374
   7223,  -20.8704739,   71.5504837,   -4.5454545
   7224,  -20.8704739,   71.5504837,   -5.4545455
   7225,  -20.8704739,   71.5504837,  -6.36363649
   7226,  -20.8704739,   71.5504837,  -7.27272749
   7227,  -20.8704739,   71.5504837,  -8.18181801
   7228,  -20.8704739,   71.5504837,    -9.090909
   7229,  -21.5504799,   70.8704758, -0.909090936
   7230,  -21.5504799,   70.8704758,  -1.81818187
   7231,  -21.5504799,   70.8704758,  -2.72727275
   7232,  -21.5504799,   70.8704758,  -3.63636374
   7233,  -21.5504799,   70.8704758,   -4.5454545
   7234,  -21.5504799,   70.8704758,   -5.4545455
   7235,  -21.5504799,   70.8704758,  -6.36363649
   7236,  -21.5504799,   70.8704758,  -7.27272749
   7237,  -21.5504799,   70.8704758,  -8.18181801
   7238,  -21.5504799,   70.8704758,    -9.090909
   7239,  -22.2083378,   70.1690292, -0.909090936
   7240,  -22.2083378,   70.1690292,  -1.81818187
   7241,  -22.2083378,   70.1690292,  -2.72727275
   7242,  -22.2083378,   70.1690292,  -3.63636374
   7243,  -22.2083378,   70.1690292,   -4.5454545
   7244,  -22.2083378,   70.1690292,   -5.4545455
   7245,  -22.2083378,   70.1690292,  -6.36363649
   7246,  -22.2083378,   70.1690292,  -7.27272749
   7247,  -22.2083378,   70.1690292,  -8.18181801
   7248,  -22.2083378,   70.1690292,    -9.090909
   7249,  -22.8433781,   69.4468536, -0.909090936
   7250,  -22.8433781,   69.4468536,  -1.81818187
   7251,  -22.8433781,   69.4468536,  -2.72727275
   7252,  -22.8433781,   69.4468536,  -3.63636374
   7253,  -22.8433781,   69.4468536,   -4.5454545
   7254,  -22.8433781,   69.4468536,   -5.4545455
   7255,  -22.8433781,   69.4468536,  -6.36363649
   7256,  -22.8433781,   69.4468536,  -7.27272749
   7257,  -22.8433781,   69.4468536,  -8.18181801
   7258,  -22.8433781,   69.4468536,    -9.090909
   7259,  -23.4549427,   68.7046967, -0.909090936
   7260,  -23.4549427,   68.7046967,  -1.81818187
   7261,  -23.4549427,   68.7046967,  -2.72727275
   7262,  -23.4549427,   68.7046967,  -3.63636374
   7263,  -23.4549427,   68.7046967,   -4.5454545
   7264,  -23.4549427,   68.7046967,   -5.4545455
   7265,  -23.4549427,   68.7046967,  -6.36363649
   7266,  -23.4549427,   68.7046967,  -7.27272749
   7267,  -23.4549427,   68.7046967,  -8.18181801
   7268,  -23.4549427,   68.7046967,    -9.090909
   7269,  -24.0424099,   67.9433136, -0.909090936
   7270,  -24.0424099,   67.9433136,  -1.81818187
   7271,  -24.0424099,   67.9433136,  -2.72727275
   7272,  -24.0424099,   67.9433136,  -3.63636374
   7273,  -24.0424099,   67.9433136,   -4.5454545
   7274,  -24.0424099,   67.9433136,   -5.4545455
   7275,  -24.0424099,   67.9433136,  -6.36363649
   7276,  -24.0424099,   67.9433136,  -7.27272749
   7277,  -24.0424099,   67.9433136,  -8.18181801
   7278,  -24.0424099,   67.9433136,    -9.090909
   7279,  -24.6051693,   67.1634979, -0.909090936
   7280,  -24.6051693,   67.1634979,  -1.81818187
   7281,  -24.6051693,   67.1634979,  -2.72727275
   7282,  -24.6051693,   67.1634979,  -3.63636374
   7283,  -24.6051693,   67.1634979,   -4.5454545
   7284,  -24.6051693,   67.1634979,   -5.4545455
   7285,  -24.6051693,   67.1634979,  -6.36363649
   7286,  -24.6051693,   67.1634979,  -7.27272749
   7287,  -24.6051693,   67.1634979,  -8.18181801
   7288,  -24.6051693,   67.1634979,    -9.090909
   7289,  -25.1426411,   66.3660507, -0.909090936
   7290,  -25.1426411,   66.3660507,  -1.81818187
   7291,  -25.1426411,   66.3660507,  -2.72727275
   7292,  -25.1426411,   66.3660507,  -3.63636374
   7293,  -25.1426411,   66.3660507,   -4.5454545
   7294,  -25.1426411,   66.3660507,   -5.4545455
   7295,  -25.1426411,   66.3660507,  -6.36363649
   7296,  -25.1426411,   66.3660507,  -7.27272749
   7297,  -25.1426411,   66.3660507,  -8.18181801
   7298,  -25.1426411,   66.3660507,    -9.090909
   7299,  -25.6542816,   65.5517807, -0.909090936
   7300,  -25.6542816,   65.5517807,  -1.81818187
   7301,  -25.6542816,   65.5517807,  -2.72727275
   7302,  -25.6542816,   65.5517807,  -3.63636374
   7303,  -25.6542816,   65.5517807,   -4.5454545
   7304,  -25.6542816,   65.5517807,   -5.4545455
   7305,  -25.6542816,   65.5517807,  -6.36363649
   7306,  -25.6542816,   65.5517807,  -7.27272749
   7307,  -25.6542816,   65.5517807,  -8.18181801
   7308,  -25.6542816,   65.5517807,    -9.090909
   7309,  -26.1395607,   64.7215271, -0.909090936
   7310,  -26.1395607,   64.7215271,  -1.81818187
   7311,  -26.1395607,   64.7215271,  -2.72727275
   7312,  -26.1395607,   64.7215271,  -3.63636374
   7313,  -26.1395607,   64.7215271,   -4.5454545
   7314,  -26.1395607,   64.7215271,   -5.4545455
   7315,  -26.1395607,   64.7215271,  -6.36363649
   7316,  -26.1395607,   64.7215271,  -7.27272749
   7317,  -26.1395607,   64.7215271,  -8.18181801
   7318,  -26.1395607,   64.7215271,    -9.090909
   7319,  -26.5979786,   63.8761482, -0.909090936
   7320,  -26.5979786,   63.8761482,  -1.81818187
   7321,  -26.5979786,   63.8761482,  -2.72727275
   7322,  -26.5979786,   63.8761482,  -3.63636374
   7323,  -26.5979786,   63.8761482,   -4.5454545
   7324,  -26.5979786,   63.8761482,   -5.4545455
   7325,  -26.5979786,   63.8761482,  -6.36363649
   7326,  -26.5979786,   63.8761482,  -7.27272749
   7327,  -26.5979786,   63.8761482,  -8.18181801
   7328,  -26.5979786,   63.8761482,    -9.090909
   7329,  -27.0290661,   63.0165138, -0.909090936
   7330,  -27.0290661,   63.0165138,  -1.81818187
   7331,  -27.0290661,   63.0165138,  -2.72727275
   7332,  -27.0290661,   63.0165138,  -3.63636374
   7333,  -27.0290661,   63.0165138,   -4.5454545
   7334,  -27.0290661,   63.0165138,   -5.4545455
   7335,  -27.0290661,   63.0165138,  -6.36363649
   7336,  -27.0290661,   63.0165138,  -7.27272749
   7337,  -27.0290661,   63.0165138,  -8.18181801
   7338,  -27.0290661,   63.0165138,    -9.090909
   7339,  -27.4323788,   62.1435013, -0.909090936
   7340,  -27.4323788,   62.1435013,  -1.81818187
   7341,  -27.4323788,   62.1435013,  -2.72727275
   7342,  -27.4323788,   62.1435013,  -3.63636374
   7343,  -27.4323788,   62.1435013,   -4.5454545
   7344,  -27.4323788,   62.1435013,   -5.4545455
   7345,  -27.4323788,   62.1435013,  -6.36363649
   7346,  -27.4323788,   62.1435013,  -7.27272749
   7347,  -27.4323788,   62.1435013,  -8.18181801
   7348,  -27.4323788,   62.1435013,    -9.090909
   7349,  -27.8075027,   61.2580109, -0.909090936
   7350,  -27.8075027,   61.2580109,  -1.81818187
   7351,  -27.8075027,   61.2580109,  -2.72727275
   7352,  -27.8075027,   61.2580109,  -3.63636374
   7353,  -27.8075027,   61.2580109,   -4.5454545
   7354,  -27.8075027,   61.2580109,   -5.4545455
   7355,  -27.8075027,   61.2580109,  -6.36363649
   7356,  -27.8075027,   61.2580109,  -7.27272749
   7357,  -27.8075027,   61.2580109,  -8.18181801
   7358,  -27.8075027,   61.2580109,    -9.090909
   7359,  -28.1540527,   60.3609505, -0.909090936
   7360,  -28.1540527,   60.3609505,  -1.81818187
   7361,  -28.1540527,   60.3609505,  -2.72727275
   7362,  -28.1540527,   60.3609505,  -3.63636374
   7363,  -28.1540527,   60.3609505,   -4.5454545
   7364,  -28.1540527,   60.3609505,   -5.4545455
   7365,  -28.1540527,   60.3609505,  -6.36363649
   7366,  -28.1540527,   60.3609505,  -7.27272749
   7367,  -28.1540527,   60.3609505,  -8.18181801
   7368,  -28.1540527,   60.3609505,    -9.090909
   7369,  -28.4716721,   59.4532471, -0.909090936
   7370,  -28.4716721,   59.4532471,  -1.81818187
   7371,  -28.4716721,   59.4532471,  -2.72727275
   7372,  -28.4716721,   59.4532471,  -3.63636374
   7373,  -28.4716721,   59.4532471,   -4.5454545
   7374,  -28.4716721,   59.4532471,   -5.4545455
   7375,  -28.4716721,   59.4532471,  -6.36363649
   7376,  -28.4716721,   59.4532471,  -7.27272749
   7377,  -28.4716721,   59.4532471,  -8.18181801
   7378,  -28.4716721,   59.4532471,    -9.090909
   7379,  -28.7600365,   58.5358276, -0.909090936
   7380,  -28.7600365,   58.5358276,  -1.81818187
   7381,  -28.7600365,   58.5358276,  -2.72727275
   7382,  -28.7600365,   58.5358276,  -3.63636374
   7383,  -28.7600365,   58.5358276,   -4.5454545
   7384,  -28.7600365,   58.5358276,   -5.4545455
   7385,  -28.7600365,   58.5358276,  -6.36363649
   7386,  -28.7600365,   58.5358276,  -7.27272749
   7387,  -28.7600365,   58.5358276,  -8.18181801
   7388,  -28.7600365,   58.5358276,    -9.090909
   7389,  -29.0188465,   57.6096382, -0.909090936
   7390,  -29.0188465,   57.6096382,  -1.81818187
   7391,  -29.0188465,   57.6096382,  -2.72727275
   7392,  -29.0188465,   57.6096382,  -3.63636374
   7393,  -29.0188465,   57.6096382,   -4.5454545
   7394,  -29.0188465,   57.6096382,   -5.4545455
   7395,  -29.0188465,   57.6096382,  -6.36363649
   7396,  -29.0188465,   57.6096382,  -7.27272749
   7397,  -29.0188465,   57.6096382,  -8.18181801
   7398,  -29.0188465,   57.6096382,    -9.090909
   7399,  -29.2478371,   56.6756287, -0.909090936
   7400,  -29.2478371,   56.6756287,  -1.81818187
   7401,  -29.2478371,   56.6756287,  -2.72727275
   7402,  -29.2478371,   56.6756287,  -3.63636374
   7403,  -29.2478371,   56.6756287,   -4.5454545
   7404,  -29.2478371,   56.6756287,   -5.4545455
   7405,  -29.2478371,   56.6756287,  -6.36363649
   7406,  -29.2478371,   56.6756287,  -7.27272749
   7407,  -29.2478371,   56.6756287,  -8.18181801
   7408,  -29.2478371,   56.6756287,    -9.090909
   7409,  -29.4467735,   55.7347603, -0.909090936
   7410,  -29.4467735,   55.7347603,  -1.81818187
   7411,  -29.4467735,   55.7347603,  -2.72727275
   7412,  -29.4467735,   55.7347603,  -3.63636374
   7413,  -29.4467735,   55.7347603,   -4.5454545
   7414,  -29.4467735,   55.7347603,   -5.4545455
   7415,  -29.4467735,   55.7347603,  -6.36363649
   7416,  -29.4467735,   55.7347603,  -7.27272749
   7417,  -29.4467735,   55.7347603,  -8.18181801
   7418,  -29.4467735,   55.7347603,    -9.090909
   7419,  -29.6154537,   54.7879982, -0.909090936
   7420,  -29.6154537,   54.7879982,  -1.81818187
   7421,  -29.6154537,   54.7879982,  -2.72727275
   7422,  -29.6154537,   54.7879982,  -3.63636374
   7423,  -29.6154537,   54.7879982,   -4.5454545
   7424,  -29.6154537,   54.7879982,   -5.4545455
   7425,  -29.6154537,   54.7879982,  -6.36363649
   7426,  -29.6154537,   54.7879982,  -7.27272749
   7427,  -29.6154537,   54.7879982,  -8.18181801
   7428,  -29.6154537,   54.7879982,    -9.090909
   7429,  -29.7537003,   53.8363152, -0.909090936
   7430,  -29.7537003,   53.8363152,  -1.81818187
   7431,  -29.7537003,   53.8363152,  -2.72727275
   7432,  -29.7537003,   53.8363152,  -3.63636374
   7433,  -29.7537003,   53.8363152,   -4.5454545
   7434,  -29.7537003,   53.8363152,   -5.4545455
   7435,  -29.7537003,   53.8363152,  -6.36363649
   7436,  -29.7537003,   53.8363152,  -7.27272749
   7437,  -29.7537003,   53.8363152,  -8.18181801
   7438,  -29.7537003,   53.8363152,    -9.090909
   7439,  -29.8613739,   52.8806915, -0.909090936
   7440,  -29.8613739,   52.8806915,  -1.81818187
   7441,  -29.8613739,   52.8806915,  -2.72727275
   7442,  -29.8613739,   52.8806915,  -3.63636374
   7443,  -29.8613739,   52.8806915,   -4.5454545
   7444,  -29.8613739,   52.8806915,   -5.4545455
   7445,  -29.8613739,   52.8806915,  -6.36363649
   7446,  -29.8613739,   52.8806915,  -7.27272749
   7447,  -29.8613739,   52.8806915,  -8.18181801
   7448,  -29.8613739,   52.8806915,    -9.090909
   7449,  -29.9383621,   51.9221077, -0.909090936
   7450,  -29.9383621,   51.9221077,  -1.81818187
   7451,  -29.9383621,   51.9221077,  -2.72727275
   7452,  -29.9383621,   51.9221077,  -3.63636374
   7453,  -29.9383621,   51.9221077,   -4.5454545
   7454,  -29.9383621,   51.9221077,   -5.4545455
   7455,  -29.9383621,   51.9221077,  -6.36363649
   7456,  -29.9383621,   51.9221077,  -7.27272749
   7457,  -29.9383621,   51.9221077,  -8.18181801
   7458,  -29.9383621,   51.9221077,    -9.090909
   7459,  -29.9845867,   50.9615479, -0.909090936
   7460,  -29.9845867,   50.9615479,  -1.81818187
   7461,  -29.9845867,   50.9615479,  -2.72727275
   7462,  -29.9845867,   50.9615479,  -3.63636374
   7463,  -29.9845867,   50.9615479,   -4.5454545
   7464,  -29.9845867,   50.9615479,   -5.4545455
   7465,  -29.9845867,   50.9615479,  -6.36363649
   7466,  -29.9845867,   50.9615479,  -7.27272749
   7467,  -29.9845867,   50.9615479,  -8.18181801
   7468,  -29.9845867,   50.9615479,    -9.090909
   7469,   20.8983479,   50.6701698,           0.
   7470,   21.8069725,   50.6993065,           0.
   7471,   22.7155952,   50.7284431,           0.
   7472,   23.6242199,   50.7575836,           0.
   7473,   24.5328426,   50.7867203,           0.
   7474,   25.4414673,   50.8158569,           0.
   7475,   26.3500919,   50.8449974,           0.
   7476,   27.2587147,   50.8741341,           0.
   7477,   28.1673393,   50.9032707,           0.
   7478,   29.0759621,   50.9324112,           0.
   7479,   20.8661308,   51.3396492,           0.
   7480,   21.7733536,   51.3978958,           0.
   7481,   22.6805763,   51.4561424,           0.
   7482,    23.587801,   51.5143852,           0.
   7483,   24.4950237,   51.5726318,           0.
   7484,   25.4022465,   51.6308784,           0.
   7485,   26.3094692,   51.6891251,           0.
   7486,    27.216692,   51.7473679,           0.
   7487,   28.1239147,   51.8056145,           0.
   7488,   29.0311394,   51.8638611,           0.
   7489,   20.8124733,   52.0077553,           0.
   7490,   21.7173634,    52.095047,           0.
   7491,   22.6222534,   52.1823425,           0.
   7492,   23.5271435,   52.2696342,           0.
   7493,   24.4320335,   52.3569298,           0.
   7494,   25.3369236,   52.4442215,           0.
   7495,   26.2418137,    52.531517,           0.
   7496,   27.1467037,   52.6188087,           0.
   7497,   28.0515938,   52.7061043,           0.
   7498,   28.9564838,    52.793396,           0.
   7499,   20.7374268,   52.6737938,           0.
   7500,   21.6390553,   52.7900467,           0.
   7501,   22.5406818,   52.9062996,           0.
   7502,   23.4423103,   53.0225525,           0.
   7503,   24.3439369,   53.1388016,           0.
   7504,   25.2455635,   53.2550545,           0.
   7505,    26.147192,   53.3713074,           0.
   7506,   27.0488186,   53.4875603,           0.
   7507,   27.9504452,   53.6038094,           0.
   7508,   28.8520737,   53.7200623,           0.
   7509,   20.6410732,   53.3370895,           0.
   7510,   21.5385113,   53.4821777,           0.
   7511,   22.4359493,   53.6272697,           0.
   7512,   23.3333874,   53.7723618,           0.
   7513,   24.2308254,   53.9174538,           0.
   7514,   25.1282635,    54.062542,           0.
   7515,   26.0257015,    54.207634,           0.
   7516,   26.9231396,    54.352726,           0.
   7517,   27.8205776,   54.4978142,           0.
   7518,   28.7180157,   54.6429062,           0.
   7519,     20.52351,   53.9969521,           0.
   7520,   21.4158363,   54.1707344,           0.
   7521,   22.3081627,   54.3445129,           0.
   7522,    23.200489,   54.5182953,           0.
   7523,   24.0928154,   54.6920738,           0.
   7524,   24.9851418,   54.8658562,           0.
   7525,   25.8774681,   55.0396347,           0.
   7526,   26.7697945,   55.2134171,           0.
   7527,   27.6621208,   55.3871994,           0.
   7528,   28.5544491,   55.5609779,           0.
   7529,   20.3848572,     54.65271,           0.
   7530,   21.2711544,   54.8550034,           0.
   7531,   22.1574516,   55.0572929,           0.
   7532,   23.0437508,   55.2595863,           0.
   7533,    23.930048,   55.4618759,           0.
   7534,   24.8163471,   55.6641693,           0.
   7535,   25.7026443,   55.8664627,           0.
   7536,   26.5889435,   56.0687523,           0.
   7537,   27.4752407,   56.2710457,           0.
   7538,   28.3615398,   56.4733353,           0.
   7539,    20.225256,    55.303688,           0.
   7540,   21.1046143,   55.5342827,           0.
   7541,   21.9839745,   55.7648773,           0.
   7542,   22.8633327,    55.995472,           0.
   7543,   23.7426929,   56.2260666,           0.
   7544,   24.6220512,   56.4566612,           0.
   7545,   25.5014095,   56.6872559,           0.
   7546,   26.3807697,   56.9178505,           0.
   7547,    27.260128,   57.1484489,           0.
   7548,   28.1394863,   57.3790436,           0.
   7549,   20.0448742,   55.9492149,           0.
   7550,   20.9163895,   56.2078743,           0.
   7551,   21.7879066,   56.4665375,           0.
   7552,   22.6594219,   56.7251968,           0.
   7553,   23.5309391,     56.98386,           0.
   7554,   24.4024544,   57.2425194,           0.
   7555,   25.2739716,   57.5011826,           0.
   7556,   26.1454868,   57.7598419,           0.
   7557,    27.017004,   58.0185051,           0.
   7558,   27.8885193,   58.2771645,           0.
   7559,   19.8438931,   56.5886269,           0.
   7560,   20.7066708,   56.8750877,           0.
   7561,   21.5694485,   57.1615486,           0.
   7562,   22.4322262,   57.4480133,           0.
   7563,   23.2950039,   57.7344742,           0.
   7564,   24.1577835,   58.0209351,           0.
   7565,   25.0205612,   58.3073997,           0.
   7566,   25.8833389,   58.5938606,           0.
   7567,   26.7461166,   58.8803215,           0.
   7568,   27.6088943,   59.1667862,           0.
   7569,   19.6225224,   57.2212677,           0.
   7570,   20.4756756,   57.5352364,           0.
   7571,   21.3288269,    57.849205,           0.
   7572,   22.1819801,   58.1631737,           0.
   7573,   23.0351334,   58.4771423,           0.
   7574,   23.8882866,    58.791111,           0.
   7575,   24.7414398,   59.1050797,           0.
   7576,    25.594593,   59.4190483,           0.
   7577,   26.4477463,    59.733017,           0.
   7578,   27.3008995,   60.0469818,           0.
   7579,   19.3809872,   57.8464928,           0.
   7580,   20.2236385,    58.187645,           0.
   7581,   21.0662899,   58.5287971,           0.
   7582,   21.9089413,   58.8699455,           0.
   7583,   22.7515926,   59.2110977,           0.
   7584,    23.594244,   59.5522499,           0.
   7585,   24.4368973,   59.8934021,           0.
   7586,   25.2795486,   60.2345543,           0.
   7587,      26.1222,   60.5757065,           0.
   7588,   26.9648514,   60.9168587,           0.
   7589,   19.1195374,   58.4636536,           0.
   7590,   19.9508209,   58.8316383,           0.
   7591,   20.7821045,   59.1996231,           0.
   7592,     21.61339,   59.5676079,           0.
   7593,   22.4446735,   59.9355927,           0.
   7594,   23.2759571,   60.3035774,           0.
   7595,   24.1072426,   60.6715622,           0.
   7596,   24.9385262,    61.039547,           0.
   7597,   25.7698097,   61.4075317,           0.
   7598,   26.6010952,   61.7755165,           0.
   7599,   18.8384399,    59.072113,           0.
   7600,   19.6575031,   59.4665527,           0.
   7601,   20.4765644,   59.8609924,           0.
   7602,   21.2956276,   60.2554321,           0.
   7603,   22.1146908,   60.6498718,           0.
   7604,   22.9337521,   61.0443115,           0.
   7605,   23.7528152,   61.4387512,           0.
   7606,   24.5718784,   61.8331947,           0.
   7607,   25.3909416,   62.2276344,           0.
   7608,   26.2100029,   62.6220741,           0.
   7609,   18.5379848,    59.671257,           0.
   7610,   19.3439846,   60.0917435,           0.
   7611,   20.1499844,   60.5122337,           0.
   7612,   20.9559841,    60.932724,           0.
   7613,   21.7619839,   61.3532143,           0.
   7614,   22.5679817,   61.7737007,           0.
   7615,   23.3739815,    62.194191,           0.
   7616,   24.1799812,   62.6146812,           0.
   7617,    24.985981,   63.0351715,           0.
   7618,   25.7919807,    63.455658,           0.
   7619,   18.2184811,   60.2604561,           0.
   7620,   19.0105896,   60.7065659,           0.
   7621,   19.8026981,   61.1526718,           0.
   7622,   20.5948067,   61.5987778,           0.
   7623,   21.3869133,   62.0448837,           0.
   7624,   22.1790218,   62.4909935,           0.
   7625,   22.9711304,   62.9370995,           0.
   7626,    23.763237,   63.3832054,           0.
   7627,   24.5553455,   63.8293114,           0.
   7628,   25.3474541,   64.2754211,           0.
   7629,   17.8802586,    60.839119,           0.
   7630,   18.6576595,   61.3103828,           0.
   7631,   19.4350624,   61.7816505,           0.
   7632,   20.2124653,   62.2529144,           0.
   7633,   20.9898682,   62.7241821,           0.
   7634,    21.767271,    63.195446,           0.
   7635,    22.544672,   63.6667137,           0.
   7636,   23.3220749,   64.1379776,           0.
   7637,   24.0994778,   64.6092453,           0.
   7638,   24.8768806,    65.080513,           0.
   7639,   17.5236607,   61.4066391,           0.
   7640,   18.2855587,   61.9025803,           0.
   7641,   19.0474567,   62.3985214,           0.
   7642,   19.8093548,   62.8944626,           0.
   7643,   20.5712528,   63.3904037,           0.
   7644,   21.3331509,   63.8863411,           0.
   7645,   22.0950508,   64.3822861,           0.
   7646,   22.8569489,   64.8782272,           0.
   7647,   23.6188469,   65.3741684,           0.
   7648,   24.3807449,   65.8701096,           0.
   7649,   17.1490555,   61.9624405,           0.
   7650,   17.8946667,   62.4825439,           0.
   7651,   18.6402779,   63.0026512,           0.
   7652,   19.3858891,   63.5227585,           0.
   7653,   20.1315002,   64.0428619,           0.
   7654,   20.8771114,    64.562973,           0.
   7655,   21.6227226,   65.0830765,           0.
   7656,   22.3683338,   65.6031799,           0.
   7657,    23.113945,    66.123291,           0.
   7658,   23.8595562,   66.6433945,           0.
   7659,   16.7568302,   62.5059471,           0.
   7660,   17.4853878,   63.0496826,           0.
   7661,   18.2139454,   63.5934219,           0.
   7662,    18.942503,   64.1371613,           0.
   7663,   19.6710625,   64.6808929,           0.
   7664,   20.3996201,   65.2246323,           0.
   7665,   21.1281776,   65.7683716,           0.
   7666,   21.8567352,   66.3121033,           0.
   7667,   22.5852928,   66.8558426,           0.
   7668,   23.3138504,   67.3995819,           0.
   7669,   16.3473854,   63.0366058,           0.
   7670,   17.0581417,   63.6034126,           0.
   7671,    17.768898,   64.1702194,           0.
   7672,   18.4796524,     64.73703,           0.
   7673,   19.1904087,   65.3038406,           0.
   7674,    19.901165,   65.8706512,           0.
   7675,   20.6119213,   66.4374619,           0.
   7676,   21.3226776,   67.0042648,           0.
   7677,    22.033432,   67.5710754,           0.
   7678,   22.7441883,    68.137886,           0.
   7679,   15.9211426,   63.5538673,           0.
   7680,   16.6133671,   64.1431656,           0.
   7681,   17.3055897,     64.73246,           0.
   7682,   17.9978142,   65.3217621,           0.
   7683,   18.6900368,   65.9110641,           0.
   7684,   19.3822613,   66.5003586,           0.
   7685,   20.0744839,   67.0896606,           0.
   7686,   20.7667084,   67.6789551,           0.
   7687,    21.458931,   68.2682571,           0.
   7688,   22.1511555,   68.8575516,           0.
   7689,   15.4785395,   64.0571976,           0.
   7690,   16.1515198,   64.6683807,           0.
   7691,   16.8244991,   65.2795639,           0.
   7692,   17.4974804,   65.8907471,           0.
   7693,   18.1704597,   66.5019302,           0.
   7694,   18.8434391,   67.1131134,           0.
   7695,   19.5164204,   67.7242966,           0.
   7696,   20.1893997,   68.3354797,           0.
   7697,   20.8623791,   68.9466629,           0.
   7698,   21.5353603,   69.5578461,           0.
   7699,   15.0200319,   64.5460892,           0.
   7700,   15.6730766,   65.1785278,           0.
   7701,   16.3261223,   65.8109665,           0.
   7702,    16.979166,   66.4434052,           0.
   7703,   17.6322117,   67.0758438,           0.
   7704,   18.2852554,   67.7082825,           0.
   7705,   18.9383011,   68.3407211,           0.
   7706,   19.5913467,   68.9731598,           0.
   7707,   20.2443905,   69.6055984,           0.
   7708,   20.8974361,   70.2380371,           0.
   7709,   14.5460901,   65.0200348,           0.
   7710,   15.1785288,   65.6730804,           0.
   7711,   15.8109674,   66.3261185,           0.
   7712,   16.4434052,   66.9791641,           0.
   7713,   17.0758438,   67.6322098,           0.
   7714,   17.7082825,   68.2852554,           0.
   7715,   18.3407211,   68.9383011,           0.
   7716,   18.9731598,   69.5913467,           0.
   7717,   19.6055984,   70.2443924,           0.
   7718,   20.2380371,    70.897438,           0.
   7719,   14.0572004,   65.4785385,           0.
   7720,   14.6683826,   66.1515198,           0.
   7721,   15.2795658,    66.824501,           0.
   7722,    15.890748,   67.4974823,           0.
   7723,   16.5019302,   68.1704636,           0.
   7724,   17.1131134,   68.8434372,           0.
   7725,   17.7242966,   69.5164185,           0.
   7726,   18.3354797,   70.1893997,           0.
   7727,    18.946661,    70.862381,           0.
   7728,   19.5578442,   71.5353622,           0.
   7729,   13.5538664,   65.9211426,           0.
   7730,   14.1431646,   66.6133652,           0.
   7731,   14.7324638,   67.3055878,           0.
   7732,   15.3217621,   67.9978104,           0.
   7733,   15.9110603,   68.6900406,           0.
   7734,   16.5003586,   69.3822632,           0.
   7735,   17.0896568,   70.0744858,           0.
   7736,    17.678957,   70.7667084,           0.
   7737,   18.2682552,    71.458931,           0.
   7738,   18.8575535,   72.1511536,           0.
   7739,   13.0366049,   66.3473892,           0.
   7740,   13.6034136,   67.0581436,           0.
   7741,   14.1702232,    67.768898,           0.
   7742,   14.7370319,   68.4796524,           0.
   7743,   15.3038406,   69.1904068,           0.
   7744,   15.8706493,   69.9011612,           0.
   7745,    16.437458,   70.6119232,           0.
   7746,   17.0042667,   71.3226776,           0.
   7747,   17.5710754,    72.033432,           0.
   7748,    18.137886,   72.7441864,           0.
   7749,   12.5059471,   66.7568283,           0.
   7750,   13.0496845,   67.4853897,           0.
   7751,    13.593421,   68.2139435,           0.
   7752,   14.1371584,   68.9425049,           0.
   7753,   14.6808949,   69.6710587,           0.
   7754,   15.2246313,   70.3996201,           0.
   7755,   15.7683687,   71.1281738,           0.
   7756,   16.3121052,   71.8567352,           0.
   7757,   16.8558426,   72.5852966,           0.
   7758,     17.39958,   73.3138504,           0.
   7759,   11.9624395,   67.1490555,           0.
   7760,   12.4825449,   67.8946686,           0.
   7761,   13.0026512,   68.6402817,           0.
   7762,   13.5227575,   69.3858871,           0.
   7763,   14.0428638,   70.1315002,           0.
   7764,   14.5629692,   70.8771133,           0.
   7765,   15.0830755,   71.6227264,           0.
   7766,   15.6031818,   72.3683319,           0.
   7767,   16.1232872,    73.113945,           0.
   7768,   16.6433945,   73.8595581,           0.
   7769,   11.4066391,   67.5236588,           0.
   7770,   11.9025793,   68.2855606,           0.
   7771,   12.3985205,   69.0474548,           0.
   7772,   12.8944616,   69.8093567,           0.
   7773,   13.3904018,   70.5712509,           0.
   7774,    13.886343,   71.3331528,           0.
   7775,   14.3822842,    72.095047,           0.
   7776,   14.8782244,   72.8569489,           0.
   7777,   15.3741655,   73.6188431,           0.
   7778,   15.8701057,   74.3807449,           0.
   7779,   10.8391171,   67.8802567,           0.
   7780,   11.3103828,   68.6576614,           0.
   7781,   11.7816496,   69.4350662,           0.
   7782,   12.2529154,   70.2124634,           0.
   7783,   12.7241812,   70.9898682,           0.
   7784,    13.195447,   71.7672729,           0.
   7785,   13.6667128,   72.5446701,           0.
   7786,   14.1379795,   73.3220749,           0.
   7787,   14.6092453,   74.0994797,           0.
   7788,   15.0805111,   74.8768768,           0.
   7789,    10.260458,    68.218483,           0.
   7790,   10.7065649,   69.0105896,           0.
   7791,   11.1526718,   69.8026962,           0.
   7792,   11.5987787,   70.5948029,           0.
   7793,   12.0448856,   71.3869171,           0.
   7794,   12.4909925,   72.1790237,           0.
   7795,   12.9370995,   72.9711304,           0.
   7796,   13.3832064,    73.763237,           0.
   7797,   13.8293133,   74.5553436,           0.
   7798,   14.2754192,   75.3474503,           0.
   7799,   9.67125511,   68.5379868,           0.
   7800,   10.0917444,   69.3439865,           0.
   7801,   10.5122337,   70.1499863,           0.
   7802,    10.932723,    70.955986,           0.
   7803,   11.3532124,   71.7619858,           0.
   7804,   11.7737017,   72.5679855,           0.
   7805,    12.194191,   73.3739853,           0.
   7806,   12.6146803,   74.1799774,           0.
   7807,   13.0351696,   74.9859772,           0.
   7808,   13.4556589,   75.7919769,           0.
   7809,   9.07211494,   68.8384399,           0.
   7810,   9.46655464,   69.6575012,           0.
   7811,   9.86099434,   70.4765625,           0.
   7812,    10.255434,   71.2956314,           0.
   7813,   10.6498737,   72.1146927,           0.
   7814,   11.0443134,    72.933754,           0.
   7815,   11.4387531,   73.7528152,           0.
   7816,   11.8331928,   74.5718765,           0.
   7817,   12.2276325,   75.3909378,           0.
   7818,   12.6220722,   76.2100067,           0.
   7819,   8.46365166,   69.1195374,           0.
   7820,   8.83163643,   69.9508209,           0.
   7821,    9.1996212,   70.7821045,           0.
   7822,   9.56760597,   71.6133881,           0.
   7823,   9.93559074,   72.4446716,           0.
   7824,   10.3035765,   73.2759552,           0.
   7825,   10.6715612,   74.1072388,           0.
   7826,    11.039546,   74.9385223,           0.
   7827,   11.4075308,   75.7698135,           0.
   7828,   11.7755156,   76.6010971,           0.
   7829,   7.84649181,   69.3809891,           0.
   7830,     8.187644,   70.2236404,           0.
   7831,   8.52879524,   71.0662918,           0.
   7832,   8.86994743,   71.9089432,           0.
   7833,   9.21109962,   72.7515945,           0.
   7834,   9.55225086,   73.5942459,           0.
   7835,   9.89340305,   74.4368973,           0.
   7836,   10.2345543,   75.2795486,           0.
   7837,   10.5757065,      76.1222,           0.
   7838,   10.9168587,   76.9648514,           0.
   7839,   7.22126913,   69.6225204,           0.
   7840,   7.53523779,   70.4756775,           0.
   7841,   7.84920597,   71.3288269,           0.
   7842,   8.16317368,   72.1819839,           0.
   7843,   8.47714233,   73.0351334,           0.
   7844,   8.79111004,   73.8882904,           0.
   7845,    9.1050787,   74.7414398,           0.
   7846,   9.41904736,   75.5945969,           0.
   7847,   9.73301506,   76.4477463,           0.
   7848,   10.0469837,   77.3009033,           0.
   7849,   6.58862638,    69.843895,           0.
   7850,   6.87508821,   70.7066727,           0.
   7851,   7.16155052,   71.5694504,           0.
   7852,   7.44801235,   72.4322281,           0.
   7853,   7.73447466,   73.2950058,           0.
   7854,   8.02093601,   74.1577835,           0.
   7855,    8.3073988,   75.0205612,           0.
   7856,   8.59386063,   75.8833389,           0.
   7857,   8.88032246,   76.7461166,           0.
   7858,   9.16678429,   77.6088943,           0.
   7859,   5.94921303,   70.0448761,           0.
   7860,   6.20787477,   70.9163895,           0.
   7861,   6.46653605,   71.7879028,           0.
   7862,   6.72519732,   72.6594238,           0.
   7863,   6.98385906,   73.5309372,           0.
   7864,   7.24252033,   74.4024582,           0.
   7865,    7.5011816,   75.2739716,           0.
   7866,   7.75984335,   76.1454849,           0.
   7867,    8.0185051,   77.0170059,           0.
   7868,   8.27716637,   77.8885193,           0.
   7869,   5.30368662,   70.2252579,           0.
   7870,   5.53428173,   71.1046143,           0.
   7871,   5.76487684,   71.9839706,           0.
   7872,   5.99547195,   72.8633347,           0.
   7873,   6.22606707,    73.742691,           0.
   7874,   6.45666218,   74.6220474,           0.
   7875,   6.68725729,   75.5014114,           0.
   7876,    6.9178524,   76.3807678,           0.
   7877,   7.14844751,   77.2601242,           0.
   7878,   7.37904263,   78.1394882,           0.
   7879,   4.65271044,   70.3848572,           0.
   7880,    4.8550024,   71.2711563,           0.
   7881,   5.05729389,   72.1574554,           0.
   7882,   5.25958586,   73.0437469,           0.
   7883,   5.46187735,   73.9300461,           0.
   7884,   5.66416931,   74.8163452,           0.
   7885,    5.8664608,   75.7026443,           0.
   7886,   6.06875277,   76.5889435,           0.
   7887,   6.27104473,   77.4752426,           0.
   7888,   6.47333622,   78.3615417,           0.
   7889,   3.99695325,   70.5235062,           0.
   7890,   4.17073393,   71.4158325,           0.
   7891,   4.34451437,   72.3081589,           0.
   7892,   4.51829481,   73.2004929,           0.
   7893,   4.69207525,   74.0928192,           0.
   7894,   4.86585617,   74.9851456,           0.
   7895,   5.03963661,   75.8774719,           0.
   7896,   5.21341705,   76.7697983,           0.
   7897,   5.38719749,   77.6621246,           0.
   7898,   5.56097841,    78.554451,           0.
   7899,   3.33708882,   70.6410751,           0.
   7900,   3.48217964,   71.5385132,           0.
   7901,   3.62727046,   72.4359512,           0.
   7902,   3.77236104,   73.3333893,           0.
   7903,   3.91745186,   74.2308273,           0.
   7904,   4.06254292,   75.1282654,           0.
   7905,    4.2076335,   76.0257034,           0.
   7906,   4.35272455,   76.9231415,           0.
   7907,   4.49781513,   77.8205795,           0.
   7908,   4.64290619,   78.7180176,           0.
   7909,   2.67379522,   70.7374268,           0.
   7910,   2.79004717,   71.6390533,           0.
   7911,   2.90629911,   72.5406799,           0.
   7912,   3.02255106,   73.4423065,           0.
   7913,   3.13880301,   74.3439331,           0.
   7914,   3.25505495,   75.2455673,           0.
   7915,    3.3713069,   76.1471939,           0.
   7916,   3.48755884,   77.0488205,           0.
   7917,   3.60381103,   77.9504471,           0.
   7918,   3.72006297,   78.8520737,           0.
   7919,   2.00775409,   70.8124695,           0.
   7920,   2.09504795,   71.7173615,           0.
   7921,   2.18234158,   72.6222534,           0.
   7922,    2.2696352,   73.5271454,           0.
   7923,   2.35692883,   74.4320297,           0.
   7924,   2.44422245,   75.3369217,           0.
   7925,   2.53151608,   76.2418137,           0.
   7926,    2.6188097,   77.1467056,           0.
   7927,   2.70610356,     78.05159,           0.
   7928,   2.79339719,   78.9564819,           0.
   7929,   1.33965003,   70.8661346,           0.
   7930,   1.39789569,   71.7733536,           0.
   7931,   1.45614135,   72.6805801,           0.
   7932,   1.51438701,   73.5877991,           0.
   7933,   1.57263267,   74.4950256,           0.
   7934,   1.63087833,   75.4022446,           0.
   7935,   1.68912399,   76.3094711,           0.
   7936,   1.74736965,   77.2166901,           0.
   7937,   1.80561531,   78.1239166,           0.
   7938,   1.86386096,   79.0311356,           0.
   7939,  0.670169353,   70.8983459,           0.
   7940,  0.699307144,   71.8069687,           0.
   7941,  0.728444934,   72.7155991,           0.
   7942,  0.757582724,   73.6242218,           0.
   7943,  0.786720514,   74.5328445,           0.
   7944,  0.815858364,   75.4414673,           0.
   7945,  0.844996154,     76.35009,           0.
   7946,  0.874133945,   77.2587128,           0.
   7947,  0.903271735,   78.1673355,           0.
   7948,  0.932409525,   79.0759659,           0.
   7949, -0.670169353,   70.8983459,           0.
   7950, -0.699307144,   71.8069687,           0.
   7951, -0.728444934,   72.7155991,           0.
   7952, -0.757582724,   73.6242218,           0.
   7953, -0.786720514,   74.5328445,           0.
   7954, -0.815858364,   75.4414673,           0.
   7955, -0.844996154,     76.35009,           0.
   7956, -0.874133945,   77.2587128,           0.
   7957, -0.903271735,   78.1673355,           0.
   7958, -0.932409525,   79.0759659,           0.
   7959,  -1.33965003,   70.8661346,           0.
   7960,  -1.39789569,   71.7733536,           0.
   7961,  -1.45614135,   72.6805801,           0.
   7962,  -1.51438701,   73.5877991,           0.
   7963,  -1.57263267,   74.4950256,           0.
   7964,  -1.63087833,   75.4022446,           0.
   7965,  -1.68912399,   76.3094711,           0.
   7966,  -1.74736965,   77.2166901,           0.
   7967,  -1.80561531,   78.1239166,           0.
   7968,  -1.86386096,   79.0311356,           0.
   7969,  -2.00775409,   70.8124695,           0.
   7970,  -2.09504795,   71.7173615,           0.
   7971,  -2.18234158,   72.6222534,           0.
   7972,   -2.2696352,   73.5271454,           0.
   7973,  -2.35692883,   74.4320297,           0.
   7974,  -2.44422245,   75.3369217,           0.
   7975,  -2.53151608,   76.2418137,           0.
   7976,   -2.6188097,   77.1467056,           0.
   7977,  -2.70610356,     78.05159,           0.
   7978,  -2.79339719,   78.9564819,           0.
   7979,  -2.67379522,   70.7374268,           0.
   7980,  -2.79004717,   71.6390533,           0.
   7981,  -2.90629911,   72.5406799,           0.
   7982,  -3.02255106,   73.4423065,           0.
   7983,  -3.13880301,   74.3439331,           0.
   7984,  -3.25505495,   75.2455673,           0.
   7985,   -3.3713069,   76.1471939,           0.
   7986,  -3.48755884,   77.0488205,           0.
   7987,  -3.60381103,   77.9504471,           0.
   7988,  -3.72006297,   78.8520737,           0.
   7989,  -3.33708882,   70.6410751,           0.
   7990,  -3.48217964,   71.5385132,           0.
   7991,  -3.62727046,   72.4359512,           0.
   7992,  -3.77236104,   73.3333893,           0.
   7993,  -3.91745186,   74.2308273,           0.
   7994,  -4.06254292,   75.1282654,           0.
