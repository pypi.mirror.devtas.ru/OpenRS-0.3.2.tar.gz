  25995,  -26.1322308,   39.5224876,  -3.63636374
  25996,  -27.0991745,   39.5224876,  -3.63636374
  25997,  -28.0661163,   39.5224876,  -3.63636374
  25998,  -29.0330582,   39.5224876,  -3.63636374
  25999,  -20.8713112,   39.4918671,  -2.72727275
  26000,  -21.7426205,   39.4918671,  -2.72727275
  26001,  -22.6139317,   39.4918671,  -2.72727275
  26002,  -23.4852428,   39.4918671,  -2.72727275
  26003,  -24.3565521,   39.4918671,  -2.72727275
  26004,  -25.2278633,   39.4918671,  -2.72727275
  26005,  -26.0991726,   39.4918671,  -2.72727275
  26006,  -27.0743809,   39.4918671,  -2.72727275
  26007,  -28.0495872,   39.4918671,  -2.72727275
  26008,  -29.0247936,   39.4918671,  -2.72727275
  26009,  -20.8665886,   39.4612427,  -1.81818187
  26010,  -21.7331753,   39.4612427,  -1.81818187
  26011,  -22.5997639,   39.4612427,  -1.81818187
  26012,  -23.4663525,   39.4612427,  -1.81818187
  26013,  -24.3329411,   39.4612427,  -1.81818187
  26014,  -25.1995277,   39.4612427,  -1.81818187
  26015,  -26.0661163,   39.4612427,  -1.81818187
  26016,  -27.0495872,   39.4612427,  -1.81818187
  26017,  -28.0330582,   39.4612427,  -1.81818187
  26018,  -29.0165291,   39.4612427,  -1.81818187
  26019,   -20.861866,   39.4306221, -0.909090936
  26020,  -21.7237301,   39.4306221, -0.909090936
  26021,  -22.5855961,   39.4306221, -0.909090936
  26022,  -23.4474621,   39.4306221, -0.909090936
  26023,  -24.3093281,   39.4306221, -0.909090936
  26024,  -25.1711922,   39.4306221, -0.909090936
  26025,  -26.0330582,   39.4306221, -0.909090936
  26026,  -27.0247936,   39.4306221, -0.909090936
  26027,  -28.0165291,   39.4306221, -0.909090936
  26028,  -29.0082645,   39.4306221, -0.909090936
  26029,  -20.9043674,   40.4966507,    -9.090909
  26030,  -21.8087368,   40.4966507,    -9.090909
  26031,  -22.7131042,   40.4966507,    -9.090909
  26032,  -23.6174736,   40.4966507,    -9.090909
  26033,   -24.521841,   40.4966507,    -9.090909
  26034,  -25.4262104,   40.4966507,    -9.090909
  26035,  -26.3305779,   40.4966507,    -9.090909
  26036,  -27.2479343,   40.4966507,    -9.090909
  26037,  -28.1652889,   40.4966507,    -9.090909
  26038,  -29.0826454,   40.4966507,    -9.090909
  26039,  -20.8996449,   40.4669838,  -8.18181801
  26040,  -21.7992916,   40.4669838,  -8.18181801
  26041,  -22.6989365,   40.4669838,  -8.18181801
  26042,  -23.5985832,   40.4669838,  -8.18181801
  26043,  -24.4982281,   40.4669838,  -8.18181801
  26044,  -25.3978748,   40.4669838,  -8.18181801
  26045,  -26.2975197,   40.4669838,  -8.18181801
  26046,  -27.2231407,   40.4669838,  -8.18181801
  26047,  -28.1487598,   40.4669838,  -8.18181801
  26048,  -29.0743809,   40.4669838,  -8.18181801
  26049,  -20.8949223,   40.4373207,  -7.27272749
  26050,  -21.7898464,   40.4373207,  -7.27272749
  26051,  -22.6847687,   40.4373207,  -7.27272749
  26052,  -23.5796928,   40.4373207,  -7.27272749
  26053,   -24.474617,   40.4373207,  -7.27272749
  26054,  -25.3695393,   40.4373207,  -7.27272749
  26055,  -26.2644634,   40.4373207,  -7.27272749
  26056,  -27.1983471,   40.4373207,  -7.27272749
  26057,  -28.1322308,   40.4373207,  -7.27272749
  26058,  -29.0661163,   40.4373207,  -7.27272749
  26059,  -20.8901997,   40.4076538,  -6.36363649
  26060,  -21.7804012,   40.4076538,  -6.36363649
  26061,  -22.6706009,   40.4076538,  -6.36363649
  26062,  -23.5608025,   40.4076538,  -6.36363649
  26063,   -24.451004,   40.4076538,  -6.36363649
  26064,  -25.3412037,   40.4076538,  -6.36363649
  26065,  -26.2314053,   40.4076538,  -6.36363649
  26066,  -27.1735535,   40.4076538,  -6.36363649
  26067,  -28.1157017,   40.4076538,  -6.36363649
  26068,  -29.0578518,   40.4076538,  -6.36363649
  26069,  -20.8854771,   40.3779907,   -5.4545455
  26070,   -21.770956,   40.3779907,   -5.4545455
  26071,  -22.6564331,   40.3779907,   -5.4545455
  26072,  -23.5419121,   40.3779907,   -5.4545455
  26073,  -24.4273911,   40.3779907,   -5.4545455
  26074,  -25.3128681,   40.3779907,   -5.4545455
  26075,  -26.1983471,   40.3779907,   -5.4545455
  26076,  -27.1487598,   40.3779907,   -5.4545455
  26077,  -28.0991726,   40.3779907,   -5.4545455
  26078,  -29.0495872,   40.3779907,   -5.4545455
  26079,  -20.8807564,   40.3483238,   -4.5454545
  26080,  -21.7615108,   40.3483238,   -4.5454545
  26081,  -22.6422672,   40.3483238,   -4.5454545
  26082,  -23.5230236,   40.3483238,   -4.5454545
  26083,  -24.4037781,   40.3483238,   -4.5454545
  26084,  -25.2845345,   40.3483238,   -4.5454545
  26085,  -26.1652889,   40.3483238,   -4.5454545
  26086,  -27.1239681,   40.3483238,   -4.5454545
  26087,  -28.0826454,   40.3483238,   -4.5454545
  26088,  -29.0413227,   40.3483238,   -4.5454545
  26089,  -20.8760338,   40.3186607,  -3.63636374
  26090,  -21.7520657,   40.3186607,  -3.63636374
  26091,  -22.6280994,   40.3186607,  -3.63636374
  26092,  -23.5041332,   40.3186607,  -3.63636374
  26093,  -24.3801651,   40.3186607,  -3.63636374
  26094,  -25.2561989,   40.3186607,  -3.63636374
  26095,  -26.1322308,   40.3186607,  -3.63636374
  26096,  -27.0991745,   40.3186607,  -3.63636374
  26097,  -28.0661163,   40.3186607,  -3.63636374
  26098,  -29.0330582,   40.3186607,  -3.63636374
  26099,  -20.8713112,   40.2889938,  -2.72727275
  26100,  -21.7426205,   40.2889938,  -2.72727275
  26101,  -22.6139317,   40.2889938,  -2.72727275
  26102,  -23.4852428,   40.2889938,  -2.72727275
  26103,  -24.3565521,   40.2889938,  -2.72727275
  26104,  -25.2278633,   40.2889938,  -2.72727275
  26105,  -26.0991726,   40.2889938,  -2.72727275
  26106,  -27.0743809,   40.2889938,  -2.72727275
  26107,  -28.0495872,   40.2889938,  -2.72727275
  26108,  -29.0247936,   40.2889938,  -2.72727275
  26109,  -20.8665886,   40.2593307,  -1.81818187
  26110,  -21.7331753,   40.2593307,  -1.81818187
  26111,  -22.5997639,   40.2593307,  -1.81818187
  26112,  -23.4663525,   40.2593307,  -1.81818187
  26113,  -24.3329411,   40.2593307,  -1.81818187
  26114,  -25.1995277,   40.2593307,  -1.81818187
  26115,  -26.0661163,   40.2593307,  -1.81818187
  26116,  -27.0495872,   40.2593307,  -1.81818187
  26117,  -28.0330582,   40.2593307,  -1.81818187
  26118,  -29.0165291,   40.2593307,  -1.81818187
  26119,   -20.861866,   40.2296638, -0.909090936
  26120,  -21.7237301,   40.2296638, -0.909090936
  26121,  -22.5855961,   40.2296638, -0.909090936
  26122,  -23.4474621,   40.2296638, -0.909090936
  26123,  -24.3093281,   40.2296638, -0.909090936
  26124,  -25.1711922,   40.2296638, -0.909090936
  26125,  -26.0330582,   40.2296638, -0.909090936
  26126,  -27.0247936,   40.2296638, -0.909090936
  26127,  -28.0165291,   40.2296638, -0.909090936
  26128,  -29.0082645,   40.2296638, -0.909090936
  26129,  -20.9043674,   41.2870827,    -9.090909
  26130,  -21.8087368,   41.2870827,    -9.090909
  26131,  -22.7131042,   41.2870827,    -9.090909
  26132,  -23.6174736,   41.2870827,    -9.090909
  26133,   -24.521841,   41.2870827,    -9.090909
  26134,  -25.4262104,   41.2870827,    -9.090909
  26135,  -26.3305779,   41.2870827,    -9.090909
  26136,  -27.2479343,   41.2870827,    -9.090909
  26137,  -28.1652889,   41.2870827,    -9.090909
  26138,  -29.0826454,   41.2870827,    -9.090909
  26139,  -20.8996449,   41.2583733,  -8.18181801
  26140,  -21.7992916,   41.2583733,  -8.18181801
  26141,  -22.6989365,   41.2583733,  -8.18181801
  26142,  -23.5985832,   41.2583733,  -8.18181801
  26143,  -24.4982281,   41.2583733,  -8.18181801
  26144,  -25.3978748,   41.2583733,  -8.18181801
  26145,  -26.2975197,   41.2583733,  -8.18181801
  26146,  -27.2231407,   41.2583733,  -8.18181801
  26147,  -28.1487598,   41.2583733,  -8.18181801
  26148,  -29.0743809,   41.2583733,  -8.18181801
  26149,  -20.8949223,   41.2296638,  -7.27272749
  26150,  -21.7898464,   41.2296638,  -7.27272749
  26151,  -22.6847687,   41.2296638,  -7.27272749
  26152,  -23.5796928,   41.2296638,  -7.27272749
  26153,   -24.474617,   41.2296638,  -7.27272749
  26154,  -25.3695393,   41.2296638,  -7.27272749
  26155,  -26.2644634,   41.2296638,  -7.27272749
  26156,  -27.1983471,   41.2296638,  -7.27272749
  26157,  -28.1322308,   41.2296638,  -7.27272749
  26158,  -29.0661163,   41.2296638,  -7.27272749
  26159,  -20.8901997,   41.2009583,  -6.36363649
  26160,  -21.7804012,   41.2009583,  -6.36363649
  26161,  -22.6706009,   41.2009583,  -6.36363649
  26162,  -23.5608025,   41.2009583,  -6.36363649
  26163,   -24.451004,   41.2009583,  -6.36363649
  26164,  -25.3412037,   41.2009583,  -6.36363649
  26165,  -26.2314053,   41.2009583,  -6.36363649
  26166,  -27.1735535,   41.2009583,  -6.36363649
  26167,  -28.1157017,   41.2009583,  -6.36363649
  26168,  -29.0578518,   41.2009583,  -6.36363649
  26169,  -20.8854771,   41.1722488,   -5.4545455
  26170,   -21.770956,   41.1722488,   -5.4545455
  26171,  -22.6564331,   41.1722488,   -5.4545455
  26172,  -23.5419121,   41.1722488,   -5.4545455
  26173,  -24.4273911,   41.1722488,   -5.4545455
  26174,  -25.3128681,   41.1722488,   -5.4545455
  26175,  -26.1983471,   41.1722488,   -5.4545455
  26176,  -27.1487598,   41.1722488,   -5.4545455
  26177,  -28.0991726,   41.1722488,   -5.4545455
  26178,  -29.0495872,   41.1722488,   -5.4545455
  26179,  -20.8807564,   41.1435394,   -4.5454545
  26180,  -21.7615108,   41.1435394,   -4.5454545
  26181,  -22.6422672,   41.1435394,   -4.5454545
  26182,  -23.5230236,   41.1435394,   -4.5454545
  26183,  -24.4037781,   41.1435394,   -4.5454545
  26184,  -25.2845345,   41.1435394,   -4.5454545
  26185,  -26.1652889,   41.1435394,   -4.5454545
  26186,  -27.1239681,   41.1435394,   -4.5454545
  26187,  -28.0826454,   41.1435394,   -4.5454545
  26188,  -29.0413227,   41.1435394,   -4.5454545
  26189,  -20.8760338,   41.1148338,  -3.63636374
  26190,  -21.7520657,   41.1148338,  -3.63636374
  26191,  -22.6280994,   41.1148338,  -3.63636374
  26192,  -23.5041332,   41.1148338,  -3.63636374
  26193,  -24.3801651,   41.1148338,  -3.63636374
  26194,  -25.2561989,   41.1148338,  -3.63636374
  26195,  -26.1322308,   41.1148338,  -3.63636374
  26196,  -27.0991745,   41.1148338,  -3.63636374
  26197,  -28.0661163,   41.1148338,  -3.63636374
  26198,  -29.0330582,   41.1148338,  -3.63636374
  26199,  -20.8713112,   41.0861244,  -2.72727275
  26200,  -21.7426205,   41.0861244,  -2.72727275
  26201,  -22.6139317,   41.0861244,  -2.72727275
  26202,  -23.4852428,   41.0861244,  -2.72727275
  26203,  -24.3565521,   41.0861244,  -2.72727275
  26204,  -25.2278633,   41.0861244,  -2.72727275
  26205,  -26.0991726,   41.0861244,  -2.72727275
  26206,  -27.0743809,   41.0861244,  -2.72727275
  26207,  -28.0495872,   41.0861244,  -2.72727275
  26208,  -29.0247936,   41.0861244,  -2.72727275
  26209,  -20.8665886,    41.057415,  -1.81818187
  26210,  -21.7331753,    41.057415,  -1.81818187
  26211,  -22.5997639,    41.057415,  -1.81818187
  26212,  -23.4663525,    41.057415,  -1.81818187
  26213,  -24.3329411,    41.057415,  -1.81818187
  26214,  -25.1995277,    41.057415,  -1.81818187
  26215,  -26.0661163,    41.057415,  -1.81818187
  26216,  -27.0495872,    41.057415,  -1.81818187
  26217,  -28.0330582,    41.057415,  -1.81818187
  26218,  -29.0165291,    41.057415,  -1.81818187
  26219,   -20.861866,   41.0287094, -0.909090936
  26220,  -21.7237301,   41.0287094, -0.909090936
  26221,  -22.5855961,   41.0287094, -0.909090936
  26222,  -23.4474621,   41.0287094, -0.909090936
  26223,  -24.3093281,   41.0287094, -0.909090936
  26224,  -25.1711922,   41.0287094, -0.909090936
  26225,  -26.0330582,   41.0287094, -0.909090936
  26226,  -27.0247936,   41.0287094, -0.909090936
  26227,  -28.0165291,   41.0287094, -0.909090936
  26228,  -29.0082645,   41.0287094, -0.909090936
  26229,  -20.9043674,   42.0775108,    -9.090909
  26230,  -21.8087368,   42.0775108,    -9.090909
  26231,  -22.7131042,   42.0775108,    -9.090909
  26232,  -23.6174736,   42.0775108,    -9.090909
  26233,   -24.521841,   42.0775108,    -9.090909
  26234,  -25.4262104,   42.0775108,    -9.090909
  26235,  -26.3305779,   42.0775108,    -9.090909
  26236,  -27.2479343,   42.0775108,    -9.090909
  26237,  -28.1652889,   42.0775108,    -9.090909
  26238,  -29.0826454,   42.0775108,    -9.090909
  26239,  -20.8996449,   42.0497589,  -8.18181801
  26240,  -21.7992916,   42.0497589,  -8.18181801
  26241,  -22.6989365,   42.0497589,  -8.18181801
  26242,  -23.5985832,   42.0497589,  -8.18181801
  26243,  -24.4982281,   42.0497589,  -8.18181801
  26244,  -25.3978748,   42.0497589,  -8.18181801
  26245,  -26.2975197,   42.0497589,  -8.18181801
  26246,  -27.2231407,   42.0497589,  -8.18181801
  26247,  -28.1487598,   42.0497589,  -8.18181801
  26248,  -29.0743809,   42.0497589,  -8.18181801
  26249,  -20.8949223,   42.0220108,  -7.27272749
  26250,  -21.7898464,   42.0220108,  -7.27272749
  26251,  -22.6847687,   42.0220108,  -7.27272749
  26252,  -23.5796928,   42.0220108,  -7.27272749
  26253,   -24.474617,   42.0220108,  -7.27272749
  26254,  -25.3695393,   42.0220108,  -7.27272749
  26255,  -26.2644634,   42.0220108,  -7.27272749
  26256,  -27.1983471,   42.0220108,  -7.27272749
  26257,  -28.1322308,   42.0220108,  -7.27272749
  26258,  -29.0661163,   42.0220108,  -7.27272749
  26259,  -20.8901997,   41.9942589,  -6.36363649
  26260,  -21.7804012,   41.9942589,  -6.36363649
  26261,  -22.6706009,   41.9942589,  -6.36363649
  26262,  -23.5608025,   41.9942589,  -6.36363649
  26263,   -24.451004,   41.9942589,  -6.36363649
  26264,  -25.3412037,   41.9942589,  -6.36363649
  26265,  -26.2314053,   41.9942589,  -6.36363649
  26266,  -27.1735535,   41.9942589,  -6.36363649
  26267,  -28.1157017,   41.9942589,  -6.36363649
  26268,  -29.0578518,   41.9942589,  -6.36363649
  26269,  -20.8854771,    41.966507,   -5.4545455
  26270,   -21.770956,    41.966507,   -5.4545455
  26271,  -22.6564331,    41.966507,   -5.4545455
  26272,  -23.5419121,    41.966507,   -5.4545455
  26273,  -24.4273911,    41.966507,   -5.4545455
  26274,  -25.3128681,    41.966507,   -5.4545455
  26275,  -26.1983471,    41.966507,   -5.4545455
  26276,  -27.1487598,    41.966507,   -5.4545455
  26277,  -28.0991726,    41.966507,   -5.4545455
  26278,  -29.0495872,    41.966507,   -5.4545455
  26279,  -20.8807564,    41.938755,   -4.5454545
  26280,  -21.7615108,    41.938755,   -4.5454545
  26281,  -22.6422672,    41.938755,   -4.5454545
  26282,  -23.5230236,    41.938755,   -4.5454545
  26283,  -24.4037781,    41.938755,   -4.5454545
  26284,  -25.2845345,    41.938755,   -4.5454545
  26285,  -26.1652889,    41.938755,   -4.5454545
  26286,  -27.1239681,    41.938755,   -4.5454545
  26287,  -28.0826454,    41.938755,   -4.5454545
  26288,  -29.0413227,    41.938755,   -4.5454545
  26289,  -20.8760338,   41.9110031,  -3.63636374
  26290,  -21.7520657,   41.9110031,  -3.63636374
  26291,  -22.6280994,   41.9110031,  -3.63636374
  26292,  -23.5041332,   41.9110031,  -3.63636374
  26293,  -24.3801651,   41.9110031,  -3.63636374
  26294,  -25.2561989,   41.9110031,  -3.63636374
  26295,  -26.1322308,   41.9110031,  -3.63636374
  26296,  -27.0991745,   41.9110031,  -3.63636374
  26297,  -28.0661163,   41.9110031,  -3.63636374
  26298,  -29.0330582,   41.9110031,  -3.63636374
  26299,  -20.8713112,    41.883255,  -2.72727275
  26300,  -21.7426205,    41.883255,  -2.72727275
  26301,  -22.6139317,    41.883255,  -2.72727275
  26302,  -23.4852428,    41.883255,  -2.72727275
  26303,  -24.3565521,    41.883255,  -2.72727275
  26304,  -25.2278633,    41.883255,  -2.72727275
  26305,  -26.0991726,    41.883255,  -2.72727275
  26306,  -27.0743809,    41.883255,  -2.72727275
  26307,  -28.0495872,    41.883255,  -2.72727275
  26308,  -29.0247936,    41.883255,  -2.72727275
  26309,  -20.8665886,   41.8555031,  -1.81818187
  26310,  -21.7331753,   41.8555031,  -1.81818187
  26311,  -22.5997639,   41.8555031,  -1.81818187
  26312,  -23.4663525,   41.8555031,  -1.81818187
  26313,  -24.3329411,   41.8555031,  -1.81818187
  26314,  -25.1995277,   41.8555031,  -1.81818187
  26315,  -26.0661163,   41.8555031,  -1.81818187
  26316,  -27.0495872,   41.8555031,  -1.81818187
  26317,  -28.0330582,   41.8555031,  -1.81818187
  26318,  -29.0165291,   41.8555031,  -1.81818187
  26319,   -20.861866,   41.8277512, -0.909090936
  26320,  -21.7237301,   41.8277512, -0.909090936
  26321,  -22.5855961,   41.8277512, -0.909090936
  26322,  -23.4474621,   41.8277512, -0.909090936
  26323,  -24.3093281,   41.8277512, -0.909090936
  26324,  -25.1711922,   41.8277512, -0.909090936
  26325,  -26.0330582,   41.8277512, -0.909090936
  26326,  -27.0247936,   41.8277512, -0.909090936
  26327,  -28.0165291,   41.8277512, -0.909090936
  26328,  -29.0082645,   41.8277512, -0.909090936
  26329,  -20.9043674,   42.8679428,    -9.090909
  26330,  -21.8087368,   42.8679428,    -9.090909
  26331,  -22.7131042,   42.8679428,    -9.090909
  26332,  -23.6174736,   42.8679428,    -9.090909
  26333,   -24.521841,   42.8679428,    -9.090909
  26334,  -25.4262104,   42.8679428,    -9.090909
  26335,  -26.3305779,   42.8679428,    -9.090909
  26336,  -27.2479343,   42.8679428,    -9.090909
  26337,  -28.1652889,   42.8679428,    -9.090909
  26338,  -29.0826454,   42.8679428,    -9.090909
  26339,  -20.8996449,   42.8411484,  -8.18181801
  26340,  -21.7992916,   42.8411484,  -8.18181801
  26341,  -22.6989365,   42.8411484,  -8.18181801
  26342,  -23.5985832,   42.8411484,  -8.18181801
  26343,  -24.4982281,   42.8411484,  -8.18181801
  26344,  -25.3978748,   42.8411484,  -8.18181801
  26345,  -26.2975197,   42.8411484,  -8.18181801
  26346,  -27.2231407,   42.8411484,  -8.18181801
  26347,  -28.1487598,   42.8411484,  -8.18181801
  26348,  -29.0743809,   42.8411484,  -8.18181801
  26349,  -20.8949223,   42.8143539,  -7.27272749
  26350,  -21.7898464,   42.8143539,  -7.27272749
  26351,  -22.6847687,   42.8143539,  -7.27272749
  26352,  -23.5796928,   42.8143539,  -7.27272749
  26353,   -24.474617,   42.8143539,  -7.27272749
  26354,  -25.3695393,   42.8143539,  -7.27272749
  26355,  -26.2644634,   42.8143539,  -7.27272749
  26356,  -27.1983471,   42.8143539,  -7.27272749
  26357,  -28.1322308,   42.8143539,  -7.27272749
  26358,  -29.0661163,   42.8143539,  -7.27272749
  26359,  -20.8901997,   42.7875595,  -6.36363649
  26360,  -21.7804012,   42.7875595,  -6.36363649
  26361,  -22.6706009,   42.7875595,  -6.36363649
  26362,  -23.5608025,   42.7875595,  -6.36363649
  26363,   -24.451004,   42.7875595,  -6.36363649
  26364,  -25.3412037,   42.7875595,  -6.36363649
  26365,  -26.2314053,   42.7875595,  -6.36363649
  26366,  -27.1735535,   42.7875595,  -6.36363649
  26367,  -28.1157017,   42.7875595,  -6.36363649
  26368,  -29.0578518,   42.7875595,  -6.36363649
  26369,  -20.8854771,   42.7607651,   -5.4545455
  26370,   -21.770956,   42.7607651,   -5.4545455
  26371,  -22.6564331,   42.7607651,   -5.4545455
  26372,  -23.5419121,   42.7607651,   -5.4545455
  26373,  -24.4273911,   42.7607651,   -5.4545455
  26374,  -25.3128681,   42.7607651,   -5.4545455
  26375,  -26.1983471,   42.7607651,   -5.4545455
  26376,  -27.1487598,   42.7607651,   -5.4545455
  26377,  -28.0991726,   42.7607651,   -5.4545455
  26378,  -29.0495872,   42.7607651,   -5.4545455
  26379,  -20.8807564,   42.7339706,   -4.5454545
  26380,  -21.7615108,   42.7339706,   -4.5454545
  26381,  -22.6422672,   42.7339706,   -4.5454545
  26382,  -23.5230236,   42.7339706,   -4.5454545
  26383,  -24.4037781,   42.7339706,   -4.5454545
  26384,  -25.2845345,   42.7339706,   -4.5454545
  26385,  -26.1652889,   42.7339706,   -4.5454545
  26386,  -27.1239681,   42.7339706,   -4.5454545
  26387,  -28.0826454,   42.7339706,   -4.5454545
  26388,  -29.0413227,   42.7339706,   -4.5454545
  26389,  -20.8760338,   42.7071762,  -3.63636374
  26390,  -21.7520657,   42.7071762,  -3.63636374
  26391,  -22.6280994,   42.7071762,  -3.63636374
  26392,  -23.5041332,   42.7071762,  -3.63636374
  26393,  -24.3801651,   42.7071762,  -3.63636374
  26394,  -25.2561989,   42.7071762,  -3.63636374
  26395,  -26.1322308,   42.7071762,  -3.63636374
  26396,  -27.0991745,   42.7071762,  -3.63636374
  26397,  -28.0661163,   42.7071762,  -3.63636374
  26398,  -29.0330582,   42.7071762,  -3.63636374
  26399,  -20.8713112,   42.6803818,  -2.72727275
  26400,  -21.7426205,   42.6803818,  -2.72727275
  26401,  -22.6139317,   42.6803818,  -2.72727275
  26402,  -23.4852428,   42.6803818,  -2.72727275
  26403,  -24.3565521,   42.6803818,  -2.72727275
  26404,  -25.2278633,   42.6803818,  -2.72727275
  26405,  -26.0991726,   42.6803818,  -2.72727275
  26406,  -27.0743809,   42.6803818,  -2.72727275
  26407,  -28.0495872,   42.6803818,  -2.72727275
  26408,  -29.0247936,   42.6803818,  -2.72727275
  26409,  -20.8665886,   42.6535873,  -1.81818187
  26410,  -21.7331753,   42.6535873,  -1.81818187
  26411,  -22.5997639,   42.6535873,  -1.81818187
  26412,  -23.4663525,   42.6535873,  -1.81818187
  26413,  -24.3329411,   42.6535873,  -1.81818187
  26414,  -25.1995277,   42.6535873,  -1.81818187
  26415,  -26.0661163,   42.6535873,  -1.81818187
  26416,  -27.0495872,   42.6535873,  -1.81818187
  26417,  -28.0330582,   42.6535873,  -1.81818187
  26418,  -29.0165291,   42.6535873,  -1.81818187
  26419,   -20.861866,   42.6267929, -0.909090936
  26420,  -21.7237301,   42.6267929, -0.909090936
  26421,  -22.5855961,   42.6267929, -0.909090936
  26422,  -23.4474621,   42.6267929, -0.909090936
  26423,  -24.3093281,   42.6267929, -0.909090936
  26424,  -25.1711922,   42.6267929, -0.909090936
  26425,  -26.0330582,   42.6267929, -0.909090936
  26426,  -27.0247936,   42.6267929, -0.909090936
  26427,  -28.0165291,   42.6267929, -0.909090936
  26428,  -29.0082645,   42.6267929, -0.909090936
  26429,  -20.9043674,   43.6583748,    -9.090909
  26430,  -21.8087368,   43.6583748,    -9.090909
  26431,  -22.7131042,   43.6583748,    -9.090909
  26432,  -23.6174736,   43.6583748,    -9.090909
  26433,   -24.521841,   43.6583748,    -9.090909
  26434,  -25.4262104,   43.6583748,    -9.090909
  26435,  -26.3305779,   43.6583748,    -9.090909
  26436,  -27.2479343,   43.6583748,    -9.090909
  26437,  -28.1652889,   43.6583748,    -9.090909
  26438,  -29.0826454,   43.6583748,    -9.090909
  26439,  -20.8996449,    43.632534,  -8.18181801
  26440,  -21.7992916,    43.632534,  -8.18181801
  26441,  -22.6989365,    43.632534,  -8.18181801
  26442,  -23.5985832,    43.632534,  -8.18181801
  26443,  -24.4982281,    43.632534,  -8.18181801
  26444,  -25.3978748,    43.632534,  -8.18181801
  26445,  -26.2975197,    43.632534,  -8.18181801
  26446,  -27.2231407,    43.632534,  -8.18181801
  26447,  -28.1487598,    43.632534,  -8.18181801
  26448,  -29.0743809,    43.632534,  -8.18181801
  26449,  -20.8949223,   43.6066971,  -7.27272749
  26450,  -21.7898464,   43.6066971,  -7.27272749
  26451,  -22.6847687,   43.6066971,  -7.27272749
  26452,  -23.5796928,   43.6066971,  -7.27272749
  26453,   -24.474617,   43.6066971,  -7.27272749
  26454,  -25.3695393,   43.6066971,  -7.27272749
  26455,  -26.2644634,   43.6066971,  -7.27272749
  26456,  -27.1983471,   43.6066971,  -7.27272749
  26457,  -28.1322308,   43.6066971,  -7.27272749
  26458,  -29.0661163,   43.6066971,  -7.27272749
  26459,  -20.8901997,   43.5808601,  -6.36363649
  26460,  -21.7804012,   43.5808601,  -6.36363649
  26461,  -22.6706009,   43.5808601,  -6.36363649
  26462,  -23.5608025,   43.5808601,  -6.36363649
  26463,   -24.451004,   43.5808601,  -6.36363649
  26464,  -25.3412037,   43.5808601,  -6.36363649
  26465,  -26.2314053,   43.5808601,  -6.36363649
  26466,  -27.1735535,   43.5808601,  -6.36363649
  26467,  -28.1157017,   43.5808601,  -6.36363649
  26468,  -29.0578518,   43.5808601,  -6.36363649
  26469,  -20.8854771,   43.5550232,   -5.4545455
  26470,   -21.770956,   43.5550232,   -5.4545455
  26471,  -22.6564331,   43.5550232,   -5.4545455
  26472,  -23.5419121,   43.5550232,   -5.4545455
  26473,  -24.4273911,   43.5550232,   -5.4545455
  26474,  -25.3128681,   43.5550232,   -5.4545455
  26475,  -26.1983471,   43.5550232,   -5.4545455
  26476,  -27.1487598,   43.5550232,   -5.4545455
  26477,  -28.0991726,   43.5550232,   -5.4545455
  26478,  -29.0495872,   43.5550232,   -5.4545455
  26479,  -20.8807564,   43.5291862,   -4.5454545
  26480,  -21.7615108,   43.5291862,   -4.5454545
  26481,  -22.6422672,   43.5291862,   -4.5454545
  26482,  -23.5230236,   43.5291862,   -4.5454545
  26483,  -24.4037781,   43.5291862,   -4.5454545
  26484,  -25.2845345,   43.5291862,   -4.5454545
  26485,  -26.1652889,   43.5291862,   -4.5454545
  26486,  -27.1239681,   43.5291862,   -4.5454545
  26487,  -28.0826454,   43.5291862,   -4.5454545
  26488,  -29.0413227,   43.5291862,   -4.5454545
  26489,  -20.8760338,   43.5033493,  -3.63636374
  26490,  -21.7520657,   43.5033493,  -3.63636374
  26491,  -22.6280994,   43.5033493,  -3.63636374
  26492,  -23.5041332,   43.5033493,  -3.63636374
  26493,  -24.3801651,   43.5033493,  -3.63636374
  26494,  -25.2561989,   43.5033493,  -3.63636374
  26495,  -26.1322308,   43.5033493,  -3.63636374
  26496,  -27.0991745,   43.5033493,  -3.63636374
  26497,  -28.0661163,   43.5033493,  -3.63636374
  26498,  -29.0330582,   43.5033493,  -3.63636374
  26499,  -20.8713112,   43.4775124,  -2.72727275
  26500,  -21.7426205,   43.4775124,  -2.72727275
  26501,  -22.6139317,   43.4775124,  -2.72727275
  26502,  -23.4852428,   43.4775124,  -2.72727275
  26503,  -24.3565521,   43.4775124,  -2.72727275
  26504,  -25.2278633,   43.4775124,  -2.72727275
  26505,  -26.0991726,   43.4775124,  -2.72727275
  26506,  -27.0743809,   43.4775124,  -2.72727275
  26507,  -28.0495872,   43.4775124,  -2.72727275
  26508,  -29.0247936,   43.4775124,  -2.72727275
  26509,  -20.8665886,   43.4516754,  -1.81818187
  26510,  -21.7331753,   43.4516754,  -1.81818187
  26511,  -22.5997639,   43.4516754,  -1.81818187
  26512,  -23.4663525,   43.4516754,  -1.81818187
  26513,  -24.3329411,   43.4516754,  -1.81818187
  26514,  -25.1995277,   43.4516754,  -1.81818187
  26515,  -26.0661163,   43.4516754,  -1.81818187
  26516,  -27.0495872,   43.4516754,  -1.81818187
  26517,  -28.0330582,   43.4516754,  -1.81818187
  26518,  -29.0165291,   43.4516754,  -1.81818187
  26519,   -20.861866,   43.4258385, -0.909090936
  26520,  -21.7237301,   43.4258385, -0.909090936
  26521,  -22.5855961,   43.4258385, -0.909090936
  26522,  -23.4474621,   43.4258385, -0.909090936
  26523,  -24.3093281,   43.4258385, -0.909090936
  26524,  -25.1711922,   43.4258385, -0.909090936
  26525,  -26.0330582,   43.4258385, -0.909090936
  26526,  -27.0247936,   43.4258385, -0.909090936
  26527,  -28.0165291,   43.4258385, -0.909090936
  26528,  -29.0082645,   43.4258385, -0.909090936
  26529,  -20.9043674,   44.4488029,    -9.090909
  26530,  -21.8087368,   44.4488029,    -9.090909
  26531,  -22.7131042,   44.4488029,    -9.090909
  26532,  -23.6174736,   44.4488029,    -9.090909
  26533,   -24.521841,   44.4488029,    -9.090909
  26534,  -25.4262104,   44.4488029,    -9.090909
  26535,  -26.3305779,   44.4488029,    -9.090909
  26536,  -27.2479343,   44.4488029,    -9.090909
  26537,  -28.1652889,   44.4488029,    -9.090909
  26538,  -29.0826454,   44.4488029,    -9.090909
  26539,  -20.8996449,   44.4239235,  -8.18181801
  26540,  -21.7992916,   44.4239235,  -8.18181801
  26541,  -22.6989365,   44.4239235,  -8.18181801
  26542,  -23.5985832,   44.4239235,  -8.18181801
  26543,  -24.4982281,   44.4239235,  -8.18181801
  26544,  -25.3978748,   44.4239235,  -8.18181801
  26545,  -26.2975197,   44.4239235,  -8.18181801
  26546,  -27.2231407,   44.4239235,  -8.18181801
  26547,  -28.1487598,   44.4239235,  -8.18181801
  26548,  -29.0743809,   44.4239235,  -8.18181801
  26549,  -20.8949223,    44.399044,  -7.27272749
  26550,  -21.7898464,    44.399044,  -7.27272749
  26551,  -22.6847687,    44.399044,  -7.27272749
  26552,  -23.5796928,    44.399044,  -7.27272749
  26553,   -24.474617,    44.399044,  -7.27272749
  26554,  -25.3695393,    44.399044,  -7.27272749
  26555,  -26.2644634,    44.399044,  -7.27272749
  26556,  -27.1983471,    44.399044,  -7.27272749
  26557,  -28.1322308,    44.399044,  -7.27272749
  26558,  -29.0661163,    44.399044,  -7.27272749
  26559,  -20.8901997,   44.3741646,  -6.36363649
  26560,  -21.7804012,   44.3741646,  -6.36363649
  26561,  -22.6706009,   44.3741646,  -6.36363649
  26562,  -23.5608025,   44.3741646,  -6.36363649
  26563,   -24.451004,   44.3741646,  -6.36363649
  26564,  -25.3412037,   44.3741646,  -6.36363649
  26565,  -26.2314053,   44.3741646,  -6.36363649
  26566,  -27.1735535,   44.3741646,  -6.36363649
  26567,  -28.1157017,   44.3741646,  -6.36363649
  26568,  -29.0578518,   44.3741646,  -6.36363649
  26569,  -20.8854771,   44.3492813,   -5.4545455
  26570,   -21.770956,   44.3492813,   -5.4545455
  26571,  -22.6564331,   44.3492813,   -5.4545455
  26572,  -23.5419121,   44.3492813,   -5.4545455
  26573,  -24.4273911,   44.3492813,   -5.4545455
  26574,  -25.3128681,   44.3492813,   -5.4545455
  26575,  -26.1983471,   44.3492813,   -5.4545455
  26576,  -27.1487598,   44.3492813,   -5.4545455
  26577,  -28.0991726,   44.3492813,   -5.4545455
  26578,  -29.0495872,   44.3492813,   -5.4545455
  26579,  -20.8807564,   44.3244019,   -4.5454545
  26580,  -21.7615108,   44.3244019,   -4.5454545
  26581,  -22.6422672,   44.3244019,   -4.5454545
  26582,  -23.5230236,   44.3244019,   -4.5454545
  26583,  -24.4037781,   44.3244019,   -4.5454545
  26584,  -25.2845345,   44.3244019,   -4.5454545
  26585,  -26.1652889,   44.3244019,   -4.5454545
  26586,  -27.1239681,   44.3244019,   -4.5454545
  26587,  -28.0826454,   44.3244019,   -4.5454545
  26588,  -29.0413227,   44.3244019,   -4.5454545
  26589,  -20.8760338,   44.2995224,  -3.63636374
  26590,  -21.7520657,   44.2995224,  -3.63636374
  26591,  -22.6280994,   44.2995224,  -3.63636374
  26592,  -23.5041332,   44.2995224,  -3.63636374
  26593,  -24.3801651,   44.2995224,  -3.63636374
  26594,  -25.2561989,   44.2995224,  -3.63636374
  26595,  -26.1322308,   44.2995224,  -3.63636374
  26596,  -27.0991745,   44.2995224,  -3.63636374
  26597,  -28.0661163,   44.2995224,  -3.63636374
  26598,  -29.0330582,   44.2995224,  -3.63636374
  26599,  -20.8713112,   44.2746429,  -2.72727275
  26600,  -21.7426205,   44.2746429,  -2.72727275
  26601,  -22.6139317,   44.2746429,  -2.72727275
  26602,  -23.4852428,   44.2746429,  -2.72727275
  26603,  -24.3565521,   44.2746429,  -2.72727275
  26604,  -25.2278633,   44.2746429,  -2.72727275
  26605,  -26.0991726,   44.2746429,  -2.72727275
  26606,  -27.0743809,   44.2746429,  -2.72727275
  26607,  -28.0495872,   44.2746429,  -2.72727275
  26608,  -29.0247936,   44.2746429,  -2.72727275
  26609,  -20.8665886,   44.2497597,  -1.81818187
  26610,  -21.7331753,   44.2497597,  -1.81818187
  26611,  -22.5997639,   44.2497597,  -1.81818187
  26612,  -23.4663525,   44.2497597,  -1.81818187
  26613,  -24.3329411,   44.2497597,  -1.81818187
  26614,  -25.1995277,   44.2497597,  -1.81818187
  26615,  -26.0661163,   44.2497597,  -1.81818187
  26616,  -27.0495872,   44.2497597,  -1.81818187
  26617,  -28.0330582,   44.2497597,  -1.81818187
  26618,  -29.0165291,   44.2497597,  -1.81818187
  26619,   -20.861866,   44.2248802, -0.909090936
  26620,  -21.7237301,   44.2248802, -0.909090936
  26621,  -22.5855961,   44.2248802, -0.909090936
  26622,  -23.4474621,   44.2248802, -0.909090936
  26623,  -24.3093281,   44.2248802, -0.909090936
  26624,  -25.1711922,   44.2248802, -0.909090936
  26625,  -26.0330582,   44.2248802, -0.909090936
  26626,  -27.0247936,   44.2248802, -0.909090936
  26627,  -28.0165291,   44.2248802, -0.909090936
  26628,  -29.0082645,   44.2248802, -0.909090936
  26629,  -20.9043674,   45.2392349,    -9.090909
  26630,  -21.8087368,   45.2392349,    -9.090909
  26631,  -22.7131042,   45.2392349,    -9.090909
  26632,  -23.6174736,   45.2392349,    -9.090909
  26633,   -24.521841,   45.2392349,    -9.090909
  26634,  -25.4262104,   45.2392349,    -9.090909
  26635,  -26.3305779,   45.2392349,    -9.090909
  26636,  -27.2479343,   45.2392349,    -9.090909
  26637,  -28.1652889,   45.2392349,    -9.090909
  26638,  -29.0826454,   45.2392349,    -9.090909
  26639,  -20.8996449,   45.2153091,  -8.18181801
  26640,  -21.7992916,   45.2153091,  -8.18181801
  26641,  -22.6989365,   45.2153091,  -8.18181801
  26642,  -23.5985832,   45.2153091,  -8.18181801
  26643,  -24.4982281,   45.2153091,  -8.18181801
  26644,  -25.3978748,   45.2153091,  -8.18181801
  26645,  -26.2975197,   45.2153091,  -8.18181801
  26646,  -27.2231407,   45.2153091,  -8.18181801
  26647,  -28.1487598,   45.2153091,  -8.18181801
  26648,  -29.0743809,   45.2153091,  -8.18181801
  26649,  -20.8949223,   45.1913872,  -7.27272749
  26650,  -21.7898464,   45.1913872,  -7.27272749
  26651,  -22.6847687,   45.1913872,  -7.27272749
  26652,  -23.5796928,   45.1913872,  -7.27272749
  26653,   -24.474617,   45.1913872,  -7.27272749
  26654,  -25.3695393,   45.1913872,  -7.27272749
  26655,  -26.2644634,   45.1913872,  -7.27272749
  26656,  -27.1983471,   45.1913872,  -7.27272749
  26657,  -28.1322308,   45.1913872,  -7.27272749
  26658,  -29.0661163,   45.1913872,  -7.27272749
  26659,  -20.8901997,   45.1674652,  -6.36363649
  26660,  -21.7804012,   45.1674652,  -6.36363649
  26661,  -22.6706009,   45.1674652,  -6.36363649
  26662,  -23.5608025,   45.1674652,  -6.36363649
  26663,   -24.451004,   45.1674652,  -6.36363649
  26664,  -25.3412037,   45.1674652,  -6.36363649
  26665,  -26.2314053,   45.1674652,  -6.36363649
  26666,  -27.1735535,   45.1674652,  -6.36363649
  26667,  -28.1157017,   45.1674652,  -6.36363649
  26668,  -29.0578518,   45.1674652,  -6.36363649
  26669,  -20.8854771,   45.1435394,   -5.4545455
  26670,   -21.770956,   45.1435394,   -5.4545455
  26671,  -22.6564331,   45.1435394,   -5.4545455
  26672,  -23.5419121,   45.1435394,   -5.4545455
  26673,  -24.4273911,   45.1435394,   -5.4545455
  26674,  -25.3128681,   45.1435394,   -5.4545455
  26675,  -26.1983471,   45.1435394,   -5.4545455
  26676,  -27.1487598,   45.1435394,   -5.4545455
  26677,  -28.0991726,   45.1435394,   -5.4545455
  26678,  -29.0495872,   45.1435394,   -5.4545455
  26679,  -20.8807564,   45.1196175,   -4.5454545
  26680,  -21.7615108,   45.1196175,   -4.5454545
  26681,  -22.6422672,   45.1196175,   -4.5454545
  26682,  -23.5230236,   45.1196175,   -4.5454545
  26683,  -24.4037781,   45.1196175,   -4.5454545
  26684,  -25.2845345,   45.1196175,   -4.5454545
  26685,  -26.1652889,   45.1196175,   -4.5454545
  26686,  -27.1239681,   45.1196175,   -4.5454545
  26687,  -28.0826454,   45.1196175,   -4.5454545
  26688,  -29.0413227,   45.1196175,   -4.5454545
  26689,  -20.8760338,   45.0956955,  -3.63636374
  26690,  -21.7520657,   45.0956955,  -3.63636374
  26691,  -22.6280994,   45.0956955,  -3.63636374
  26692,  -23.5041332,   45.0956955,  -3.63636374
  26693,  -24.3801651,   45.0956955,  -3.63636374
  26694,  -25.2561989,   45.0956955,  -3.63636374
  26695,  -26.1322308,   45.0956955,  -3.63636374
  26696,  -27.0991745,   45.0956955,  -3.63636374
  26697,  -28.0661163,   45.0956955,  -3.63636374
  26698,  -29.0330582,   45.0956955,  -3.63636374
  26699,  -20.8713112,   45.0717697,  -2.72727275
  26700,  -21.7426205,   45.0717697,  -2.72727275
  26701,  -22.6139317,   45.0717697,  -2.72727275
  26702,  -23.4852428,   45.0717697,  -2.72727275
  26703,  -24.3565521,   45.0717697,  -2.72727275
  26704,  -25.2278633,   45.0717697,  -2.72727275
  26705,  -26.0991726,   45.0717697,  -2.72727275
  26706,  -27.0743809,   45.0717697,  -2.72727275
  26707,  -28.0495872,   45.0717697,  -2.72727275
  26708,  -29.0247936,   45.0717697,  -2.72727275
  26709,  -20.8665886,   45.0478477,  -1.81818187
  26710,  -21.7331753,   45.0478477,  -1.81818187
  26711,  -22.5997639,   45.0478477,  -1.81818187
  26712,  -23.4663525,   45.0478477,  -1.81818187
  26713,  -24.3329411,   45.0478477,  -1.81818187
  26714,  -25.1995277,   45.0478477,  -1.81818187
  26715,  -26.0661163,   45.0478477,  -1.81818187
  26716,  -27.0495872,   45.0478477,  -1.81818187
  26717,  -28.0330582,   45.0478477,  -1.81818187
  26718,  -29.0165291,   45.0478477,  -1.81818187
  26719,   -20.861866,    45.023922, -0.909090936
  26720,  -21.7237301,    45.023922, -0.909090936
  26721,  -22.5855961,    45.023922, -0.909090936
  26722,  -23.4474621,    45.023922, -0.909090936
  26723,  -24.3093281,    45.023922, -0.909090936
  26724,  -25.1711922,    45.023922, -0.909090936
  26725,  -26.0330582,    45.023922, -0.909090936
  26726,  -27.0247936,    45.023922, -0.909090936
  26727,  -28.0165291,    45.023922, -0.909090936
  26728,  -29.0082645,    45.023922, -0.909090936
  26729,  -20.9051552,   46.0326958,    -9.090909
  26730,  -21.8103104,   46.0326958,    -9.090909
  26731,  -22.7154655,   46.0326958,    -9.090909
  26732,  -23.6206226,   46.0326958,    -9.090909
  26733,  -24.5257759,   46.0326958,    -9.090909
  26734,   -25.430933,   46.0326958,    -9.090909
  26735,  -26.3360882,   46.0326958,    -9.090909
  26736,  -27.2520676,   46.0326958,    -9.090909
  26737,  -28.1680431,   46.0326958,    -9.090909
  26738,  -29.0840225,   46.0326958,    -9.090909
  26739,  -20.9012184,   46.0127602,  -8.18181801
  26740,  -21.8024406,   46.0127602,  -8.18181801
  26741,  -22.7036591,   46.0127602,  -8.18181801
  26742,  -23.6048794,   46.0127602,  -8.18181801
  26743,  -24.5060997,   46.0127602,  -8.18181801
  26744,    -25.40732,   46.0127602,  -8.18181801
  26745,  -26.3085403,   46.0127602,  -8.18181801
  26746,  -27.2314053,   46.0127602,  -8.18181801
  26747,  -28.1542702,   46.0127602,  -8.18181801
  26748,  -29.0771351,   46.0127602,  -8.18181801
  26749,  -20.8972836,   45.9928246,  -7.27272749
  26750,   -21.794569,   45.9928246,  -7.27272749
  26751,  -22.6918526,   45.9928246,  -7.27272749
  26752,   -23.589138,   45.9928246,  -7.27272749
  26753,  -24.4864216,   45.9928246,  -7.27272749
  26754,   -25.383707,   45.9928246,  -7.27272749
  26755,  -26.2809906,   45.9928246,  -7.27272749
  26756,  -27.2107449,   45.9928246,  -7.27272749
  26757,  -28.1404953,   45.9928246,  -7.27272749
  26758,  -29.0702496,   45.9928246,  -7.27272749
  26759,  -20.8933487,   45.9728851,  -6.36363649
  26760,  -21.7866974,   45.9728851,  -6.36363649
  26761,  -22.6800461,   45.9728851,  -6.36363649
  26762,  -23.5733967,   45.9728851,  -6.36363649
  26763,  -24.4667454,   45.9728851,  -6.36363649
  26764,  -25.3600941,   45.9728851,  -6.36363649
  26765,  -26.2534428,   45.9728851,  -6.36363649
  26766,  -27.1900826,   45.9728851,  -6.36363649
  26767,  -28.1267223,   45.9728851,  -6.36363649
  26768,  -29.0633621,   45.9728851,  -6.36363649
  26769,  -20.8894138,   45.9529495,   -5.4545455
  26770,  -21.7788277,   45.9529495,   -5.4545455
  26771,  -22.6682396,   45.9529495,   -5.4545455
  26772,  -23.5576553,   45.9529495,   -5.4545455
  26773,  -24.4470673,   45.9529495,   -5.4545455
  26774,  -25.3364811,   45.9529495,   -5.4545455
  26775,  -26.2258949,   45.9529495,   -5.4545455
  26776,  -27.1694221,   45.9529495,   -5.4545455
  26777,  -28.1129475,   45.9529495,   -5.4545455
  26778,  -29.0564747,   45.9529495,   -5.4545455
  26779,  -20.8854771,   45.9330139,   -4.5454545
  26780,   -21.770956,   45.9330139,   -4.5454545
  26781,   -22.656435,   45.9330139,   -4.5454545
  26782,  -23.5419121,   45.9330139,   -4.5454545
  26783,  -24.4273911,   45.9330139,   -4.5454545
  26784,    -25.31287,   45.9330139,   -4.5454545
  26785,  -26.1983471,   45.9330139,   -4.5454545
  26786,  -27.1487598,   45.9330139,   -4.5454545
  26787,  -28.0991745,   45.9330139,   -4.5454545
  26788,  -29.0495872,   45.9330139,   -4.5454545
  26789,  -20.8815422,   45.9130783,  -3.63636374
  26790,  -21.7630863,   45.9130783,  -3.63636374
  26791,  -22.6446285,   45.9130783,  -3.63636374
  26792,  -23.5261707,   45.9130783,  -3.63636374
  26793,  -24.4077129,   45.9130783,  -3.63636374
  26794,   -25.289257,   45.9130783,  -3.63636374
  26795,  -26.1707993,   45.9130783,  -3.63636374
  26796,  -27.1280994,   45.9130783,  -3.63636374
  26797,  -28.0853996,   45.9130783,  -3.63636374
  26798,  -29.0426998,   45.9130783,  -3.63636374
  26799,  -20.8776073,   45.8931427,  -2.72727275
  26800,  -21.7552147,   45.8931427,  -2.72727275
  26801,   -22.632822,   45.8931427,  -2.72727275
  26802,  -23.5104294,   45.8931427,  -2.72727275
  26803,  -24.3880367,   45.8931427,  -2.72727275
  26804,  -25.2656441,   45.8931427,  -2.72727275
  26805,  -26.1432514,   45.8931427,  -2.72727275
  26806,  -27.1074371,   45.8931427,  -2.72727275
  26807,  -28.0716267,   45.8931427,  -2.72727275
  26808,  -29.0358124,   45.8931427,  -2.72727275
  26809,  -20.8736725,   45.8732071,  -1.81818187
  26810,  -21.7473431,   45.8732071,  -1.81818187
  26811,  -22.6210155,   45.8732071,  -1.81818187
  26812,   -23.494688,   45.8732071,  -1.81818187
  26813,  -24.3683586,   45.8732071,  -1.81818187
  26814,  -25.2420311,   45.8732071,  -1.81818187
  26815,  -26.1157017,   45.8732071,  -1.81818187
  26816,  -27.0867767,   45.8732071,  -1.81818187
  26817,  -28.0578518,   45.8732071,  -1.81818187
  26818,  -29.0289268,   45.8732071,  -1.81818187
  26819,  -20.8697357,   45.8532677, -0.909090936
  26820,  -21.7394733,   45.8532677, -0.909090936
  26821,  -22.6092091,   45.8532677, -0.909090936
  26822,  -23.4789448,   45.8532677, -0.909090936
  26823,  -24.3486824,   45.8532677, -0.909090936
  26824,  -25.2184181,   45.8532677, -0.909090936
  26825,  -26.0881538,   45.8532677, -0.909090936
  26826,  -27.0661144,   45.8532677, -0.909090936
  26827,  -28.0440788,   45.8532677, -0.909090936
  26828,  -29.0220394,   45.8532677, -0.909090936
  26829,   -20.905941,   46.8261566,    -9.090909
  26830,  -21.8118858,   46.8261566,    -9.090909
  26831,  -22.7178268,   46.8261566,    -9.090909
  26832,  -23.6237698,   46.8261566,    -9.090909
  26833,  -24.5297127,   46.8261566,    -9.090909
  26834,  -25.4356556,   46.8261566,    -9.090909
  26835,  -26.3415966,   46.8261566,    -9.090909
  26836,  -27.2561989,   46.8261566,    -9.090909
  26837,  -28.1707993,   46.8261566,    -9.090909
  26838,  -29.0853996,   46.8261566,    -9.090909
  26839,  -20.9027939,   46.8102074,  -8.18181801
  26840,  -21.8055878,   46.8102074,  -8.18181801
  26841,  -22.7083817,   46.8102074,  -8.18181801
  26842,  -23.6111774,   46.8102074,  -8.18181801
  26843,  -24.5139694,   46.8102074,  -8.18181801
  26844,  -25.4167652,   46.8102074,  -8.18181801
  26845,  -26.3195591,   46.8102074,  -8.18181801
  26846,  -27.2396698,   46.8102074,  -8.18181801
  26847,  -28.1597786,   46.8102074,  -8.18181801
  26848,  -29.0798912,   46.8102074,  -8.18181801
  26849,  -20.8996449,   46.7942581,  -7.27272749
  26850,  -21.7992916,   46.7942581,  -7.27272749
  26851,  -22.6989365,   46.7942581,  -7.27272749
  26852,  -23.5985832,   46.7942581,  -7.27272749
  26853,  -24.4982281,   46.7942581,  -7.27272749
  26854,  -25.3978748,   46.7942581,  -7.27272749
  26855,  -26.2975197,   46.7942581,  -7.27272749
  26856,  -27.2231407,   46.7942581,  -7.27272749
  26857,  -28.1487598,   46.7942581,  -7.27272749
  26858,  -29.0743809,   46.7942581,  -7.27272749
  26859,  -20.8964958,   46.7783089,  -6.36363649
  26860,  -21.7929955,   46.7783089,  -6.36363649
  26861,  -22.6894913,   46.7783089,  -6.36363649
  26862,   -23.585989,   46.7783089,  -6.36363649
  26863,  -24.4824867,   46.7783089,  -6.36363649
  26864,  -25.3789845,   46.7783089,  -6.36363649
  26865,  -26.2754822,   46.7783089,  -6.36363649
  26866,  -27.2066116,   46.7783089,  -6.36363649
  26867,  -28.1377411,   46.7783089,  -6.36363649
  26868,  -29.0688705,   46.7783089,  -6.36363649
  26869,  -20.8933487,   46.7623596,   -5.4545455
  26870,  -21.7866993,   46.7623596,   -5.4545455
  26871,  -22.6800461,   46.7623596,   -5.4545455
  26872,  -23.5733967,   46.7623596,   -5.4545455
  26873,  -24.4667454,   46.7623596,   -5.4545455
  26874,  -25.3600941,   46.7623596,   -5.4545455
  26875,  -26.2534428,   46.7623596,   -5.4545455
  26876,  -27.1900826,   46.7623596,   -5.4545455
  26877,  -28.1267223,   46.7623596,   -5.4545455
  26878,  -29.0633621,   46.7623596,   -5.4545455
  26879,  -20.8901997,   46.7464104,   -4.5454545
  26880,  -21.7804012,   46.7464104,   -4.5454545
  26881,  -22.6706028,   46.7464104,   -4.5454545
  26882,  -23.5608025,   46.7464104,   -4.5454545
  26883,  -24.4510021,   46.7464104,   -4.5454545
  26884,  -25.3412056,   46.7464104,   -4.5454545
  26885,  -26.2314053,   46.7464104,   -4.5454545
  26886,  -27.1735554,   46.7464104,   -4.5454545
  26887,  -28.1157017,   46.7464104,   -4.5454545
  26888,  -29.0578518,   46.7464104,   -4.5454545
  26889,  -20.8870525,   46.7304611,  -3.63636374
  26890,  -21.7741051,   46.7304611,  -3.63636374
  26891,  -22.6611576,   46.7304611,  -3.63636374
  26892,  -23.5482101,   46.7304611,  -3.63636374
  26893,  -24.4352608,   46.7304611,  -3.63636374
  26894,  -25.3223152,   46.7304611,  -3.63636374
  26895,  -26.2093658,   46.7304611,  -3.63636374
  26896,  -27.1570263,   46.7304611,  -3.63636374
  26897,  -28.1046829,   46.7304611,  -3.63636374
  26898,  -29.0523434,   46.7304611,  -3.63636374
  26899,  -20.8839035,   46.7145119,  -2.72727275
  26900,  -21.7678089,   46.7145119,  -2.72727275
  26901,  -22.6517124,   46.7145119,  -2.72727275
  26902,  -23.5356159,   46.7145119,  -2.72727275
  26903,  -24.4195194,   46.7145119,  -2.72727275
  26904,  -25.3034248,   46.7145119,  -2.72727275
  26905,  -26.1873283,   46.7145119,  -2.72727275
  26906,  -27.1404972,   46.7145119,  -2.72727275
  26907,  -28.0936642,   46.7145119,  -2.72727275
  26908,   -29.046833,   46.7145119,  -2.72727275
  26909,  -20.8807545,   46.6985664,  -1.81818187
  26910,  -21.7615128,   46.6985664,  -1.81818187
  26911,  -22.6422672,   46.6985664,  -1.81818187
  26912,  -23.5230217,   46.6985664,  -1.81818187
  26913,  -24.4037781,   46.6985664,  -1.81818187
  26914,  -25.2845345,   46.6985664,  -1.81818187
  26915,  -26.1652889,   46.6985664,  -1.81818187
  26916,  -27.1239681,   46.6985664,  -1.81818187
  26917,  -28.0826454,   46.6985664,  -1.81818187
  26918,  -29.0413227,   46.6985664,  -1.81818187
  26919,  -20.8776073,   46.6826172, -0.909090936
  26920,  -21.7552147,   46.6826172, -0.909090936
  26921,   -22.632822,   46.6826172, -0.909090936
  26922,  -23.5104294,   46.6826172, -0.909090936
  26923,  -24.3880348,   46.6826172, -0.909090936
  26924,  -25.2656441,   46.6826172, -0.909090936
  26925,  -26.1432514,   46.6826172, -0.909090936
  26926,   -27.107439,   46.6826172, -0.909090936
  26927,  -28.0716248,   46.6826172, -0.909090936
  26928,  -29.0358143,   46.6826172, -0.909090936
  26929,  -20.9067287,   47.6196175,    -9.090909
  26930,  -21.8134594,   47.6196175,    -9.090909
  26931,  -22.7201881,   47.6196175,    -9.090909
  26932,  -23.6269188,   47.6196175,    -9.090909
  26933,  -24.5336475,   47.6196175,    -9.090909
  26934,  -25.4403782,   47.6196175,    -9.090909
  26935,  -26.3471069,   47.6196175,    -9.090909
  26936,  -27.2603321,   47.6196175,    -9.090909
  26937,  -28.1735535,   47.6196175,    -9.090909
  26938,  -29.0867767,   47.6196175,    -9.090909
  26939,  -20.9043674,   47.6076546,  -8.18181801
  26940,  -21.8087368,   47.6076546,  -8.18181801
  26941,  -22.7131042,   47.6076546,  -8.18181801
  26942,  -23.6174736,   47.6076546,  -8.18181801
  26943,   -24.521841,   47.6076546,  -8.18181801
  26944,  -25.4262104,   47.6076546,  -8.18181801
  26945,  -26.3305779,   47.6076546,  -8.18181801
  26946,  -27.2479343,   47.6076546,  -8.18181801
  26947,  -28.1652889,   47.6076546,  -8.18181801
  26948,  -29.0826454,   47.6076546,  -8.18181801
  26949,  -20.9020061,   47.5956955,  -7.27272749
  26950,  -21.8040142,   47.5956955,  -7.27272749
  26951,  -22.7060204,   47.5956955,  -7.27272749
  26952,  -23.6080284,   47.5956955,  -7.27272749
  26953,  -24.5100346,   47.5956955,  -7.27272749
  26954,  -25.4120426,   47.5956955,  -7.27272749
  26955,  -26.3140488,   47.5956955,  -7.27272749
  26956,  -27.2355385,   47.5956955,  -7.27272749
  26957,  -28.1570244,   47.5956955,  -7.27272749
  26958,  -29.0785122,   47.5956955,  -7.27272749
  26959,  -20.8996449,   47.5837326,  -6.36363649
  26960,  -21.7992916,   47.5837326,  -6.36363649
  26961,  -22.6989365,   47.5837326,  -6.36363649
  26962,  -23.5985832,   47.5837326,  -6.36363649
  26963,  -24.4982281,   47.5837326,  -6.36363649
  26964,  -25.3978748,   47.5837326,  -6.36363649
  26965,  -26.2975197,   47.5837326,  -6.36363649
  26966,  -27.2231407,   47.5837326,  -6.36363649
  26967,  -28.1487598,   47.5837326,  -6.36363649
  26968,  -29.0743809,   47.5837326,  -6.36363649
  26969,  -20.8972836,   47.5717697,   -5.4545455
  26970,   -21.794569,   47.5717697,   -5.4545455
  26971,  -22.6918526,   47.5717697,   -5.4545455
  26972,   -23.589138,   47.5717697,   -5.4545455
  26973,  -24.4864216,   47.5717697,   -5.4545455
  26974,   -25.383707,   47.5717697,   -5.4545455
  26975,  -26.2809906,   47.5717697,   -5.4545455
  26976,  -27.2107449,   47.5717697,   -5.4545455
  26977,  -28.1404953,   47.5717697,   -5.4545455
  26978,  -29.0702477,   47.5717697,   -5.4545455
  26979,  -20.8949242,   47.5598068,   -4.5454545
  26980,  -21.7898464,   47.5598068,   -4.5454545
  26981,  -22.6847706,   47.5598068,   -4.5454545
  26982,  -23.5796928,   47.5598068,   -4.5454545
  26983,   -24.474617,   47.5598068,   -4.5454545
  26984,  -25.3695412,   47.5598068,   -4.5454545
  26985,  -26.2644634,   47.5598068,   -4.5454545
  26986,  -27.1983471,   47.5598068,   -4.5454545
  26987,  -28.1322327,   47.5598068,   -4.5454545
  26988,  -29.0661163,   47.5598068,   -4.5454545
  26989,  -20.8925629,   47.5478477,  -3.63636374
  26990,  -21.7851238,   47.5478477,  -3.63636374
  26991,  -22.6776867,   47.5478477,  -3.63636374
  26992,  -23.5702477,   47.5478477,  -3.63636374
  26993,  -24.4628105,   47.5478477,  -3.63636374
  26994,  -25.3553734,   47.5478477,  -3.63636374
  26995,  -26.2479343,   47.5478477,  -3.63636374
  26996,  -27.1859512,   47.5478477,  -3.63636374
  26997,  -28.1239681,   47.5478477,  -3.63636374
  26998,  -29.0619831,   47.5478477,  -3.63636374
  26999,  -20.8902016,   47.5358849,  -2.72727275
  27000,  -21.7804012,   47.5358849,  -2.72727275
  27001,  -22.6706028,   47.5358849,  -2.72727275
  27002,  -23.5608025,   47.5358849,  -2.72727275
  27003,   -24.451004,   47.5358849,  -2.72727275
  27004,  -25.3412056,   47.5358849,  -2.72727275
  27005,  -26.2314053,   47.5358849,  -2.72727275
  27006,  -27.1735535,   47.5358849,  -2.72727275
  27007,  -28.1157036,   47.5358849,  -2.72727275
  27008,  -29.0578518,   47.5358849,  -2.72727275
  27009,  -20.8878403,    47.523922,  -1.81818187
  27010,  -21.7756786,    47.523922,  -1.81818187
  27011,  -22.6635189,    47.523922,  -1.81818187
  27012,  -23.5513573,    47.523922,  -1.81818187
  27013,  -24.4391975,    47.523922,  -1.81818187
  27014,  -25.3270378,    47.523922,  -1.81818187
  27015,  -26.2148762,    47.523922,  -1.81818187
  27016,  -27.1611576,    47.523922,  -1.81818187
  27017,   -28.107439,    47.523922,  -1.81818187
  27018,  -29.0537186,    47.523922,  -1.81818187
  27019,   -20.885479,   47.5119629, -0.909090936
  27020,   -21.770956,   47.5119629, -0.909090936
  27021,   -22.656435,   47.5119629, -0.909090936
  27022,  -23.5419121,   47.5119629, -0.909090936
  27023,  -24.4273911,   47.5119629, -0.909090936
  27024,    -25.31287,   47.5119629, -0.909090936
  27025,  -26.1983471,   47.5119629, -0.909090936
  27026,  -27.1487598,   47.5119629, -0.909090936
  27027,  -28.0991745,   47.5119629, -0.909090936
  27028,  -29.0495872,   47.5119629, -0.909090936
  27029,  -20.9075165,   48.4130783,    -9.090909
  27030,   -21.815033,   48.4130783,    -9.090909
  27031,  -22.7225494,   48.4130783,    -9.090909
  27032,  -23.6300678,   48.4130783,    -9.090909
  27033,  -24.5375824,   48.4130783,    -9.090909
  27034,  -25.4451008,   48.4130783,    -9.090909
  27035,  -26.3526173,   48.4130783,    -9.090909
  27036,  -27.2644634,   48.4130783,    -9.090909
  27037,  -28.1763077,   48.4130783,    -9.090909
  27038,  -29.0881557,   48.4130783,    -9.090909
  27039,   -20.905941,   48.4051018,  -8.18181801
  27040,  -21.8118858,   48.4051018,  -8.18181801
  27041,  -22.7178268,   48.4051018,  -8.18181801
  27042,  -23.6237698,   48.4051018,  -8.18181801
  27043,  -24.5297127,   48.4051018,  -8.18181801
  27044,  -25.4356556,   48.4051018,  -8.18181801
  27045,  -26.3415966,   48.4051018,  -8.18181801
  27046,  -27.2561989,   48.4051018,  -8.18181801
  27047,  -28.1707993,   48.4051018,  -8.18181801
  27048,  -29.0853996,   48.4051018,  -8.18181801
  27049,  -20.9043674,   48.3971291,  -7.27272749
  27050,  -21.8087368,   48.3971291,  -7.27272749
  27051,  -22.7131042,   48.3971291,  -7.27272749
  27052,  -23.6174736,   48.3971291,  -7.27272749
  27053,   -24.521841,   48.3971291,  -7.27272749
  27054,  -25.4262104,   48.3971291,  -7.27272749
  27055,  -26.3305779,   48.3971291,  -7.27272749
  27056,  -27.2479343,   48.3971291,  -7.27272749
  27057,  -28.1652889,   48.3971291,  -7.27272749
  27058,  -29.0826454,   48.3971291,  -7.27272749
  27059,  -20.9027939,   48.3891563,  -6.36363649
  27060,  -21.8055878,   48.3891563,  -6.36363649
  27061,  -22.7083817,   48.3891563,  -6.36363649
  27062,  -23.6111774,   48.3891563,  -6.36363649
  27063,  -24.5139694,   48.3891563,  -6.36363649
  27064,  -25.4167652,   48.3891563,  -6.36363649
  27065,  -26.3195591,   48.3891563,  -6.36363649
  27066,  -27.2396698,   48.3891563,  -6.36363649
  27067,  -28.1597786,   48.3891563,  -6.36363649
  27068,  -29.0798912,   48.3891563,  -6.36363649
  27069,  -20.9012203,   48.3811798,   -5.4545455
  27070,  -21.8024406,   48.3811798,   -5.4545455
  27071,  -22.7036591,   48.3811798,   -5.4545455
  27072,  -23.6048794,   48.3811798,   -5.4545455
  27073,  -24.5060997,   48.3811798,   -5.4545455
  27074,    -25.40732,   48.3811798,   -5.4545455
  27075,  -26.3085403,   48.3811798,   -5.4545455
  27076,  -27.2314053,   48.3811798,   -5.4545455
  27077,  -28.1542702,   48.3811798,   -5.4545455
  27078,  -29.0771351,   48.3811798,   -5.4545455
  27079,  -20.8996449,   48.3732071,   -4.5454545
  27080,  -21.7992916,   48.3732071,   -4.5454545
  27081,  -22.6989384,   48.3732071,   -4.5454545
  27082,  -23.5985832,   48.3732071,   -4.5454545
  27083,  -24.4982281,   48.3732071,   -4.5454545
  27084,  -25.3978748,   48.3732071,   -4.5454545
  27085,  -26.2975197,   48.3732071,   -4.5454545
  27086,  -27.2231407,   48.3732071,   -4.5454545
  27087,  -28.1487598,   48.3732071,   -4.5454545
  27088,  -29.0743809,   48.3732071,   -4.5454545
  27089,  -20.8980713,   48.3652306,  -3.63636374
  27090,  -21.7961445,   48.3652306,  -3.63636374
  27091,  -22.6942158,   48.3652306,  -3.63636374
  27092,  -23.5922852,   48.3652306,  -3.63636374
  27093,  -24.4903584,   48.3652306,  -3.63636374
  27094,  -25.3884296,   48.3652306,  -3.63636374
  27095,  -26.2865009,   48.3652306,  -3.63636374
  27096,  -27.2148762,   48.3652306,  -3.63636374
  27097,  -28.1432514,   48.3652306,  -3.63636374
  27098,  -29.0716248,   48.3652306,  -3.63636374
  27099,  -20.8964977,   48.3572578,  -2.72727275
  27100,  -21.7929955,   48.3572578,  -2.72727275
  27101,  -22.6894932,   48.3572578,  -2.72727275
  27102,   -23.585989,   48.3572578,  -2.72727275
  27103,  -24.4824867,   48.3572578,  -2.72727275
  27104,  -25.3789845,   48.3572578,  -2.72727275
  27105,  -26.2754822,   48.3572578,  -2.72727275
  27106,  -27.2066116,   48.3572578,  -2.72727275
  27107,  -28.1377411,   48.3572578,  -2.72727275
  27108,  -29.0688705,   48.3572578,  -2.72727275
  27109,  -20.8949242,   48.3492813,  -1.81818187
  27110,  -21.7898464,   48.3492813,  -1.81818187
  27111,  -22.6847706,   48.3492813,  -1.81818187
  27112,  -23.5796928,   48.3492813,  -1.81818187
  27113,  -24.4746151,   48.3492813,  -1.81818187
  27114,  -25.3695393,   48.3492813,  -1.81818187
  27115,  -26.2644634,   48.3492813,  -1.81818187
  27116,  -27.1983471,   48.3492813,  -1.81818187
  27117,  -28.1322308,   48.3492813,  -1.81818187
  27118,  -29.0661163,   48.3492813,  -1.81818187
  27119,  -20.8933487,   48.3413086, -0.909090936
  27120,  -21.7866993,   48.3413086, -0.909090936
  27121,   -22.680048,   48.3413086, -0.909090936
  27122,  -23.5733948,   48.3413086, -0.909090936
  27123,  -24.4667454,   48.3413086, -0.909090936
  27124,  -25.3600941,   48.3413086, -0.909090936
  27125,  -26.2534428,   48.3413086, -0.909090936
  27126,  -27.1900826,   48.3413086, -0.909090936
  27127,  -28.1267223,   48.3413086, -0.909090936
  27128,  -29.0633602,   48.3413086, -0.909090936
  27129,  -20.9083023,   49.2065392,    -9.090909
  27130,  -21.8166084,   49.2065392,    -9.090909
  27131,  -22.7249107,   49.2065392,    -9.090909
  27132,   -23.633215,   49.2065392,    -9.090909
  27133,  -24.5415192,   49.2065392,    -9.090909
  27134,  -25.4498234,   49.2065392,    -9.090909
  27135,  -26.3581257,   49.2065392,    -9.090909
  27136,  -27.2685947,   49.2065392,    -9.090909
  27137,  -28.1790638,   49.2065392,    -9.090909
  27138,  -29.0895329,   49.2065392,    -9.090909
  27139,  -20.9075165,   49.2025528,  -8.18181801
  27140,   -21.815033,   49.2025528,  -8.18181801
  27141,  -22.7225494,   49.2025528,  -8.18181801
  27142,  -23.6300678,   49.2025528,  -8.18181801
  27143,  -24.5375824,   49.2025528,  -8.18181801
  27144,  -25.4451008,   49.2025528,  -8.18181801
  27145,  -26.3526173,   49.2025528,  -8.18181801
  27146,  -27.2644634,   49.2025528,  -8.18181801
  27147,  -28.1763077,   49.2025528,  -8.18181801
  27148,  -29.0881557,   49.2025528,  -8.18181801
  27149,  -20.9067287,   49.1985664,  -7.27272749
  27150,  -21.8134594,   49.1985664,  -7.27272749
  27151,  -22.7201881,   49.1985664,  -7.27272749
  27152,  -23.6269188,   49.1985664,  -7.27272749
  27153,  -24.5336475,   49.1985664,  -7.27272749
  27154,  -25.4403782,   49.1985664,  -7.27272749
  27155,  -26.3471069,   49.1985664,  -7.27272749
  27156,  -27.2603302,   49.1985664,  -7.27272749
  27157,  -28.1735535,   49.1985664,  -7.27272749
  27158,  -29.0867767,   49.1985664,  -7.27272749
  27159,   -20.905941,   49.1945763,  -6.36363649
  27160,  -21.8118858,   49.1945763,  -6.36363649
  27161,  -22.7178268,   49.1945763,  -6.36363649
  27162,  -23.6237698,   49.1945763,  -6.36363649
  27163,  -24.5297127,   49.1945763,  -6.36363649
  27164,  -25.4356556,   49.1945763,  -6.36363649
  27165,  -26.3415966,   49.1945763,  -6.36363649
  27166,  -27.2561989,   49.1945763,  -6.36363649
  27167,  -28.1707993,   49.1945763,  -6.36363649
  27168,  -29.0853996,   49.1945763,  -6.36363649
  27169,  -20.9051552,   49.1905899,   -5.4545455
  27170,  -21.8103104,   49.1905899,   -5.4545455
  27171,  -22.7154655,   49.1905899,   -5.4545455
  27172,  -23.6206226,   49.1905899,   -5.4545455
  27173,  -24.5257778,   49.1905899,   -5.4545455
  27174,   -25.430933,   49.1905899,   -5.4545455
  27175,  -26.3360882,   49.1905899,   -5.4545455
  27176,  -27.2520657,   49.1905899,   -5.4545455
  27177,   -28.168045,   49.1905899,   -5.4545455
  27178,  -29.0840225,   49.1905899,   -5.4545455
  27179,  -20.9043674,   49.1866035,   -4.5454545
  27180,  -21.8087368,   49.1866035,   -4.5454545
  27181,  -22.7131042,   49.1866035,   -4.5454545
  27182,  -23.6174736,   49.1866035,   -4.5454545
  27183,   -24.521841,   49.1866035,   -4.5454545
  27184,  -25.4262104,   49.1866035,   -4.5454545
  27185,  -26.3305779,   49.1866035,   -4.5454545
  27186,  -27.2479343,   49.1866035,   -4.5454545
  27187,  -28.1652889,   49.1866035,   -4.5454545
  27188,  -29.0826454,   49.1866035,   -4.5454545
  27189,  -20.9035816,   49.1826172,  -3.63636374
  27190,  -21.8071613,   49.1826172,  -3.63636374
  27191,   -22.710743,   49.1826172,  -3.63636374
  27192,  -23.6143265,   49.1826172,  -3.63636374
  27193,  -24.5179062,   49.1826172,  -3.63636374
  27194,  -25.4214878,   49.1826172,  -3.63636374
  27195,  -26.3250694,   49.1826172,  -3.63636374
  27196,  -27.2438011,   49.1826172,  -3.63636374
  27197,  -28.1625347,   49.1826172,  -3.63636374
  27198,  -29.0812683,   49.1826172,  -3.63636374
  27199,  -20.9027939,    49.178627,  -2.72727275
  27200,  -21.8055878,    49.178627,  -2.72727275
  27201,  -22.7083817,    49.178627,  -2.72727275
  27202,  -23.6111774,    49.178627,  -2.72727275
  27203,  -24.5139713,    49.178627,  -2.72727275
  27204,  -25.4167652,    49.178627,  -2.72727275
  27205,  -26.3195591,    49.178627,  -2.72727275
  27206,  -27.2396698,    49.178627,  -2.72727275
  27207,  -28.1597805,    49.178627,  -2.72727275
  27208,  -29.0798912,    49.178627,  -2.72727275
  27209,  -20.9020061,   49.1746407,  -1.81818187
  27210,  -21.8040142,   49.1746407,  -1.81818187
  27211,  -22.7060204,   49.1746407,  -1.81818187
  27212,  -23.6080284,   49.1746407,  -1.81818187
  27213,  -24.5100365,   49.1746407,  -1.81818187
  27214,  -25.4120426,   49.1746407,  -1.81818187
  27215,  -26.3140488,   49.1746407,  -1.81818187
  27216,  -27.2355366,   49.1746407,  -1.81818187
  27217,  -28.1570263,   49.1746407,  -1.81818187
  27218,  -29.0785122,   49.1746407,  -1.81818187
  27219,  -20.9012203,   49.1706543, -0.909090936
  27220,  -21.8024387,   49.1706543, -0.909090936
  27221,  -22.7036591,   49.1706543, -0.909090936
  27222,  -23.6048813,   49.1706543, -0.909090936
  27223,  -24.5060997,   49.1706543, -0.909090936
  27224,    -25.40732,   49.1706543, -0.909090936
  27225,  -26.3085403,   49.1706543, -0.909090936
  27226,  -27.2314053,   49.1706543, -0.909090936
  27227,  -28.1542702,   49.1706543, -0.909090936
  27228,  -29.0771351,   49.1706543, -0.909090936
  27229,   20.8983479,   50.6701698, -0.909090936
  27230,   21.8069725,   50.6993065, -0.909090936
  27231,   22.7155952,   50.7284431, -0.909090936
  27232,   23.6242199,   50.7575836, -0.909090936
  27233,   24.5328426,   50.7867203, -0.909090936
  27234,   25.4414673,   50.8158569, -0.909090936
  27235,   26.3500919,   50.8449974, -0.909090936
  27236,   27.2587147,   50.8741341, -0.909090936
  27237,   28.1673393,   50.9032707, -0.909090936
  27238,   29.0759621,   50.9324112, -0.909090936
  27239,   20.8983479,   50.6701698,  -1.81818187
  27240,   21.8069725,   50.6993065,  -1.81818187
  27241,   22.7155952,   50.7284431,  -1.81818187
  27242,   23.6242199,   50.7575836,  -1.81818187
  27243,   24.5328426,   50.7867203,  -1.81818187
  27244,   25.4414673,   50.8158569,  -1.81818187
  27245,   26.3500919,   50.8449974,  -1.81818187
  27246,   27.2587147,   50.8741341,  -1.81818187
  27247,   28.1673393,   50.9032707,  -1.81818187
  27248,   29.0759621,   50.9324112,  -1.81818187
  27249,   20.8983479,   50.6701698,  -2.72727275
  27250,   21.8069725,   50.6993065,  -2.72727275
  27251,   22.7155952,   50.7284431,  -2.72727275
  27252,   23.6242199,   50.7575836,  -2.72727275
  27253,   24.5328426,   50.7867203,  -2.72727275
  27254,   25.4414673,   50.8158569,  -2.72727275
  27255,   26.3500919,   50.8449974,  -2.72727275
  27256,   27.2587147,   50.8741341,  -2.72727275
  27257,   28.1673393,   50.9032707,  -2.72727275
  27258,   29.0759621,   50.9324112,  -2.72727275
  27259,   20.8983479,   50.6701698,  -3.63636374
  27260,   21.8069725,   50.6993065,  -3.63636374
  27261,   22.7155952,   50.7284431,  -3.63636374
  27262,   23.6242199,   50.7575836,  -3.63636374
  27263,   24.5328426,   50.7867203,  -3.63636374
  27264,   25.4414673,   50.8158569,  -3.63636374
  27265,   26.3500919,   50.8449974,  -3.63636374
  27266,   27.2587147,   50.8741341,  -3.63636374
  27267,   28.1673393,   50.9032707,  -3.63636374
  27268,   29.0759621,   50.9324112,  -3.63636374
  27269,   20.8983479,   50.6701698,   -4.5454545
  27270,   21.8069725,   50.6993065,   -4.5454545
  27271,   22.7155952,   50.7284431,   -4.5454545
  27272,   23.6242199,   50.7575836,   -4.5454545
  27273,   24.5328426,   50.7867203,   -4.5454545
  27274,   25.4414673,   50.8158569,   -4.5454545
  27275,   26.3500919,   50.8449974,   -4.5454545
  27276,   27.2587147,   50.8741341,   -4.5454545
  27277,   28.1673393,   50.9032707,   -4.5454545
  27278,   29.0759621,   50.9324112,   -4.5454545
  27279,   20.8983479,   50.6701698,   -5.4545455
  27280,   21.8069725,   50.6993065,   -5.4545455
  27281,   22.7155952,   50.7284431,   -5.4545455
  27282,   23.6242199,   50.7575836,   -5.4545455
  27283,   24.5328426,   50.7867203,   -5.4545455
  27284,   25.4414673,   50.8158569,   -5.4545455
  27285,   26.3500919,   50.8449974,   -5.4545455
  27286,   27.2587147,   50.8741341,   -5.4545455
  27287,   28.1673393,   50.9032707,   -5.4545455
  27288,   29.0759621,   50.9324112,   -5.4545455
  27289,   20.8983479,   50.6701698,  -6.36363649
  27290,   21.8069725,   50.6993065,  -6.36363649
  27291,   22.7155952,   50.7284431,  -6.36363649
  27292,   23.6242199,   50.7575836,  -6.36363649
  27293,   24.5328426,   50.7867203,  -6.36363649
  27294,   25.4414673,   50.8158569,  -6.36363649
  27295,   26.3500919,   50.8449974,  -6.36363649
  27296,   27.2587147,   50.8741341,  -6.36363649
  27297,   28.1673393,   50.9032707,  -6.36363649
  27298,   29.0759621,   50.9324112,  -6.36363649
  27299,   20.8983479,   50.6701698,  -7.27272749
  27300,   21.8069725,   50.6993065,  -7.27272749
  27301,   22.7155952,   50.7284431,  -7.27272749
  27302,   23.6242199,   50.7575836,  -7.27272749
  27303,   24.5328426,   50.7867203,  -7.27272749
  27304,   25.4414673,   50.8158569,  -7.27272749
  27305,   26.3500919,   50.8449974,  -7.27272749
  27306,   27.2587147,   50.8741341,  -7.27272749
  27307,   28.1673393,   50.9032707,  -7.27272749
  27308,   29.0759621,   50.9324112,  -7.27272749
  27309,   20.8983479,   50.6701698,  -8.18181801
  27310,   21.8069725,   50.6993065,  -8.18181801
  27311,   22.7155952,   50.7284431,  -8.18181801
  27312,   23.6242199,   50.7575836,  -8.18181801
  27313,   24.5328426,   50.7867203,  -8.18181801
  27314,   25.4414673,   50.8158569,  -8.18181801
  27315,   26.3500919,   50.8449974,  -8.18181801
  27316,   27.2587147,   50.8741341,  -8.18181801
  27317,   28.1673393,   50.9032707,  -8.18181801
  27318,   29.0759621,   50.9324112,  -8.18181801
  27319,   20.8983479,   50.6701698,    -9.090909
  27320,   21.8069725,   50.6993065,    -9.090909
  27321,   22.7155952,   50.7284431,    -9.090909
  27322,   23.6242199,   50.7575836,    -9.090909
  27323,   24.5328426,   50.7867203,    -9.090909
  27324,   25.4414673,   50.8158569,    -9.090909
  27325,   26.3500919,   50.8449974,    -9.090909
  27326,   27.2587147,   50.8741341,    -9.090909
  27327,   28.1673393,   50.9032707,    -9.090909
  27328,   29.0759621,   50.9324112,    -9.090909
  27329,   20.8661308,   51.3396492, -0.909090936
  27330,   21.7733536,   51.3978958, -0.909090936
  27331,   22.6805763,   51.4561424, -0.909090936
  27332,    23.587801,   51.5143852, -0.909090936
  27333,   24.4950237,   51.5726318, -0.909090936
  27334,   25.4022465,   51.6308784, -0.909090936
  27335,   26.3094692,   51.6891251, -0.909090936
  27336,    27.216692,   51.7473679, -0.909090936
  27337,   28.1239147,   51.8056145, -0.909090936
  27338,   29.0311394,   51.8638611, -0.909090936
  27339,   20.8661308,   51.3396492,  -1.81818187
  27340,   21.7733536,   51.3978958,  -1.81818187
  27341,   22.6805763,   51.4561424,  -1.81818187
  27342,    23.587801,   51.5143852,  -1.81818187
  27343,   24.4950237,   51.5726318,  -1.81818187
  27344,   25.4022465,   51.6308784,  -1.81818187
  27345,   26.3094692,   51.6891251,  -1.81818187
  27346,    27.216692,   51.7473679,  -1.81818187
  27347,   28.1239147,   51.8056145,  -1.81818187
  27348,   29.0311394,   51.8638611,  -1.81818187
  27349,   20.8661308,   51.3396492,  -2.72727275
  27350,   21.7733536,   51.3978958,  -2.72727275
  27351,   22.6805763,   51.4561424,  -2.72727275
  27352,    23.587801,   51.5143852,  -2.72727275
  27353,   24.4950237,   51.5726318,  -2.72727275
  27354,   25.4022465,   51.6308784,  -2.72727275
  27355,   26.3094692,   51.6891251,  -2.72727275
  27356,    27.216692,   51.7473679,  -2.72727275
  27357,   28.1239147,   51.8056145,  -2.72727275
  27358,   29.0311394,   51.8638611,  -2.72727275
  27359,   20.8661308,   51.3396492,  -3.63636374
  27360,   21.7733536,   51.3978958,  -3.63636374
  27361,   22.6805763,   51.4561424,  -3.63636374
  27362,    23.587801,   51.5143852,  -3.63636374
  27363,   24.4950237,   51.5726318,  -3.63636374
  27364,   25.4022465,   51.6308784,  -3.63636374
  27365,   26.3094692,   51.6891251,  -3.63636374
  27366,    27.216692,   51.7473679,  -3.63636374
  27367,   28.1239147,   51.8056145,  -3.63636374
  27368,   29.0311394,   51.8638611,  -3.63636374
  27369,   20.8661308,   51.3396492,   -4.5454545
  27370,   21.7733536,   51.3978958,   -4.5454545
  27371,   22.6805763,   51.4561424,   -4.5454545
  27372,    23.587801,   51.5143852,   -4.5454545
  27373,   24.4950237,   51.5726318,   -4.5454545
  27374,   25.4022465,   51.6308784,   -4.5454545
  27375,   26.3094692,   51.6891251,   -4.5454545
  27376,    27.216692,   51.7473679,   -4.5454545
  27377,   28.1239147,   51.8056145,   -4.5454545
  27378,   29.0311394,   51.8638611,   -4.5454545
  27379,   20.8661308,   51.3396492,   -5.4545455
  27380,   21.7733536,   51.3978958,   -5.4545455
  27381,   22.6805763,   51.4561424,   -5.4545455
  27382,    23.587801,   51.5143852,   -5.4545455
  27383,   24.4950237,   51.5726318,   -5.4545455
  27384,   25.4022465,   51.6308784,   -5.4545455
  27385,   26.3094692,   51.6891251,   -5.4545455
  27386,    27.216692,   51.7473679,   -5.4545455
  27387,   28.1239147,   51.8056145,   -5.4545455
  27388,   29.0311394,   51.8638611,   -5.4545455
  27389,   20.8661308,   51.3396492,  -6.36363649
  27390,   21.7733536,   51.3978958,  -6.36363649
  27391,   22.6805763,   51.4561424,  -6.36363649
  27392,    23.587801,   51.5143852,  -6.36363649
  27393,   24.4950237,   51.5726318,  -6.36363649
  27394,   25.4022465,   51.6308784,  -6.36363649
  27395,   26.3094692,   51.6891251,  -6.36363649
  27396,    27.216692,   51.7473679,  -6.36363649
  27397,   28.1239147,   51.8056145,  -6.36363649
  27398,   29.0311394,   51.8638611,  -6.36363649
  27399,   20.8661308,   51.3396492,  -7.27272749
  27400,   21.7733536,   51.3978958,  -7.27272749
  27401,   22.6805763,   51.4561424,  -7.27272749
  27402,    23.587801,   51.5143852,  -7.27272749
  27403,   24.4950237,   51.5726318,  -7.27272749
  27404,   25.4022465,   51.6308784,  -7.27272749
  27405,   26.3094692,   51.6891251,  -7.27272749
  27406,    27.216692,   51.7473679,  -7.27272749
  27407,   28.1239147,   51.8056145,  -7.27272749
  27408,   29.0311394,   51.8638611,  -7.27272749
  27409,   20.8661308,   51.3396492,  -8.18181801
  27410,   21.7733536,   51.3978958,  -8.18181801
  27411,   22.6805763,   51.4561424,  -8.18181801
  27412,    23.587801,   51.5143852,  -8.18181801
  27413,   24.4950237,   51.5726318,  -8.18181801
  27414,   25.4022465,   51.6308784,  -8.18181801
  27415,   26.3094692,   51.6891251,  -8.18181801
  27416,    27.216692,   51.7473679,  -8.18181801
  27417,   28.1239147,   51.8056145,  -8.18181801
  27418,   29.0311394,   51.8638611,  -8.18181801
  27419,   20.8661308,   51.3396492,    -9.090909
  27420,   21.7733536,   51.3978958,    -9.090909
  27421,   22.6805763,   51.4561424,    -9.090909
  27422,    23.587801,   51.5143852,    -9.090909
  27423,   24.4950237,   51.5726318,    -9.090909
  27424,   25.4022465,   51.6308784,    -9.090909
  27425,   26.3094692,   51.6891251,    -9.090909
  27426,    27.216692,   51.7473679,    -9.090909
  27427,   28.1239147,   51.8056145,    -9.090909
  27428,   29.0311394,   51.8638611,    -9.090909
  27429,   20.8124752,   52.0077553, -0.909090936
  27430,   21.7173653,    52.095047, -0.909090936
  27431,   22.6222553,   52.1823425, -0.909090936
  27432,   23.5271454,   52.2696342, -0.909090936
  27433,   24.4320354,   52.3569298, -0.909090936
  27434,   25.3369236,   52.4442215, -0.909090936
  27435,   26.2418137,    52.531517, -0.909090936
  27436,   27.1467037,   52.6188087, -0.909090936
  27437,   28.0515938,   52.7061043, -0.909090936
  27438,   28.9564838,    52.793396, -0.909090936
  27439,   20.8124752,   52.0077553,  -1.81818187
  27440,   21.7173653,    52.095047,  -1.81818187
  27441,   22.6222553,   52.1823425,  -1.81818187
  27442,   23.5271454,   52.2696342,  -1.81818187
  27443,   24.4320354,   52.3569298,  -1.81818187
  27444,   25.3369236,   52.4442215,  -1.81818187
  27445,   26.2418137,    52.531517,  -1.81818187
  27446,   27.1467037,   52.6188087,  -1.81818187
  27447,   28.0515938,   52.7061043,  -1.81818187
  27448,   28.9564838,    52.793396,  -1.81818187
  27449,   20.8124752,   52.0077553,  -2.72727275
  27450,   21.7173653,    52.095047,  -2.72727275
  27451,   22.6222553,   52.1823425,  -2.72727275
  27452,   23.5271454,   52.2696342,  -2.72727275
  27453,   24.4320354,   52.3569298,  -2.72727275
  27454,   25.3369236,   52.4442215,  -2.72727275
  27455,   26.2418137,    52.531517,  -2.72727275
  27456,   27.1467037,   52.6188087,  -2.72727275
  27457,   28.0515938,   52.7061043,  -2.72727275
  27458,   28.9564838,    52.793396,  -2.72727275
  27459,   20.8124752,   52.0077553,  -3.63636374
  27460,   21.7173653,    52.095047,  -3.63636374
  27461,   22.6222553,   52.1823425,  -3.63636374
  27462,   23.5271454,   52.2696342,  -3.63636374
  27463,   24.4320354,   52.3569298,  -3.63636374
  27464,   25.3369236,   52.4442215,  -3.63636374
  27465,   26.2418137,    52.531517,  -3.63636374
  27466,   27.1467037,   52.6188087,  -3.63636374
  27467,   28.0515938,   52.7061043,  -3.63636374
  27468,   28.9564838,    52.793396,  -3.63636374
  27469,   20.8124752,   52.0077553,   -4.5454545
  27470,   21.7173653,    52.095047,   -4.5454545
  27471,   22.6222553,   52.1823425,   -4.5454545
  27472,   23.5271454,   52.2696342,   -4.5454545
  27473,   24.4320354,   52.3569298,   -4.5454545
  27474,   25.3369236,   52.4442215,   -4.5454545
  27475,   26.2418137,    52.531517,   -4.5454545
  27476,   27.1467037,   52.6188087,   -4.5454545
  27477,   28.0515938,   52.7061043,   -4.5454545
  27478,   28.9564838,    52.793396,   -4.5454545
  27479,   20.8124752,   52.0077553,   -5.4545455
  27480,   21.7173653,    52.095047,   -5.4545455
  27481,   22.6222553,   52.1823425,   -5.4545455
  27482,   23.5271454,   52.2696342,   -5.4545455
  27483,   24.4320354,   52.3569298,   -5.4545455
  27484,   25.3369236,   52.4442215,   -5.4545455
  27485,   26.2418137,    52.531517,   -5.4545455
  27486,   27.1467037,   52.6188087,   -5.4545455
  27487,   28.0515938,   52.7061043,   -5.4545455
  27488,   28.9564838,    52.793396,   -5.4545455
  27489,   20.8124752,   52.0077553,  -6.36363649
  27490,   21.7173653,    52.095047,  -6.36363649
  27491,   22.6222553,   52.1823425,  -6.36363649
  27492,   23.5271454,   52.2696342,  -6.36363649
  27493,   24.4320354,   52.3569298,  -6.36363649
  27494,   25.3369236,   52.4442215,  -6.36363649
  27495,   26.2418137,    52.531517,  -6.36363649
  27496,   27.1467037,   52.6188087,  -6.36363649
  27497,   28.0515938,   52.7061043,  -6.36363649
  27498,   28.9564838,    52.793396,  -6.36363649
  27499,   20.8124752,   52.0077553,  -7.27272749
  27500,   21.7173653,    52.095047,  -7.27272749
  27501,   22.6222553,   52.1823425,  -7.27272749
  27502,   23.5271454,   52.2696342,  -7.27272749
  27503,   24.4320354,   52.3569298,  -7.27272749
  27504,   25.3369236,   52.4442215,  -7.27272749
  27505,   26.2418137,    52.531517,  -7.27272749
  27506,   27.1467037,   52.6188087,  -7.27272749
  27507,   28.0515938,   52.7061043,  -7.27272749
  27508,   28.9564838,    52.793396,  -7.27272749
  27509,   20.8124752,   52.0077553,  -8.18181801
  27510,   21.7173653,    52.095047,  -8.18181801
  27511,   22.6222553,   52.1823425,  -8.18181801
  27512,   23.5271454,   52.2696342,  -8.18181801
  27513,   24.4320354,   52.3569298,  -8.18181801
  27514,   25.3369236,   52.4442215,  -8.18181801
  27515,   26.2418137,    52.531517,  -8.18181801
  27516,   27.1467037,   52.6188087,  -8.18181801
  27517,   28.0515938,   52.7061043,  -8.18181801
  27518,   28.9564838,    52.793396,  -8.18181801
  27519,   20.8124752,   52.0077553,    -9.090909
  27520,   21.7173653,    52.095047,    -9.090909
  27521,   22.6222553,   52.1823425,    -9.090909
  27522,   23.5271454,   52.2696342,    -9.090909
  27523,   24.4320354,   52.3569298,    -9.090909
  27524,   25.3369236,   52.4442215,    -9.090909
  27525,   26.2418137,    52.531517,    -9.090909
  27526,   27.1467037,   52.6188087,    -9.090909
  27527,   28.0515938,   52.7061043,    -9.090909
  27528,   28.9564838,    52.793396,    -9.090909
  27529,   20.7374268,   52.6737938, -0.909090936
  27530,   21.6390553,   52.7900467, -0.909090936
  27531,   22.5406818,   52.9062996, -0.909090936
  27532,   23.4423103,   53.0225525, -0.909090936
  27533,   24.3439369,   53.1388016, -0.909090936
  27534,   25.2455635,   53.2550545, -0.909090936
  27535,    26.147192,   53.3713074, -0.909090936
  27536,   27.0488186,   53.4875603, -0.909090936
  27537,   27.9504452,   53.6038094, -0.909090936
  27538,   28.8520737,   53.7200623, -0.909090936
  27539,   20.7374268,   52.6737938,  -1.81818187
  27540,   21.6390553,   52.7900467,  -1.81818187
  27541,   22.5406818,   52.9062996,  -1.81818187
  27542,   23.4423103,   53.0225525,  -1.81818187
  27543,   24.3439369,   53.1388016,  -1.81818187
  27544,   25.2455635,   53.2550545,  -1.81818187
  27545,    26.147192,   53.3713074,  -1.81818187
  27546,   27.0488186,   53.4875603,  -1.81818187
  27547,   27.9504452,   53.6038094,  -1.81818187
  27548,   28.8520737,   53.7200623,  -1.81818187
  27549,   20.7374268,   52.6737938,  -2.72727275
  27550,   21.6390553,   52.7900467,  -2.72727275
  27551,   22.5406818,   52.9062996,  -2.72727275
  27552,   23.4423103,   53.0225525,  -2.72727275
  27553,   24.3439369,   53.1388016,  -2.72727275
  27554,   25.2455635,   53.2550545,  -2.72727275
  27555,    26.147192,   53.3713074,  -2.72727275
  27556,   27.0488186,   53.4875603,  -2.72727275
  27557,   27.9504452,   53.6038094,  -2.72727275
  27558,   28.8520737,   53.7200623,  -2.72727275
  27559,   20.7374268,   52.6737938,  -3.63636374
  27560,   21.6390553,   52.7900467,  -3.63636374
  27561,   22.5406818,   52.9062996,  -3.63636374
  27562,   23.4423103,   53.0225525,  -3.63636374
  27563,   24.3439369,   53.1388016,  -3.63636374
  27564,   25.2455635,   53.2550545,  -3.63636374
  27565,    26.147192,   53.3713074,  -3.63636374
  27566,   27.0488186,   53.4875603,  -3.63636374
  27567,   27.9504452,   53.6038094,  -3.63636374
  27568,   28.8520737,   53.7200623,  -3.63636374
  27569,   20.7374268,   52.6737938,   -4.5454545
  27570,   21.6390553,   52.7900467,   -4.5454545
  27571,   22.5406818,   52.9062996,   -4.5454545
  27572,   23.4423103,   53.0225525,   -4.5454545
  27573,   24.3439369,   53.1388016,   -4.5454545
  27574,   25.2455635,   53.2550545,   -4.5454545
  27575,    26.147192,   53.3713074,   -4.5454545
  27576,   27.0488186,   53.4875603,   -4.5454545
  27577,   27.9504452,   53.6038094,   -4.5454545
  27578,   28.8520737,   53.7200623,   -4.5454545
  27579,   20.7374268,   52.6737938,   -5.4545455
  27580,   21.6390553,   52.7900467,   -5.4545455
  27581,   22.5406818,   52.9062996,   -5.4545455
  27582,   23.4423103,   53.0225525,   -5.4545455
  27583,   24.3439369,   53.1388016,   -5.4545455
  27584,   25.2455635,   53.2550545,   -5.4545455
  27585,    26.147192,   53.3713074,   -5.4545455
  27586,   27.0488186,   53.4875603,   -5.4545455
  27587,   27.9504452,   53.6038094,   -5.4545455
  27588,   28.8520737,   53.7200623,   -5.4545455
  27589,   20.7374268,   52.6737938,  -6.36363649
  27590,   21.6390553,   52.7900467,  -6.36363649
  27591,   22.5406818,   52.9062996,  -6.36363649
  27592,   23.4423103,   53.0225525,  -6.36363649
  27593,   24.3439369,   53.1388016,  -6.36363649
  27594,   25.2455635,   53.2550545,  -6.36363649
  27595,    26.147192,   53.3713074,  -6.36363649
  27596,   27.0488186,   53.4875603,  -6.36363649
  27597,   27.9504452,   53.6038094,  -6.36363649
  27598,   28.8520737,   53.7200623,  -6.36363649
  27599,   20.7374268,   52.6737938,  -7.27272749
  27600,   21.6390553,   52.7900467,  -7.27272749
  27601,   22.5406818,   52.9062996,  -7.27272749
  27602,   23.4423103,   53.0225525,  -7.27272749
  27603,   24.3439369,   53.1388016,  -7.27272749
  27604,   25.2455635,   53.2550545,  -7.27272749
  27605,    26.147192,   53.3713074,  -7.27272749
  27606,   27.0488186,   53.4875603,  -7.27272749
  27607,   27.9504452,   53.6038094,  -7.27272749
  27608,   28.8520737,   53.7200623,  -7.27272749
  27609,   20.7374268,   52.6737938,  -8.18181801
  27610,   21.6390553,   52.7900467,  -8.18181801
  27611,   22.5406818,   52.9062996,  -8.18181801
  27612,   23.4423103,   53.0225525,  -8.18181801
  27613,   24.3439369,   53.1388016,  -8.18181801
  27614,   25.2455635,   53.2550545,  -8.18181801
  27615,    26.147192,   53.3713074,  -8.18181801
  27616,   27.0488186,   53.4875603,  -8.18181801
  27617,   27.9504452,   53.6038094,  -8.18181801
  27618,   28.8520737,   53.7200623,  -8.18181801
  27619,   20.7374268,   52.6737938,    -9.090909
  27620,   21.6390553,   52.7900467,    -9.090909
  27621,   22.5406818,   52.9062996,    -9.090909
  27622,   23.4423103,   53.0225525,    -9.090909
  27623,   24.3439369,   53.1388016,    -9.090909
  27624,   25.2455635,   53.2550545,    -9.090909
  27625,    26.147192,   53.3713074,    -9.090909
  27626,   27.0488186,   53.4875603,    -9.090909
  27627,   27.9504452,   53.6038094,    -9.090909
  27628,   28.8520737,   53.7200623,    -9.090909
  27629,   20.6410732,   53.3370895, -0.909090936
  27630,   21.5385113,   53.4821777, -0.909090936
  27631,   22.4359493,   53.6272697, -0.909090936
  27632,   23.3333874,   53.7723618, -0.909090936
  27633,   24.2308254,   53.9174538, -0.909090936
  27634,   25.1282635,    54.062542, -0.909090936
  27635,   26.0257015,    54.207634, -0.909090936
  27636,   26.9231396,    54.352726, -0.909090936
  27637,   27.8205776,   54.4978142, -0.909090936
  27638,   28.7180157,   54.6429062, -0.909090936
  27639,   20.6410732,   53.3370895,  -1.81818187
  27640,   21.5385113,   53.4821777,  -1.81818187
  27641,   22.4359493,   53.6272697,  -1.81818187
  27642,   23.3333874,   53.7723618,  -1.81818187
  27643,   24.2308254,   53.9174538,  -1.81818187
  27644,   25.1282635,    54.062542,  -1.81818187
  27645,   26.0257015,    54.207634,  -1.81818187
  27646,   26.9231396,    54.352726,  -1.81818187
  27647,   27.8205776,   54.4978142,  -1.81818187
  27648,   28.7180157,   54.6429062,  -1.81818187
  27649,   20.6410732,   53.3370895,  -2.72727275
  27650,   21.5385113,   53.4821777,  -2.72727275
  27651,   22.4359493,   53.6272697,  -2.72727275
  27652,   23.3333874,   53.7723618,  -2.72727275
  27653,   24.2308254,   53.9174538,  -2.72727275
  27654,   25.1282635,    54.062542,  -2.72727275
  27655,   26.0257015,    54.207634,  -2.72727275
  27656,   26.9231396,    54.352726,  -2.72727275
  27657,   27.8205776,   54.4978142,  -2.72727275
  27658,   28.7180157,   54.6429062,  -2.72727275
  27659,   20.6410732,   53.3370895,  -3.63636374
  27660,   21.5385113,   53.4821777,  -3.63636374
  27661,   22.4359493,   53.6272697,  -3.63636374
  27662,   23.3333874,   53.7723618,  -3.63636374
  27663,   24.2308254,   53.9174538,  -3.63636374
  27664,   25.1282635,    54.062542,  -3.63636374
  27665,   26.0257015,    54.207634,  -3.63636374
  27666,   26.9231396,    54.352726,  -3.63636374
  27667,   27.8205776,   54.4978142,  -3.63636374
  27668,   28.7180157,   54.6429062,  -3.63636374
  27669,   20.6410732,   53.3370895,   -4.5454545
  27670,   21.5385113,   53.4821777,   -4.5454545
  27671,   22.4359493,   53.6272697,   -4.5454545
  27672,   23.3333874,   53.7723618,   -4.5454545
  27673,   24.2308254,   53.9174538,   -4.5454545
  27674,   25.1282635,    54.062542,   -4.5454545
  27675,   26.0257015,    54.207634,   -4.5454545
  27676,   26.9231396,    54.352726,   -4.5454545
  27677,   27.8205776,   54.4978142,   -4.5454545
  27678,   28.7180157,   54.6429062,   -4.5454545
  27679,   20.6410732,   53.3370895,   -5.4545455
  27680,   21.5385113,   53.4821777,   -5.4545455
  27681,   22.4359493,   53.6272697,   -5.4545455
  27682,   23.3333874,   53.7723618,   -5.4545455
  27683,   24.2308254,   53.9174538,   -5.4545455
  27684,   25.1282635,    54.062542,   -5.4545455
  27685,   26.0257015,    54.207634,   -5.4545455
  27686,   26.9231396,    54.352726,   -5.4545455
  27687,   27.8205776,   54.4978142,   -5.4545455
  27688,   28.7180157,   54.6429062,   -5.4545455
  27689,   20.6410732,   53.3370895,  -6.36363649
  27690,   21.5385113,   53.4821777,  -6.36363649
  27691,   22.4359493,   53.6272697,  -6.36363649
  27692,   23.3333874,   53.7723618,  -6.36363649
  27693,   24.2308254,   53.9174538,  -6.36363649
  27694,   25.1282635,    54.062542,  -6.36363649
  27695,   26.0257015,    54.207634,  -6.36363649
  27696,   26.9231396,    54.352726,  -6.36363649
  27697,   27.8205776,   54.4978142,  -6.36363649
  27698,   28.7180157,   54.6429062,  -6.36363649
  27699,   20.6410732,   53.3370895,  -7.27272749
  27700,   21.5385113,   53.4821777,  -7.27272749
  27701,   22.4359493,   53.6272697,  -7.27272749
  27702,   23.3333874,   53.7723618,  -7.27272749
  27703,   24.2308254,   53.9174538,  -7.27272749
  27704,   25.1282635,    54.062542,  -7.27272749
  27705,   26.0257015,    54.207634,  -7.27272749
  27706,   26.9231396,    54.352726,  -7.27272749
  27707,   27.8205776,   54.4978142,  -7.27272749
  27708,   28.7180157,   54.6429062,  -7.27272749
  27709,   20.6410732,   53.3370895,  -8.18181801
  27710,   21.5385113,   53.4821777,  -8.18181801
  27711,   22.4359493,   53.6272697,  -8.18181801
  27712,   23.3333874,   53.7723618,  -8.18181801
  27713,   24.2308254,   53.9174538,  -8.18181801
  27714,   25.1282635,    54.062542,  -8.18181801
  27715,   26.0257015,    54.207634,  -8.18181801
  27716,   26.9231396,    54.352726,  -8.18181801
  27717,   27.8205776,   54.4978142,  -8.18181801
  27718,   28.7180157,   54.6429062,  -8.18181801
  27719,   20.6410732,   53.3370895,    -9.090909
  27720,   21.5385113,   53.4821777,    -9.090909
  27721,   22.4359493,   53.6272697,    -9.090909
  27722,   23.3333874,   53.7723618,    -9.090909
  27723,   24.2308254,   53.9174538,    -9.090909
  27724,   25.1282635,    54.062542,    -9.090909
  27725,   26.0257015,    54.207634,    -9.090909
  27726,   26.9231396,    54.352726,    -9.090909
  27727,   27.8205776,   54.4978142,    -9.090909
  27728,   28.7180157,   54.6429062,    -9.090909
  27729,     20.52351,   53.9969521, -0.909090936
  27730,   21.4158363,   54.1707344, -0.909090936
  27731,   22.3081627,   54.3445129, -0.909090936
  27732,    23.200489,   54.5182953, -0.909090936
  27733,   24.0928154,   54.6920738, -0.909090936
  27734,   24.9851398,   54.8658562, -0.909090936
  27735,   25.8774662,   55.0396347, -0.909090936
  27736,   26.7697926,   55.2134171, -0.909090936
  27737,   27.6621189,   55.3871994, -0.909090936
  27738,   28.5544472,   55.5609779, -0.909090936
  27739,     20.52351,   53.9969521,  -1.81818187
  27740,   21.4158363,   54.1707344,  -1.81818187
  27741,   22.3081627,   54.3445129,  -1.81818187
  27742,    23.200489,   54.5182953,  -1.81818187
  27743,   24.0928154,   54.6920738,  -1.81818187
  27744,   24.9851398,   54.8658562,  -1.81818187
  27745,   25.8774662,   55.0396347,  -1.81818187
  27746,   26.7697926,   55.2134171,  -1.81818187
  27747,   27.6621189,   55.3871994,  -1.81818187
  27748,   28.5544472,   55.5609779,  -1.81818187
  27749,     20.52351,   53.9969521,  -2.72727275
  27750,   21.4158363,   54.1707344,  -2.72727275
  27751,   22.3081627,   54.3445129,  -2.72727275
  27752,    23.200489,   54.5182953,  -2.72727275
  27753,   24.0928154,   54.6920738,  -2.72727275
  27754,   24.9851398,   54.8658562,  -2.72727275
  27755,   25.8774662,   55.0396347,  -2.72727275
  27756,   26.7697926,   55.2134171,  -2.72727275
  27757,   27.6621189,   55.3871994,  -2.72727275
  27758,   28.5544472,   55.5609779,  -2.72727275
  27759,     20.52351,   53.9969521,  -3.63636374
  27760,   21.4158363,   54.1707344,  -3.63636374
  27761,   22.3081627,   54.3445129,  -3.63636374
  27762,    23.200489,   54.5182953,  -3.63636374
  27763,   24.0928154,   54.6920738,  -3.63636374
  27764,   24.9851398,   54.8658562,  -3.63636374
  27765,   25.8774662,   55.0396347,  -3.63636374
  27766,   26.7697926,   55.2134171,  -3.63636374
  27767,   27.6621189,   55.3871994,  -3.63636374
  27768,   28.5544472,   55.5609779,  -3.63636374
  27769,     20.52351,   53.9969521,   -4.5454545
  27770,   21.4158363,   54.1707344,   -4.5454545
  27771,   22.3081627,   54.3445129,   -4.5454545
  27772,    23.200489,   54.5182953,   -4.5454545
  27773,   24.0928154,   54.6920738,   -4.5454545
  27774,   24.9851398,   54.8658562,   -4.5454545
  27775,   25.8774662,   55.0396347,   -4.5454545
  27776,   26.7697926,   55.2134171,   -4.5454545
  27777,   27.6621189,   55.3871994,   -4.5454545
  27778,   28.5544472,   55.5609779,   -4.5454545
  27779,     20.52351,   53.9969521,   -5.4545455
  27780,   21.4158363,   54.1707344,   -5.4545455
  27781,   22.3081627,   54.3445129,   -5.4545455
  27782,    23.200489,   54.5182953,   -5.4545455
  27783,   24.0928154,   54.6920738,   -5.4545455
  27784,   24.9851398,   54.8658562,   -5.4545455
  27785,   25.8774662,   55.0396347,   -5.4545455
  27786,   26.7697926,   55.2134171,   -5.4545455
  27787,   27.6621189,   55.3871994,   -5.4545455
  27788,   28.5544472,   55.5609779,   -5.4545455
  27789,     20.52351,   53.9969521,  -6.36363649
  27790,   21.4158363,   54.1707344,  -6.36363649
  27791,   22.3081627,   54.3445129,  -6.36363649
  27792,    23.200489,   54.5182953,  -6.36363649
  27793,   24.0928154,   54.6920738,  -6.36363649
  27794,   24.9851398,   54.8658562,  -6.36363649
  27795,   25.8774662,   55.0396347,  -6.36363649
  27796,   26.7697926,   55.2134171,  -6.36363649
  27797,   27.6621189,   55.3871994,  -6.36363649
  27798,   28.5544472,   55.5609779,  -6.36363649
  27799,     20.52351,   53.9969521,  -7.27272749
  27800,   21.4158363,   54.1707344,  -7.27272749
  27801,   22.3081627,   54.3445129,  -7.27272749
  27802,    23.200489,   54.5182953,  -7.27272749
  27803,   24.0928154,   54.6920738,  -7.27272749
  27804,   24.9851398,   54.8658562,  -7.27272749
  27805,   25.8774662,   55.0396347,  -7.27272749
  27806,   26.7697926,   55.2134171,  -7.27272749
  27807,   27.6621189,   55.3871994,  -7.27272749
  27808,   28.5544472,   55.5609779,  -7.27272749
  27809,     20.52351,   53.9969521,  -8.18181801
  27810,   21.4158363,   54.1707344,  -8.18181801
  27811,   22.3081627,   54.3445129,  -8.18181801
  27812,    23.200489,   54.5182953,  -8.18181801
  27813,   24.0928154,   54.6920738,  -8.18181801
  27814,   24.9851398,   54.8658562,  -8.18181801
  27815,   25.8774662,   55.0396347,  -8.18181801
  27816,   26.7697926,   55.2134171,  -8.18181801
  27817,   27.6621189,   55.3871994,  -8.18181801
  27818,   28.5544472,   55.5609779,  -8.18181801
  27819,     20.52351,   53.9969521,    -9.090909
  27820,   21.4158363,   54.1707344,    -9.090909
  27821,   22.3081627,   54.3445129,    -9.090909
  27822,    23.200489,   54.5182953,    -9.090909
  27823,   24.0928154,   54.6920738,    -9.090909
  27824,   24.9851398,   54.8658562,    -9.090909
  27825,   25.8774662,   55.0396347,    -9.090909
  27826,   26.7697926,   55.2134171,    -9.090909
  27827,   27.6621189,   55.3871994,    -9.090909
  27828,   28.5544472,   55.5609779,    -9.090909
  27829,   20.3848572,     54.65271, -0.909090936
  27830,   21.2711544,   54.8550034, -0.909090936
  27831,   22.1574516,   55.0572929, -0.909090936
  27832,   23.0437508,   55.2595863, -0.909090936
  27833,    23.930048,   55.4618759, -0.909090936
  27834,   24.8163471,   55.6641693, -0.909090936
  27835,   25.7026443,   55.8664627, -0.909090936
  27836,   26.5889435,   56.0687523, -0.909090936
  27837,   27.4752407,   56.2710457, -0.909090936
  27838,   28.3615398,   56.4733353, -0.909090936
  27839,   20.3848572,     54.65271,  -1.81818187
  27840,   21.2711544,   54.8550034,  -1.81818187
  27841,   22.1574516,   55.0572929,  -1.81818187
  27842,   23.0437508,   55.2595863,  -1.81818187
  27843,    23.930048,   55.4618759,  -1.81818187
  27844,   24.8163471,   55.6641693,  -1.81818187
  27845,   25.7026443,   55.8664627,  -1.81818187
  27846,   26.5889435,   56.0687523,  -1.81818187
  27847,   27.4752407,   56.2710457,  -1.81818187
  27848,   28.3615398,   56.4733353,  -1.81818187
  27849,   20.3848572,     54.65271,  -2.72727275
  27850,   21.2711544,   54.8550034,  -2.72727275
  27851,   22.1574516,   55.0572929,  -2.72727275
  27852,   23.0437508,   55.2595863,  -2.72727275
  27853,    23.930048,   55.4618759,  -2.72727275
  27854,   24.8163471,   55.6641693,  -2.72727275
  27855,   25.7026443,   55.8664627,  -2.72727275
  27856,   26.5889435,   56.0687523,  -2.72727275
  27857,   27.4752407,   56.2710457,  -2.72727275
  27858,   28.3615398,   56.4733353,  -2.72727275
  27859,   20.3848572,     54.65271,  -3.63636374
  27860,   21.2711544,   54.8550034,  -3.63636374
  27861,   22.1574516,   55.0572929,  -3.63636374
  27862,   23.0437508,   55.2595863,  -3.63636374
  27863,    23.930048,   55.4618759,  -3.63636374
  27864,   24.8163471,   55.6641693,  -3.63636374
  27865,   25.7026443,   55.8664627,  -3.63636374
  27866,   26.5889435,   56.0687523,  -3.63636374
  27867,   27.4752407,   56.2710457,  -3.63636374
  27868,   28.3615398,   56.4733353,  -3.63636374
  27869,   20.3848572,     54.65271,   -4.5454545
  27870,   21.2711544,   54.8550034,   -4.5454545
  27871,   22.1574516,   55.0572929,   -4.5454545
  27872,   23.0437508,   55.2595863,   -4.5454545
  27873,    23.930048,   55.4618759,   -4.5454545
  27874,   24.8163471,   55.6641693,   -4.5454545
  27875,   25.7026443,   55.8664627,   -4.5454545
  27876,   26.5889435,   56.0687523,   -4.5454545
  27877,   27.4752407,   56.2710457,   -4.5454545
  27878,   28.3615398,   56.4733353,   -4.5454545
  27879,   20.3848572,     54.65271,   -5.4545455
  27880,   21.2711544,   54.8550034,   -5.4545455
  27881,   22.1574516,   55.0572929,   -5.4545455
  27882,   23.0437508,   55.2595863,   -5.4545455
  27883,    23.930048,   55.4618759,   -5.4545455
  27884,   24.8163471,   55.6641693,   -5.4545455
  27885,   25.7026443,   55.8664627,   -5.4545455
  27886,   26.5889435,   56.0687523,   -5.4545455
  27887,   27.4752407,   56.2710457,   -5.4545455
  27888,   28.3615398,   56.4733353,   -5.4545455
  27889,   20.3848572,     54.65271,  -6.36363649
  27890,   21.2711544,   54.8550034,  -6.36363649
  27891,   22.1574516,   55.0572929,  -6.36363649
  27892,   23.0437508,   55.2595863,  -6.36363649
  27893,    23.930048,   55.4618759,  -6.36363649
  27894,   24.8163471,   55.6641693,  -6.36363649
  27895,   25.7026443,   55.8664627,  -6.36363649
  27896,   26.5889435,   56.0687523,  -6.36363649
  27897,   27.4752407,   56.2710457,  -6.36363649
  27898,   28.3615398,   56.4733353,  -6.36363649
  27899,   20.3848572,     54.65271,  -7.27272749
  27900,   21.2711544,   54.8550034,  -7.27272749
  27901,   22.1574516,   55.0572929,  -7.27272749
  27902,   23.0437508,   55.2595863,  -7.27272749
  27903,    23.930048,   55.4618759,  -7.27272749
  27904,   24.8163471,   55.6641693,  -7.27272749
  27905,   25.7026443,   55.8664627,  -7.27272749
  27906,   26.5889435,   56.0687523,  -7.27272749
  27907,   27.4752407,   56.2710457,  -7.27272749
  27908,   28.3615398,   56.4733353,  -7.27272749
  27909,   20.3848572,     54.65271,  -8.18181801
  27910,   21.2711544,   54.8550034,  -8.18181801
  27911,   22.1574516,   55.0572929,  -8.18181801
  27912,   23.0437508,   55.2595863,  -8.18181801
  27913,    23.930048,   55.4618759,  -8.18181801
  27914,   24.8163471,   55.6641693,  -8.18181801
  27915,   25.7026443,   55.8664627,  -8.18181801
  27916,   26.5889435,   56.0687523,  -8.18181801
  27917,   27.4752407,   56.2710457,  -8.18181801
  27918,   28.3615398,   56.4733353,  -8.18181801
  27919,   20.3848572,     54.65271,    -9.090909
  27920,   21.2711544,   54.8550034,    -9.090909
  27921,   22.1574516,   55.0572929,    -9.090909
  27922,   23.0437508,   55.2595863,    -9.090909
  27923,    23.930048,   55.4618759,    -9.090909
  27924,   24.8163471,   55.6641693,    -9.090909
  27925,   25.7026443,   55.8664627,    -9.090909
  27926,   26.5889435,   56.0687523,    -9.090909
  27927,   27.4752407,   56.2710457,    -9.090909
  27928,   28.3615398,   56.4733353,    -9.090909
  27929,    20.225256,    55.303688, -0.909090936
  27930,   21.1046143,   55.5342827, -0.909090936
  27931,   21.9839745,   55.7648773, -0.909090936
  27932,   22.8633327,    55.995472, -0.909090936
  27933,   23.7426929,   56.2260666, -0.909090936
  27934,   24.6220512,   56.4566612, -0.909090936
  27935,   25.5014095,   56.6872559, -0.909090936
  27936,   26.3807697,   56.9178505, -0.909090936
  27937,    27.260128,   57.1484489, -0.909090936
  27938,   28.1394863,   57.3790436, -0.909090936
  27939,    20.225256,    55.303688,  -1.81818187
  27940,   21.1046143,   55.5342827,  -1.81818187
  27941,   21.9839745,   55.7648773,  -1.81818187
  27942,   22.8633327,    55.995472,  -1.81818187
  27943,   23.7426929,   56.2260666,  -1.81818187
  27944,   24.6220512,   56.4566612,  -1.81818187
  27945,   25.5014095,   56.6872559,  -1.81818187
  27946,   26.3807697,   56.9178505,  -1.81818187
  27947,    27.260128,   57.1484489,  -1.81818187
  27948,   28.1394863,   57.3790436,  -1.81818187
  27949,    20.225256,    55.303688,  -2.72727275
  27950,   21.1046143,   55.5342827,  -2.72727275
  27951,   21.9839745,   55.7648773,  -2.72727275
  27952,   22.8633327,    55.995472,  -2.72727275
  27953,   23.7426929,   56.2260666,  -2.72727275
  27954,   24.6220512,   56.4566612,  -2.72727275
  27955,   25.5014095,   56.6872559,  -2.72727275
  27956,   26.3807697,   56.9178505,  -2.72727275
  27957,    27.260128,   57.1484489,  -2.72727275
  27958,   28.1394863,   57.3790436,  -2.72727275
  27959,    20.225256,    55.303688,  -3.63636374
  27960,   21.1046143,   55.5342827,  -3.63636374
  27961,   21.9839745,   55.7648773,  -3.63636374
  27962,   22.8633327,    55.995472,  -3.63636374
  27963,   23.7426929,   56.2260666,  -3.63636374
  27964,   24.6220512,   56.4566612,  -3.63636374
  27965,   25.5014095,   56.6872559,  -3.63636374
  27966,   26.3807697,   56.9178505,  -3.63636374
  27967,    27.260128,   57.1484489,  -3.63636374
  27968,   28.1394863,   57.3790436,  -3.63636374
  27969,    20.225256,    55.303688,   -4.5454545
  27970,   21.1046143,   55.5342827,   -4.5454545
  27971,   21.9839745,   55.7648773,   -4.5454545
  27972,   22.8633327,    55.995472,   -4.5454545
  27973,   23.7426929,   56.2260666,   -4.5454545
  27974,   24.6220512,   56.4566612,   -4.5454545
  27975,   25.5014095,   56.6872559,   -4.5454545
  27976,   26.3807697,   56.9178505,   -4.5454545
  27977,    27.260128,   57.1484489,   -4.5454545
  27978,   28.1394863,   57.3790436,   -4.5454545
  27979,    20.225256,    55.303688,   -5.4545455
  27980,   21.1046143,   55.5342827,   -5.4545455
  27981,   21.9839745,   55.7648773,   -5.4545455
  27982,   22.8633327,    55.995472,   -5.4545455
  27983,   23.7426929,   56.2260666,   -5.4545455
  27984,   24.6220512,   56.4566612,   -5.4545455
  27985,   25.5014095,   56.6872559,   -5.4545455
  27986,   26.3807697,   56.9178505,   -5.4545455
  27987,    27.260128,   57.1484489,   -5.4545455
  27988,   28.1394863,   57.3790436,   -5.4545455
  27989,    20.225256,    55.303688,  -6.36363649
  27990,   21.1046143,   55.5342827,  -6.36363649
  27991,   21.9839745,   55.7648773,  -6.36363649
  27992,   22.8633327,    55.995472,  -6.36363649
  27993,   23.7426929,   56.2260666,  -6.36363649
  27994,   24.6220512,   56.4566612,  -6.36363649
