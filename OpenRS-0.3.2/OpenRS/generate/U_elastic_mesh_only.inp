   3995,   -22.727272,          50.,    -9.090909
   3996,   -23.636364,          50.,    -9.090909
   3997,   -24.545454,          50.,    -9.090909
   3998,   -25.454546,          50.,    -9.090909
   3999,   -26.363636,          50.,    -9.090909
   4000,   -27.272728,          50.,    -9.090909
   4001,   -28.181818,          50.,    -9.090909
   4002,    -29.09091,          50.,    -9.090909
   4003,    -20.90909,          50.,  -8.18181801
   4004,   -21.818182,          50.,  -8.18181801
   4005,   -22.727272,          50.,  -8.18181801
   4006,   -23.636364,          50.,  -8.18181801
   4007,   -24.545454,          50.,  -8.18181801
   4008,   -25.454546,          50.,  -8.18181801
   4009,   -26.363636,          50.,  -8.18181801
   4010,   -27.272728,          50.,  -8.18181801
   4011,   -28.181818,          50.,  -8.18181801
   4012,    -29.09091,          50.,  -8.18181801
   4013,    -20.90909,          50.,  -7.27272749
   4014,   -21.818182,          50.,  -7.27272749
   4015,   -22.727272,          50.,  -7.27272749
   4016,   -23.636364,          50.,  -7.27272749
   4017,   -24.545454,          50.,  -7.27272749
   4018,   -25.454546,          50.,  -7.27272749
   4019,   -26.363636,          50.,  -7.27272749
   4020,   -27.272728,          50.,  -7.27272749
   4021,   -28.181818,          50.,  -7.27272749
   4022,    -29.09091,          50.,  -7.27272749
   4023,    -20.90909,          50.,  -6.36363649
   4024,   -21.818182,          50.,  -6.36363649
   4025,   -22.727272,          50.,  -6.36363649
   4026,   -23.636364,          50.,  -6.36363649
   4027,   -24.545454,          50.,  -6.36363649
   4028,   -25.454546,          50.,  -6.36363649
   4029,   -26.363636,          50.,  -6.36363649
   4030,   -27.272728,          50.,  -6.36363649
   4031,   -28.181818,          50.,  -6.36363649
   4032,    -29.09091,          50.,  -6.36363649
   4033,    -20.90909,          50.,   -5.4545455
   4034,   -21.818182,          50.,   -5.4545455
   4035,   -22.727272,          50.,   -5.4545455
   4036,   -23.636364,          50.,   -5.4545455
   4037,   -24.545454,          50.,   -5.4545455
   4038,   -25.454546,          50.,   -5.4545455
   4039,   -26.363636,          50.,   -5.4545455
   4040,   -27.272728,          50.,   -5.4545455
   4041,   -28.181818,          50.,   -5.4545455
   4042,    -29.09091,          50.,   -5.4545455
   4043,    -20.90909,          50.,   -4.5454545
   4044,   -21.818182,          50.,   -4.5454545
   4045,   -22.727272,          50.,   -4.5454545
   4046,   -23.636364,          50.,   -4.5454545
   4047,   -24.545454,          50.,   -4.5454545
   4048,   -25.454546,          50.,   -4.5454545
   4049,   -26.363636,          50.,   -4.5454545
   4050,   -27.272728,          50.,   -4.5454545
   4051,   -28.181818,          50.,   -4.5454545
   4052,    -29.09091,          50.,   -4.5454545
   4053,    -20.90909,          50.,  -3.63636374
   4054,   -21.818182,          50.,  -3.63636374
   4055,   -22.727272,          50.,  -3.63636374
   4056,   -23.636364,          50.,  -3.63636374
   4057,   -24.545454,          50.,  -3.63636374
   4058,   -25.454546,          50.,  -3.63636374
   4059,   -26.363636,          50.,  -3.63636374
   4060,   -27.272728,          50.,  -3.63636374
   4061,   -28.181818,          50.,  -3.63636374
   4062,    -29.09091,          50.,  -3.63636374
   4063,    -20.90909,          50.,  -2.72727275
   4064,   -21.818182,          50.,  -2.72727275
   4065,   -22.727272,          50.,  -2.72727275
   4066,   -23.636364,          50.,  -2.72727275
   4067,   -24.545454,          50.,  -2.72727275
   4068,   -25.454546,          50.,  -2.72727275
   4069,   -26.363636,          50.,  -2.72727275
   4070,   -27.272728,          50.,  -2.72727275
   4071,   -28.181818,          50.,  -2.72727275
   4072,    -29.09091,          50.,  -2.72727275
   4073,    -20.90909,          50.,  -1.81818187
   4074,   -21.818182,          50.,  -1.81818187
   4075,   -22.727272,          50.,  -1.81818187
   4076,   -23.636364,          50.,  -1.81818187
   4077,   -24.545454,          50.,  -1.81818187
   4078,   -25.454546,          50.,  -1.81818187
   4079,   -26.363636,          50.,  -1.81818187
   4080,   -27.272728,          50.,  -1.81818187
   4081,   -28.181818,          50.,  -1.81818187
   4082,    -29.09091,          50.,  -1.81818187
   4083,    -20.90909,          50., -0.909090936
   4084,   -21.818182,          50., -0.909090936
   4085,   -22.727272,          50., -0.909090936
   4086,   -23.636364,          50., -0.909090936
   4087,   -24.545454,          50., -0.909090936
   4088,   -25.454546,          50., -0.909090936
   4089,   -26.363636,          50., -0.909090936
   4090,   -27.272728,          50., -0.909090936
   4091,   -28.181818,          50., -0.909090936
   4092,    -29.09091,          50., -0.909090936
   4093,         -20.,   20.7826385,    -9.090909
   4094,         -20.,   20.7758026,  -8.18181801
   4095,         -20.,   20.7689686,  -7.27272749
   4096,         -20.,   20.7621326,  -6.36363649
   4097,         -20.,   20.7552967,   -5.4545455
   4098,         -20.,   20.7484627,   -4.5454545
   4099,         -20.,   20.7416267,  -3.63636374
   4100,         -20.,   20.7347908,  -2.72727275
   4101,         -20.,   20.7279568,  -1.81818187
   4102,         -20.,   20.7211208, -0.909090936
   4103,         -20.,   21.5652771,    -9.090909
   4104,         -20.,   21.5516071,  -8.18181801
   4105,         -20.,   21.5379353,  -7.27272749
   4106,         -20.,   21.5242653,  -6.36363649
   4107,         -20.,   21.5105953,   -5.4545455
   4108,         -20.,   21.4969234,   -4.5454545
   4109,         -20.,   21.4832535,  -3.63636374
   4110,         -20.,   21.4695835,  -2.72727275
   4111,         -20.,   21.4559116,  -1.81818187
   4112,         -20.,   21.4422417, -0.909090936
   4113,         -20.,   22.3479156,    -9.090909
   4114,         -20.,   22.3274097,  -8.18181801
   4115,         -20.,   22.3069038,  -7.27272749
   4116,         -20.,   22.2863979,  -6.36363649
   4117,         -20.,    22.265892,   -5.4545455
   4118,         -20.,   22.2453861,   -4.5454545
   4119,         -20.,   22.2248802,  -3.63636374
   4120,         -20.,   22.2043743,  -2.72727275
   4121,         -20.,   22.1838684,  -1.81818187
   4122,         -20.,   22.1633625, -0.909090936
   4123,         -20.,   23.1305542,    -9.090909
   4124,         -20.,   23.1032124,  -8.18181801
   4125,         -20.,   23.0758724,  -7.27272749
   4126,         -20.,   23.0485306,  -6.36363649
   4127,         -20.,   23.0211887,   -5.4545455
   4128,         -20.,   22.9938488,   -4.5454545
   4129,         -20.,    22.966507,  -3.63636374
   4130,         -20.,    22.939167,  -2.72727275
   4131,         -20.,   22.9118252,  -1.81818187
   4132,         -20.,   22.8844833, -0.909090936
   4133,         -20.,   23.9131927,    -9.090909
   4134,         -20.,    23.879015,  -8.18181801
   4135,         -20.,   23.8448391,  -7.27272749
   4136,         -20.,   23.8106632,  -6.36363649
   4137,         -20.,   23.7764874,   -5.4545455
   4138,         -20.,   23.7423096,   -4.5454545
   4139,         -20.,   23.7081337,  -3.63636374
   4140,         -20.,   23.6739578,  -2.72727275
   4141,         -20.,    23.639782,  -1.81818187
   4142,         -20.,   23.6056042, -0.909090936
   4143,         -20.,   24.6958313,    -9.090909
   4144,         -20.,   24.6548195,  -8.18181801
   4145,         -20.,   24.6138077,  -7.27272749
   4146,         -20.,   24.5727959,  -6.36363649
   4147,         -20.,   24.5317841,   -5.4545455
   4148,         -20.,   24.4907722,   -4.5454545
   4149,         -20.,   24.4497604,  -3.63636374
   4150,         -20.,   24.4087486,  -2.72727275
   4151,         -20.,   24.3677368,  -1.81818187
   4152,         -20.,    24.326725, -0.909090936
   4153,         -20.,   25.4784698,    -9.090909
   4154,         -20.,   25.4306221,  -8.18181801
   4155,         -20.,   25.3827744,  -7.27272749
   4156,         -20.,   25.3349285,  -6.36363649
   4157,         -20.,   25.2870808,   -5.4545455
   4158,         -20.,   25.2392349,   -4.5454545
   4159,         -20.,   25.1913872,  -3.63636374
   4160,         -20.,   25.1435413,  -2.72727275
   4161,         -20.,   25.0956936,  -1.81818187
   4162,         -20.,   25.0478477, -0.909090936
   4163,         -20.,   26.2688999,    -9.090909
   4164,         -20.,   26.2220097,  -8.18181801
   4165,         -20.,   26.1751194,  -7.27272749
   4166,         -20.,   26.1282291,  -6.36363649
   4167,         -20.,   26.0813389,   -5.4545455
   4168,         -20.,   26.0344505,   -4.5454545
   4169,         -20.,   25.9875603,  -3.63636374
   4170,         -20.,     25.94067,  -2.72727275
   4171,         -20.,   25.8937798,  -1.81818187
   4172,         -20.,   25.8468895, -0.909090936
   4173,         -20.,     27.05933,    -9.090909
   4174,         -20.,   27.0133972,  -8.18181801
   4175,         -20.,   26.9674644,  -7.27272749
   4176,         -20.,   26.9215317,  -6.36363649
   4177,         -20.,   26.8755989,   -5.4545455
   4178,         -20.,   26.8296642,   -4.5454545
   4179,         -20.,   26.7837315,  -3.63636374
   4180,         -20.,   26.7377987,  -2.72727275
   4181,         -20.,   26.6918659,  -1.81818187
   4182,         -20.,   26.6459332, -0.909090936
   4183,         -20.,   27.8497601,    -9.090909
   4184,         -20.,   27.8047848,  -8.18181801
   4185,         -20.,   27.7598095,  -7.27272749
   4186,         -20.,   27.7148323,  -6.36363649
   4187,         -20.,    27.669857,   -5.4545455
   4188,         -20.,   27.6248798,   -4.5454545
   4189,         -20.,   27.5799046,  -3.63636374
   4190,         -20.,   27.5349274,  -2.72727275
   4191,         -20.,   27.4899521,  -1.81818187
   4192,         -20.,   27.4449768, -0.909090936
   4193,         -20.,    28.640192,    -9.090909
   4194,         -20.,   28.5961723,  -8.18181801
   4195,         -20.,   28.5521526,  -7.27272749
   4196,         -20.,   28.5081348,  -6.36363649
   4197,         -20.,   28.4641151,   -5.4545455
   4198,         -20.,   28.4200954,   -4.5454545
   4199,         -20.,   28.3760757,  -3.63636374
   4200,         -20.,    28.332058,  -2.72727275
   4201,         -20.,   28.2880383,  -1.81818187
   4202,         -20.,   28.2440186, -0.909090936
   4203,         -20.,   29.4306221,    -9.090909
   4204,         -20.,   29.3875599,  -8.18181801
   4205,         -20.,   29.3444977,  -7.27272749
   4206,         -20.,   29.3014355,  -6.36363649
   4207,         -20.,   29.2583733,   -5.4545455
   4208,         -20.,   29.2153111,   -4.5454545
   4209,         -20.,   29.1722488,  -3.63636374
   4210,         -20.,   29.1291866,  -2.72727275
   4211,         -20.,   29.0861244,  -1.81818187
   4212,         -20.,   29.0430622, -0.909090936
   4213,         -20.,   30.2210522,    -9.090909
   4214,         -20.,   30.1789474,  -8.18181801
   4215,         -20.,   30.1368427,  -7.27272749
   4216,         -20.,   30.0947361,  -6.36363649
   4217,         -20.,   30.0526314,   -5.4545455
   4218,         -20.,   30.0105267,   -4.5454545
   4219,         -20.,   29.9684219,  -3.63636374
   4220,         -20.,   29.9263153,  -2.72727275
   4221,         -20.,   29.8842106,  -1.81818187
   4222,         -20.,   29.8421059, -0.909090936
   4223,         -20.,   31.0114841,    -9.090909
   4224,         -20.,    30.970335,  -8.18181801
   4225,         -20.,   30.9291859,  -7.27272749
   4226,         -20.,   30.8880386,  -6.36363649
   4227,         -20.,   30.8468895,   -5.4545455
   4228,         -20.,   30.8057423,   -4.5454545
   4229,         -20.,   30.7645931,  -3.63636374
   4230,         -20.,   30.7234459,  -2.72727275
   4231,         -20.,   30.6822968,  -1.81818187
   4232,         -20.,   30.6411476, -0.909090936
   4233,         -20.,   31.8019142,    -9.090909
   4234,         -20.,   31.7617226,  -8.18181801
   4235,         -20.,   31.7215309,  -7.27272749
   4236,         -20.,   31.6813393,  -6.36363649
   4237,         -20.,   31.6411476,   -5.4545455
   4238,         -20.,   31.6009579,   -4.5454545
   4239,         -20.,   31.5607662,  -3.63636374
   4240,         -20.,   31.5205746,  -2.72727275
   4241,         -20.,   31.4803829,  -1.81818187
   4242,         -20.,   31.4401913, -0.909090936
   4243,         -20.,   32.5923462,    -9.090909
   4244,         -20.,   32.5531082,  -8.18181801
   4245,         -20.,   32.5138741,  -7.27272749
   4246,         -20.,   32.4746399,  -6.36363649
   4247,         -20.,   32.4354057,   -5.4545455
   4248,         -20.,   32.3961716,   -4.5454545
   4249,         -20.,   32.3569374,  -3.63636374
   4250,         -20.,   32.3177032,  -2.72727275
   4251,         -20.,   32.2784691,  -1.81818187
   4252,         -20.,   32.2392349, -0.909090936
   4253,         -20.,   33.3827744,    -9.090909
   4254,         -20.,   33.3444977,  -8.18181801
   4255,         -20.,    33.306221,  -7.27272749
   4256,         -20.,   33.2679443,  -6.36363649
   4257,         -20.,   33.2296638,   -5.4545455
   4258,         -20.,   33.1913872,   -4.5454545
   4259,         -20.,   33.1531105,  -3.63636374
   4260,         -20.,   33.1148338,  -2.72727275
   4261,         -20.,   33.0765533,  -1.81818187
   4262,         -20.,   33.0382767, -0.909090936
   4263,         -20.,   34.1732063,    -9.090909
   4264,         -20.,   34.1358833,  -8.18181801
   4265,         -20.,   34.0985641,  -7.27272749
   4266,         -20.,    34.061245,  -6.36363649
   4267,         -20.,    34.023922,   -5.4545455
   4268,         -20.,   33.9866028,   -4.5454545
   4269,         -20.,   33.9492836,  -3.63636374
   4270,         -20.,   33.9119606,  -2.72727275
   4271,         -20.,   33.8746414,  -1.81818187
   4272,         -20.,   33.8373222, -0.909090936
   4273,         -20.,   34.9636345,    -9.090909
   4274,         -20.,   34.9272728,  -8.18181801
   4275,         -20.,   34.8909073,  -7.27272749
   4276,         -20.,   34.8545456,  -6.36363649
   4277,         -20.,   34.8181801,   -5.4545455
   4278,         -20.,   34.7818184,   -4.5454545
   4279,         -20.,   34.7454529,  -3.63636374
   4280,         -20.,   34.7090912,  -2.72727275
   4281,         -20.,   34.6727257,  -1.81818187
   4282,         -20.,    34.636364, -0.909090936
   4283,         -20.,   35.7540665,    -9.090909
   4284,         -20.,   35.7186584,  -8.18181801
   4285,         -20.,   35.6832542,  -7.27272749
   4286,         -20.,   35.6478462,  -6.36363649
   4287,         -20.,    35.612442,   -5.4545455
   4288,         -20.,    35.577034,   -4.5454545
   4289,         -20.,    35.541626,  -3.63636374
   4290,         -20.,   35.5062218,  -2.72727275
   4291,         -20.,   35.4708138,  -1.81818187
   4292,         -20.,   35.4354057, -0.909090936
   4293,         -20.,   36.5444984,    -9.090909
   4294,         -20.,   36.5100479,  -8.18181801
   4295,         -20.,   36.4755974,  -7.27272749
   4296,         -20.,   36.4411469,  -6.36363649
   4297,         -20.,   36.4067001,   -5.4545455
   4298,         -20.,   36.3722496,   -4.5454545
   4299,         -20.,   36.3377991,  -3.63636374
   4300,         -20.,   36.3033485,  -2.72727275
   4301,         -20.,    36.268898,  -1.81818187
   4302,         -20.,   36.2344513, -0.909090936
   4303,         -20.,   37.3349266,    -9.090909
   4304,         -20.,   37.3014336,  -8.18181801
   4305,         -20.,   37.2679443,  -7.27272749
   4306,         -20.,   37.2344513,  -6.36363649
   4307,         -20.,   37.2009583,   -5.4545455
   4308,         -20.,   37.1674652,   -4.5454545
   4309,         -20.,   37.1339722,  -3.63636374
   4310,         -20.,   37.1004791,  -2.72727275
   4311,         -20.,   37.0669861,  -1.81818187
   4312,         -20.,    37.033493, -0.909090936
   4313,         -20.,   38.1253586,    -9.090909
   4314,         -20.,    38.092823,  -8.18181801
   4315,         -20.,   38.0602875,  -7.27272749
   4316,         -20.,   38.0277519,  -6.36363649
   4317,         -20.,   37.9952164,   -5.4545455
   4318,         -20.,   37.9626808,   -4.5454545
   4319,         -20.,   37.9301453,  -3.63636374
   4320,         -20.,   37.8976059,  -2.72727275
   4321,         -20.,   37.8650703,  -1.81818187
   4322,         -20.,   37.8325348, -0.909090936
   4323,         -20.,   38.9157906,    -9.090909
   4324,         -20.,   38.8842087,  -8.18181801
   4325,         -20.,   38.8526306,  -7.27272749
   4326,         -20.,   38.8210526,  -6.36363649
   4327,         -20.,   38.7894745,   -5.4545455
   4328,         -20.,   38.7578964,   -4.5454545
   4329,         -20.,   38.7263145,  -3.63636374
   4330,         -20.,   38.6947365,  -2.72727275
   4331,         -20.,   38.6631584,  -1.81818187
   4332,         -20.,   38.6315804, -0.909090936
   4333,         -20.,   39.7062187,    -9.090909
   4334,         -20.,   39.6755981,  -8.18181801
   4335,         -20.,   39.6449776,  -7.27272749
   4336,         -20.,   39.6143532,  -6.36363649
   4337,         -20.,   39.5837326,   -5.4545455
   4338,         -20.,   39.5531082,   -4.5454545
   4339,         -20.,   39.5224876,  -3.63636374
   4340,         -20.,   39.4918671,  -2.72727275
   4341,         -20.,   39.4612427,  -1.81818187
   4342,         -20.,   39.4306221, -0.909090936
   4343,         -20.,   40.4966507,    -9.090909
   4344,         -20.,   40.4669838,  -8.18181801
   4345,         -20.,   40.4373207,  -7.27272749
   4346,         -20.,   40.4076538,  -6.36363649
   4347,         -20.,   40.3779907,   -5.4545455
   4348,         -20.,   40.3483238,   -4.5454545
   4349,         -20.,   40.3186607,  -3.63636374
   4350,         -20.,   40.2889938,  -2.72727275
   4351,         -20.,   40.2593307,  -1.81818187
   4352,         -20.,   40.2296638, -0.909090936
   4353,         -20.,   41.2870827,    -9.090909
   4354,         -20.,   41.2583733,  -8.18181801
   4355,         -20.,   41.2296638,  -7.27272749
   4356,         -20.,   41.2009583,  -6.36363649
   4357,         -20.,   41.1722488,   -5.4545455
   4358,         -20.,   41.1435394,   -4.5454545
   4359,         -20.,   41.1148338,  -3.63636374
   4360,         -20.,   41.0861244,  -2.72727275
   4361,         -20.,    41.057415,  -1.81818187
   4362,         -20.,   41.0287094, -0.909090936
   4363,         -20.,   42.0775108,    -9.090909
   4364,         -20.,   42.0497589,  -8.18181801
   4365,         -20.,   42.0220108,  -7.27272749
   4366,         -20.,   41.9942589,  -6.36363649
   4367,         -20.,    41.966507,   -5.4545455
   4368,         -20.,    41.938755,   -4.5454545
   4369,         -20.,   41.9110031,  -3.63636374
   4370,         -20.,    41.883255,  -2.72727275
   4371,         -20.,   41.8555031,  -1.81818187
   4372,         -20.,   41.8277512, -0.909090936
   4373,         -20.,   42.8679428,    -9.090909
   4374,         -20.,   42.8411484,  -8.18181801
   4375,         -20.,   42.8143539,  -7.27272749
   4376,         -20.,   42.7875595,  -6.36363649
   4377,         -20.,   42.7607651,   -5.4545455
   4378,         -20.,   42.7339706,   -4.5454545
   4379,         -20.,   42.7071762,  -3.63636374
   4380,         -20.,   42.6803818,  -2.72727275
   4381,         -20.,   42.6535873,  -1.81818187
   4382,         -20.,   42.6267929, -0.909090936
   4383,         -20.,   43.6583748,    -9.090909
   4384,         -20.,    43.632534,  -8.18181801
   4385,         -20.,   43.6066971,  -7.27272749
   4386,         -20.,   43.5808601,  -6.36363649
   4387,         -20.,   43.5550232,   -5.4545455
   4388,         -20.,   43.5291862,   -4.5454545
   4389,         -20.,   43.5033493,  -3.63636374
   4390,         -20.,   43.4775124,  -2.72727275
   4391,         -20.,   43.4516754,  -1.81818187
   4392,         -20.,   43.4258385, -0.909090936
   4393,         -20.,   44.4488029,    -9.090909
   4394,         -20.,   44.4239235,  -8.18181801
   4395,         -20.,    44.399044,  -7.27272749
   4396,         -20.,   44.3741646,  -6.36363649
   4397,         -20.,   44.3492813,   -5.4545455
   4398,         -20.,   44.3244019,   -4.5454545
   4399,         -20.,   44.2995224,  -3.63636374
   4400,         -20.,   44.2746429,  -2.72727275
   4401,         -20.,   44.2497597,  -1.81818187
   4402,         -20.,   44.2248802, -0.909090936
   4403,         -20.,   45.2392349,    -9.090909
   4404,         -20.,   45.2153091,  -8.18181801
   4405,         -20.,   45.1913872,  -7.27272749
   4406,         -20.,   45.1674652,  -6.36363649
   4407,         -20.,   45.1435394,   -5.4545455
   4408,         -20.,   45.1196175,   -4.5454545
   4409,         -20.,   45.0956955,  -3.63636374
   4410,         -20.,   45.0717697,  -2.72727275
   4411,         -20.,   45.0478477,  -1.81818187
   4412,         -20.,    45.023922, -0.909090936
   4413,         -20.,   46.0326958,    -9.090909
   4414,         -20.,   46.0127602,  -8.18181801
   4415,         -20.,   45.9928246,  -7.27272749
   4416,         -20.,   45.9728851,  -6.36363649
   4417,         -20.,   45.9529495,   -5.4545455
   4418,         -20.,   45.9330139,   -4.5454545
   4419,         -20.,   45.9130783,  -3.63636374
   4420,         -20.,   45.8931427,  -2.72727275
   4421,         -20.,   45.8732071,  -1.81818187
   4422,         -20.,   45.8532677, -0.909090936
   4423,         -20.,   46.8261566,    -9.090909
   4424,         -20.,   46.8102074,  -8.18181801
   4425,         -20.,   46.7942581,  -7.27272749
   4426,         -20.,   46.7783089,  -6.36363649
   4427,         -20.,   46.7623596,   -5.4545455
   4428,         -20.,   46.7464104,   -4.5454545
   4429,         -20.,   46.7304611,  -3.63636374
   4430,         -20.,   46.7145119,  -2.72727275
   4431,         -20.,   46.6985664,  -1.81818187
   4432,         -20.,   46.6826172, -0.909090936
   4433,         -20.,   47.6196175,    -9.090909
   4434,         -20.,   47.6076546,  -8.18181801
   4435,         -20.,   47.5956955,  -7.27272749
   4436,         -20.,   47.5837326,  -6.36363649
   4437,         -20.,   47.5717697,   -5.4545455
   4438,         -20.,   47.5598068,   -4.5454545
   4439,         -20.,   47.5478477,  -3.63636374
   4440,         -20.,   47.5358849,  -2.72727275
   4441,         -20.,    47.523922,  -1.81818187
   4442,         -20.,   47.5119629, -0.909090936
   4443,         -20.,   48.4130783,    -9.090909
   4444,         -20.,   48.4051018,  -8.18181801
   4445,         -20.,   48.3971291,  -7.27272749
   4446,         -20.,   48.3891563,  -6.36363649
   4447,         -20.,   48.3811798,   -5.4545455
   4448,         -20.,   48.3732071,   -4.5454545
   4449,         -20.,   48.3652306,  -3.63636374
   4450,         -20.,   48.3572578,  -2.72727275
   4451,         -20.,   48.3492813,  -1.81818187
   4452,         -20.,   48.3413086, -0.909090936
   4453,         -20.,   49.2065392,    -9.090909
   4454,         -20.,   49.2025528,  -8.18181801
   4455,         -20.,   49.1985664,  -7.27272749
   4456,         -20.,   49.1945763,  -6.36363649
   4457,         -20.,   49.1905899,   -5.4545455
   4458,         -20.,   49.1866035,   -4.5454545
   4459,         -20.,   49.1826172,  -3.63636374
   4460,         -20.,    49.178627,  -2.72727275
   4461,         -20.,   49.1746407,  -1.81818187
   4462,         -20.,   49.1706543, -0.909090936
   4463,         -30.,   20.7826385,    -9.090909
   4464,         -30.,   20.7758026,  -8.18181801
   4465,         -30.,   20.7689686,  -7.27272749
   4466,         -30.,   20.7621326,  -6.36363649
   4467,         -30.,   20.7552967,   -5.4545455
   4468,         -30.,   20.7484627,   -4.5454545
   4469,         -30.,   20.7416267,  -3.63636374
   4470,         -30.,   20.7347908,  -2.72727275
   4471,         -30.,   20.7279568,  -1.81818187
   4472,         -30.,   20.7211208, -0.909090936
   4473,         -30.,   21.5652771,    -9.090909
   4474,         -30.,   21.5516071,  -8.18181801
   4475,         -30.,   21.5379353,  -7.27272749
   4476,         -30.,   21.5242653,  -6.36363649
   4477,         -30.,   21.5105953,   -5.4545455
   4478,         -30.,   21.4969234,   -4.5454545
   4479,         -30.,   21.4832535,  -3.63636374
   4480,         -30.,   21.4695835,  -2.72727275
   4481,         -30.,   21.4559116,  -1.81818187
   4482,         -30.,   21.4422417, -0.909090936
   4483,         -30.,   22.3479156,    -9.090909
   4484,         -30.,   22.3274097,  -8.18181801
   4485,         -30.,   22.3069038,  -7.27272749
   4486,         -30.,   22.2863979,  -6.36363649
   4487,         -30.,    22.265892,   -5.4545455
   4488,         -30.,   22.2453861,   -4.5454545
   4489,         -30.,   22.2248802,  -3.63636374
   4490,         -30.,   22.2043743,  -2.72727275
   4491,         -30.,   22.1838684,  -1.81818187
   4492,         -30.,   22.1633625, -0.909090936
   4493,         -30.,   23.1305542,    -9.090909
   4494,         -30.,   23.1032124,  -8.18181801
   4495,         -30.,   23.0758724,  -7.27272749
   4496,         -30.,   23.0485306,  -6.36363649
   4497,         -30.,   23.0211887,   -5.4545455
   4498,         -30.,   22.9938488,   -4.5454545
   4499,         -30.,    22.966507,  -3.63636374
   4500,         -30.,    22.939167,  -2.72727275
   4501,         -30.,   22.9118252,  -1.81818187
   4502,         -30.,   22.8844833, -0.909090936
   4503,         -30.,   23.9131927,    -9.090909
   4504,         -30.,    23.879015,  -8.18181801
   4505,         -30.,   23.8448391,  -7.27272749
   4506,         -30.,   23.8106632,  -6.36363649
   4507,         -30.,   23.7764874,   -5.4545455
   4508,         -30.,   23.7423096,   -4.5454545
   4509,         -30.,   23.7081337,  -3.63636374
   4510,         -30.,   23.6739578,  -2.72727275
   4511,         -30.,    23.639782,  -1.81818187
   4512,         -30.,   23.6056042, -0.909090936
   4513,         -30.,   24.6958313,    -9.090909
   4514,         -30.,   24.6548195,  -8.18181801
   4515,         -30.,   24.6138077,  -7.27272749
   4516,         -30.,   24.5727959,  -6.36363649
   4517,         -30.,   24.5317841,   -5.4545455
   4518,         -30.,   24.4907722,   -4.5454545
   4519,         -30.,   24.4497604,  -3.63636374
   4520,         -30.,   24.4087486,  -2.72727275
   4521,         -30.,   24.3677368,  -1.81818187
   4522,         -30.,    24.326725, -0.909090936
   4523,         -30.,   25.4784698,    -9.090909
   4524,         -30.,   25.4306221,  -8.18181801
   4525,         -30.,   25.3827744,  -7.27272749
   4526,         -30.,   25.3349285,  -6.36363649
   4527,         -30.,   25.2870808,   -5.4545455
   4528,         -30.,   25.2392349,   -4.5454545
   4529,         -30.,   25.1913872,  -3.63636374
   4530,         -30.,   25.1435413,  -2.72727275
   4531,         -30.,   25.0956936,  -1.81818187
   4532,         -30.,   25.0478477, -0.909090936
   4533,         -30.,   26.2688999,    -9.090909
   4534,         -30.,   26.2220097,  -8.18181801
   4535,         -30.,   26.1751194,  -7.27272749
   4536,         -30.,   26.1282291,  -6.36363649
   4537,         -30.,   26.0813389,   -5.4545455
   4538,         -30.,   26.0344505,   -4.5454545
   4539,         -30.,   25.9875603,  -3.63636374
   4540,         -30.,     25.94067,  -2.72727275
   4541,         -30.,   25.8937798,  -1.81818187
   4542,         -30.,   25.8468895, -0.909090936
   4543,         -30.,     27.05933,    -9.090909
   4544,         -30.,   27.0133972,  -8.18181801
   4545,         -30.,   26.9674644,  -7.27272749
   4546,         -30.,   26.9215317,  -6.36363649
   4547,         -30.,   26.8755989,   -5.4545455
   4548,         -30.,   26.8296642,   -4.5454545
   4549,         -30.,   26.7837315,  -3.63636374
   4550,         -30.,   26.7377987,  -2.72727275
   4551,         -30.,   26.6918659,  -1.81818187
   4552,         -30.,   26.6459332, -0.909090936
   4553,         -30.,   27.8497601,    -9.090909
   4554,         -30.,   27.8047848,  -8.18181801
   4555,         -30.,   27.7598095,  -7.27272749
   4556,         -30.,   27.7148323,  -6.36363649
   4557,         -30.,    27.669857,   -5.4545455
   4558,         -30.,   27.6248798,   -4.5454545
   4559,         -30.,   27.5799046,  -3.63636374
   4560,         -30.,   27.5349274,  -2.72727275
   4561,         -30.,   27.4899521,  -1.81818187
   4562,         -30.,   27.4449768, -0.909090936
   4563,         -30.,    28.640192,    -9.090909
   4564,         -30.,   28.5961723,  -8.18181801
   4565,         -30.,   28.5521526,  -7.27272749
   4566,         -30.,   28.5081348,  -6.36363649
   4567,         -30.,   28.4641151,   -5.4545455
   4568,         -30.,   28.4200954,   -4.5454545
   4569,         -30.,   28.3760757,  -3.63636374
   4570,         -30.,    28.332058,  -2.72727275
   4571,         -30.,   28.2880383,  -1.81818187
   4572,         -30.,   28.2440186, -0.909090936
   4573,         -30.,   29.4306221,    -9.090909
   4574,         -30.,   29.3875599,  -8.18181801
   4575,         -30.,   29.3444977,  -7.27272749
   4576,         -30.,   29.3014355,  -6.36363649
   4577,         -30.,   29.2583733,   -5.4545455
   4578,         -30.,   29.2153111,   -4.5454545
   4579,         -30.,   29.1722488,  -3.63636374
   4580,         -30.,   29.1291866,  -2.72727275
   4581,         -30.,   29.0861244,  -1.81818187
   4582,         -30.,   29.0430622, -0.909090936
   4583,         -30.,   30.2210522,    -9.090909
   4584,         -30.,   30.1789474,  -8.18181801
   4585,         -30.,   30.1368427,  -7.27272749
   4586,         -30.,   30.0947361,  -6.36363649
   4587,         -30.,   30.0526314,   -5.4545455
   4588,         -30.,   30.0105267,   -4.5454545
   4589,         -30.,   29.9684219,  -3.63636374
   4590,         -30.,   29.9263153,  -2.72727275
   4591,         -30.,   29.8842106,  -1.81818187
   4592,         -30.,   29.8421059, -0.909090936
   4593,         -30.,   31.0114841,    -9.090909
   4594,         -30.,    30.970335,  -8.18181801
   4595,         -30.,   30.9291859,  -7.27272749
   4596,         -30.,   30.8880386,  -6.36363649
   4597,         -30.,   30.8468895,   -5.4545455
   4598,         -30.,   30.8057423,   -4.5454545
   4599,         -30.,   30.7645931,  -3.63636374
   4600,         -30.,   30.7234459,  -2.72727275
   4601,         -30.,   30.6822968,  -1.81818187
   4602,         -30.,   30.6411476, -0.909090936
   4603,         -30.,   31.8019142,    -9.090909
   4604,         -30.,   31.7617226,  -8.18181801
   4605,         -30.,   31.7215309,  -7.27272749
   4606,         -30.,   31.6813393,  -6.36363649
   4607,         -30.,   31.6411476,   -5.4545455
   4608,         -30.,   31.6009579,   -4.5454545
   4609,         -30.,   31.5607662,  -3.63636374
   4610,         -30.,   31.5205746,  -2.72727275
   4611,         -30.,   31.4803829,  -1.81818187
   4612,         -30.,   31.4401913, -0.909090936
   4613,         -30.,   32.5923462,    -9.090909
   4614,         -30.,   32.5531082,  -8.18181801
   4615,         -30.,   32.5138741,  -7.27272749
   4616,         -30.,   32.4746399,  -6.36363649
   4617,         -30.,   32.4354057,   -5.4545455
   4618,         -30.,   32.3961716,   -4.5454545
   4619,         -30.,   32.3569374,  -3.63636374
   4620,         -30.,   32.3177032,  -2.72727275
   4621,         -30.,   32.2784691,  -1.81818187
   4622,         -30.,   32.2392349, -0.909090936
   4623,         -30.,   33.3827744,    -9.090909
   4624,         -30.,   33.3444977,  -8.18181801
   4625,         -30.,    33.306221,  -7.27272749
   4626,         -30.,   33.2679443,  -6.36363649
   4627,         -30.,   33.2296638,   -5.4545455
   4628,         -30.,   33.1913872,   -4.5454545
   4629,         -30.,   33.1531105,  -3.63636374
   4630,         -30.,   33.1148338,  -2.72727275
   4631,         -30.,   33.0765533,  -1.81818187
   4632,         -30.,   33.0382767, -0.909090936
   4633,         -30.,   34.1732063,    -9.090909
   4634,         -30.,   34.1358833,  -8.18181801
   4635,         -30.,   34.0985641,  -7.27272749
   4636,         -30.,    34.061245,  -6.36363649
   4637,         -30.,    34.023922,   -5.4545455
   4638,         -30.,   33.9866028,   -4.5454545
   4639,         -30.,   33.9492836,  -3.63636374
   4640,         -30.,   33.9119606,  -2.72727275
   4641,         -30.,   33.8746414,  -1.81818187
   4642,         -30.,   33.8373222, -0.909090936
   4643,         -30.,   34.9636345,    -9.090909
   4644,         -30.,   34.9272728,  -8.18181801
   4645,         -30.,   34.8909073,  -7.27272749
   4646,         -30.,   34.8545456,  -6.36363649
   4647,         -30.,   34.8181801,   -5.4545455
   4648,         -30.,   34.7818184,   -4.5454545
   4649,         -30.,   34.7454529,  -3.63636374
   4650,         -30.,   34.7090912,  -2.72727275
   4651,         -30.,   34.6727257,  -1.81818187
   4652,         -30.,    34.636364, -0.909090936
   4653,         -30.,   35.7540665,    -9.090909
   4654,         -30.,   35.7186584,  -8.18181801
   4655,         -30.,   35.6832542,  -7.27272749
   4656,         -30.,   35.6478462,  -6.36363649
   4657,         -30.,    35.612442,   -5.4545455
   4658,         -30.,    35.577034,   -4.5454545
   4659,         -30.,    35.541626,  -3.63636374
   4660,         -30.,   35.5062218,  -2.72727275
   4661,         -30.,   35.4708138,  -1.81818187
   4662,         -30.,   35.4354057, -0.909090936
   4663,         -30.,   36.5444984,    -9.090909
   4664,         -30.,   36.5100479,  -8.18181801
   4665,         -30.,   36.4755974,  -7.27272749
   4666,         -30.,   36.4411469,  -6.36363649
   4667,         -30.,   36.4067001,   -5.4545455
   4668,         -30.,   36.3722496,   -4.5454545
   4669,         -30.,   36.3377991,  -3.63636374
   4670,         -30.,   36.3033485,  -2.72727275
   4671,         -30.,    36.268898,  -1.81818187
   4672,         -30.,   36.2344513, -0.909090936
   4673,         -30.,   37.3349266,    -9.090909
   4674,         -30.,   37.3014336,  -8.18181801
   4675,         -30.,   37.2679443,  -7.27272749
   4676,         -30.,   37.2344513,  -6.36363649
   4677,         -30.,   37.2009583,   -5.4545455
   4678,         -30.,   37.1674652,   -4.5454545
   4679,         -30.,   37.1339722,  -3.63636374
   4680,         -30.,   37.1004791,  -2.72727275
   4681,         -30.,   37.0669861,  -1.81818187
   4682,         -30.,    37.033493, -0.909090936
   4683,         -30.,   38.1253586,    -9.090909
   4684,         -30.,    38.092823,  -8.18181801
   4685,         -30.,   38.0602875,  -7.27272749
   4686,         -30.,   38.0277519,  -6.36363649
   4687,         -30.,   37.9952164,   -5.4545455
   4688,         -30.,   37.9626808,   -4.5454545
   4689,         -30.,   37.9301453,  -3.63636374
   4690,         -30.,   37.8976059,  -2.72727275
   4691,         -30.,   37.8650703,  -1.81818187
   4692,         -30.,   37.8325348, -0.909090936
   4693,         -30.,   38.9157906,    -9.090909
   4694,         -30.,   38.8842087,  -8.18181801
   4695,         -30.,   38.8526306,  -7.27272749
   4696,         -30.,   38.8210526,  -6.36363649
   4697,         -30.,   38.7894745,   -5.4545455
   4698,         -30.,   38.7578964,   -4.5454545
   4699,         -30.,   38.7263145,  -3.63636374
   4700,         -30.,   38.6947365,  -2.72727275
   4701,         -30.,   38.6631584,  -1.81818187
   4702,         -30.,   38.6315804, -0.909090936
   4703,         -30.,   39.7062187,    -9.090909
   4704,         -30.,   39.6755981,  -8.18181801
   4705,         -30.,   39.6449776,  -7.27272749
   4706,         -30.,   39.6143532,  -6.36363649
   4707,         -30.,   39.5837326,   -5.4545455
   4708,         -30.,   39.5531082,   -4.5454545
   4709,         -30.,   39.5224876,  -3.63636374
   4710,         -30.,   39.4918671,  -2.72727275
   4711,         -30.,   39.4612427,  -1.81818187
   4712,         -30.,   39.4306221, -0.909090936
   4713,         -30.,   40.4966507,    -9.090909
   4714,         -30.,   40.4669838,  -8.18181801
   4715,         -30.,   40.4373207,  -7.27272749
   4716,         -30.,   40.4076538,  -6.36363649
   4717,         -30.,   40.3779907,   -5.4545455
   4718,         -30.,   40.3483238,   -4.5454545
   4719,         -30.,   40.3186607,  -3.63636374
   4720,         -30.,   40.2889938,  -2.72727275
   4721,         -30.,   40.2593307,  -1.81818187
   4722,         -30.,   40.2296638, -0.909090936
   4723,         -30.,   41.2870827,    -9.090909
   4724,         -30.,   41.2583733,  -8.18181801
   4725,         -30.,   41.2296638,  -7.27272749
   4726,         -30.,   41.2009583,  -6.36363649
   4727,         -30.,   41.1722488,   -5.4545455
   4728,         -30.,   41.1435394,   -4.5454545
   4729,         -30.,   41.1148338,  -3.63636374
   4730,         -30.,   41.0861244,  -2.72727275
   4731,         -30.,    41.057415,  -1.81818187
   4732,         -30.,   41.0287094, -0.909090936
   4733,         -30.,   42.0775108,    -9.090909
   4734,         -30.,   42.0497589,  -8.18181801
   4735,         -30.,   42.0220108,  -7.27272749
   4736,         -30.,   41.9942589,  -6.36363649
   4737,         -30.,    41.966507,   -5.4545455
   4738,         -30.,    41.938755,   -4.5454545
   4739,         -30.,   41.9110031,  -3.63636374
   4740,         -30.,    41.883255,  -2.72727275
   4741,         -30.,   41.8555031,  -1.81818187
   4742,         -30.,   41.8277512, -0.909090936
   4743,         -30.,   42.8679428,    -9.090909
   4744,         -30.,   42.8411484,  -8.18181801
   4745,         -30.,   42.8143539,  -7.27272749
   4746,         -30.,   42.7875595,  -6.36363649
   4747,         -30.,   42.7607651,   -5.4545455
   4748,         -30.,   42.7339706,   -4.5454545
   4749,         -30.,   42.7071762,  -3.63636374
   4750,         -30.,   42.6803818,  -2.72727275
   4751,         -30.,   42.6535873,  -1.81818187
   4752,         -30.,   42.6267929, -0.909090936
   4753,         -30.,   43.6583748,    -9.090909
   4754,         -30.,    43.632534,  -8.18181801
   4755,         -30.,   43.6066971,  -7.27272749
   4756,         -30.,   43.5808601,  -6.36363649
   4757,         -30.,   43.5550232,   -5.4545455
   4758,         -30.,   43.5291862,   -4.5454545
   4759,         -30.,   43.5033493,  -3.63636374
   4760,         -30.,   43.4775124,  -2.72727275
   4761,         -30.,   43.4516754,  -1.81818187
   4762,         -30.,   43.4258385, -0.909090936
   4763,         -30.,   44.4488029,    -9.090909
   4764,         -30.,   44.4239235,  -8.18181801
   4765,         -30.,    44.399044,  -7.27272749
   4766,         -30.,   44.3741646,  -6.36363649
   4767,         -30.,   44.3492813,   -5.4545455
   4768,         -30.,   44.3244019,   -4.5454545
   4769,         -30.,   44.2995224,  -3.63636374
   4770,         -30.,   44.2746429,  -2.72727275
   4771,         -30.,   44.2497597,  -1.81818187
   4772,         -30.,   44.2248802, -0.909090936
   4773,         -30.,   45.2392349,    -9.090909
   4774,         -30.,   45.2153091,  -8.18181801
   4775,         -30.,   45.1913872,  -7.27272749
   4776,         -30.,   45.1674652,  -6.36363649
   4777,         -30.,   45.1435394,   -5.4545455
   4778,         -30.,   45.1196175,   -4.5454545
   4779,         -30.,   45.0956955,  -3.63636374
   4780,         -30.,   45.0717697,  -2.72727275
   4781,         -30.,   45.0478477,  -1.81818187
   4782,         -30.,    45.023922, -0.909090936
   4783,         -30.,   46.0326958,    -9.090909
   4784,         -30.,   46.0127602,  -8.18181801
   4785,         -30.,   45.9928246,  -7.27272749
   4786,         -30.,   45.9728851,  -6.36363649
   4787,         -30.,   45.9529495,   -5.4545455
   4788,         -30.,   45.9330139,   -4.5454545
   4789,         -30.,   45.9130783,  -3.63636374
   4790,         -30.,   45.8931427,  -2.72727275
   4791,         -30.,   45.8732071,  -1.81818187
   4792,         -30.,   45.8532677, -0.909090936
   4793,         -30.,   46.8261566,    -9.090909
   4794,         -30.,   46.8102074,  -8.18181801
   4795,         -30.,   46.7942581,  -7.27272749
   4796,         -30.,   46.7783089,  -6.36363649
   4797,         -30.,   46.7623596,   -5.4545455
   4798,         -30.,   46.7464104,   -4.5454545
   4799,         -30.,   46.7304611,  -3.63636374
   4800,         -30.,   46.7145119,  -2.72727275
   4801,         -30.,   46.6985664,  -1.81818187
   4802,         -30.,   46.6826172, -0.909090936
   4803,         -30.,   47.6196175,    -9.090909
   4804,         -30.,   47.6076546,  -8.18181801
   4805,         -30.,   47.5956955,  -7.27272749
   4806,         -30.,   47.5837326,  -6.36363649
   4807,         -30.,   47.5717697,   -5.4545455
   4808,         -30.,   47.5598068,   -4.5454545
   4809,         -30.,   47.5478477,  -3.63636374
   4810,         -30.,   47.5358849,  -2.72727275
   4811,         -30.,    47.523922,  -1.81818187
   4812,         -30.,   47.5119629, -0.909090936
   4813,         -30.,   48.4130783,    -9.090909
   4814,         -30.,   48.4051018,  -8.18181801
   4815,         -30.,   48.3971291,  -7.27272749
   4816,         -30.,   48.3891563,  -6.36363649
   4817,         -30.,   48.3811798,   -5.4545455
   4818,         -30.,   48.3732071,   -4.5454545
   4819,         -30.,   48.3652306,  -3.63636374
   4820,         -30.,   48.3572578,  -2.72727275
   4821,         -30.,   48.3492813,  -1.81818187
   4822,         -30.,   48.3413086, -0.909090936
   4823,         -30.,   49.2065392,    -9.090909
   4824,         -30.,   49.2025528,  -8.18181801
   4825,         -30.,   49.1985664,  -7.27272749
   4826,         -30.,   49.1945763,  -6.36363649
   4827,         -30.,   49.1905899,   -5.4545455
   4828,         -30.,   49.1866035,   -4.5454545
   4829,         -30.,   49.1826172,  -3.63636374
   4830,         -30.,    49.178627,  -2.72727275
   4831,         -30.,   49.1746407,  -1.81818187
   4832,         -30.,   49.1706543, -0.909090936
   4833,    -20.90909,   20.7894745,         -10.
   4834,   -21.818182,   20.7894745,         -10.
   4835,   -22.727272,   20.7894745,         -10.
   4836,   -23.636364,   20.7894745,         -10.
   4837,   -24.545454,   20.7894745,         -10.
   4838,   -25.454546,   20.7894745,         -10.
   4839,   -26.363636,   20.7894745,         -10.
   4840,   -27.272728,   20.7894745,         -10.
   4841,   -28.181818,   20.7894745,         -10.
   4842,    -29.09091,   20.7894745,         -10.
   4843,    -20.90909,   21.5789471,         -10.
   4844,   -21.818182,   21.5789471,         -10.
   4845,   -22.727272,   21.5789471,         -10.
   4846,   -23.636364,   21.5789471,         -10.
   4847,   -24.545454,   21.5789471,         -10.
   4848,   -25.454546,   21.5789471,         -10.
   4849,   -26.363636,   21.5789471,         -10.
   4850,   -27.272728,   21.5789471,         -10.
   4851,   -28.181818,   21.5789471,         -10.
   4852,    -29.09091,   21.5789471,         -10.
   4853,    -20.90909,   22.3684216,         -10.
   4854,   -21.818182,   22.3684216,         -10.
   4855,   -22.727272,   22.3684216,         -10.
   4856,   -23.636364,   22.3684216,         -10.
   4857,   -24.545454,   22.3684216,         -10.
   4858,   -25.454546,   22.3684216,         -10.
   4859,   -26.363636,   22.3684216,         -10.
   4860,   -27.272728,   22.3684216,         -10.
   4861,   -28.181818,   22.3684216,         -10.
   4862,    -29.09091,   22.3684216,         -10.
   4863,    -20.90909,   23.1578941,         -10.
   4864,   -21.818182,   23.1578941,         -10.
   4865,   -22.727272,   23.1578941,         -10.
   4866,   -23.636364,   23.1578941,         -10.
   4867,   -24.545454,   23.1578941,         -10.
   4868,   -25.454546,   23.1578941,         -10.
   4869,   -26.363636,   23.1578941,         -10.
   4870,   -27.272728,   23.1578941,         -10.
   4871,   -28.181818,   23.1578941,         -10.
   4872,    -29.09091,   23.1578941,         -10.
   4873,    -20.90909,   23.9473686,         -10.
   4874,   -21.818182,   23.9473686,         -10.
   4875,   -22.727272,   23.9473686,         -10.
   4876,   -23.636364,   23.9473686,         -10.
   4877,   -24.545454,   23.9473686,         -10.
   4878,   -25.454546,   23.9473686,         -10.
   4879,   -26.363636,   23.9473686,         -10.
   4880,   -27.272728,   23.9473686,         -10.
   4881,   -28.181818,   23.9473686,         -10.
   4882,    -29.09091,   23.9473686,         -10.
   4883,    -20.90909,   24.7368412,         -10.
   4884,   -21.818182,   24.7368412,         -10.
   4885,   -22.727272,   24.7368412,         -10.
   4886,   -23.636364,   24.7368412,         -10.
   4887,   -24.545454,   24.7368412,         -10.
   4888,   -25.454546,   24.7368412,         -10.
   4889,   -26.363636,   24.7368412,         -10.
   4890,   -27.272728,   24.7368412,         -10.
   4891,   -28.181818,   24.7368412,         -10.
   4892,    -29.09091,   24.7368412,         -10.
   4893,    -20.90909,   25.5263157,         -10.
   4894,   -21.818182,   25.5263157,         -10.
   4895,   -22.727272,   25.5263157,         -10.
   4896,   -23.636364,   25.5263157,         -10.
   4897,   -24.545454,   25.5263157,         -10.
   4898,   -25.454546,   25.5263157,         -10.
   4899,   -26.363636,   25.5263157,         -10.
   4900,   -27.272728,   25.5263157,         -10.
   4901,   -28.181818,   25.5263157,         -10.
   4902,    -29.09091,   25.5263157,         -10.
   4903,    -20.90909,   26.3157902,         -10.
   4904,   -21.818182,   26.3157902,         -10.
   4905,   -22.727272,   26.3157902,         -10.
   4906,   -23.636364,   26.3157902,         -10.
   4907,   -24.545454,   26.3157902,         -10.
   4908,   -25.454546,   26.3157902,         -10.
   4909,   -26.363636,   26.3157902,         -10.
   4910,   -27.272728,   26.3157902,         -10.
   4911,   -28.181818,   26.3157902,         -10.
   4912,    -29.09091,   26.3157902,         -10.
   4913,    -20.90909,   27.1052628,         -10.
   4914,   -21.818182,   27.1052628,         -10.
   4915,   -22.727272,   27.1052628,         -10.
   4916,   -23.636364,   27.1052628,         -10.
   4917,   -24.545454,   27.1052628,         -10.
   4918,   -25.454546,   27.1052628,         -10.
   4919,   -26.363636,   27.1052628,         -10.
   4920,   -27.272728,   27.1052628,         -10.
   4921,   -28.181818,   27.1052628,         -10.
   4922,    -29.09091,   27.1052628,         -10.
   4923,    -20.90909,   27.8947372,         -10.
   4924,   -21.818182,   27.8947372,         -10.
   4925,   -22.727272,   27.8947372,         -10.
   4926,   -23.636364,   27.8947372,         -10.
   4927,   -24.545454,   27.8947372,         -10.
   4928,   -25.454546,   27.8947372,         -10.
   4929,   -26.363636,   27.8947372,         -10.
   4930,   -27.272728,   27.8947372,         -10.
   4931,   -28.181818,   27.8947372,         -10.
   4932,    -29.09091,   27.8947372,         -10.
   4933,    -20.90909,   28.6842098,         -10.
   4934,   -21.818182,   28.6842098,         -10.
   4935,   -22.727272,   28.6842098,         -10.
   4936,   -23.636364,   28.6842098,         -10.
   4937,   -24.545454,   28.6842098,         -10.
   4938,   -25.454546,   28.6842098,         -10.
   4939,   -26.363636,   28.6842098,         -10.
   4940,   -27.272728,   28.6842098,         -10.
   4941,   -28.181818,   28.6842098,         -10.
   4942,    -29.09091,   28.6842098,         -10.
   4943,    -20.90909,   29.4736843,         -10.
   4944,   -21.818182,   29.4736843,         -10.
   4945,   -22.727272,   29.4736843,         -10.
   4946,   -23.636364,   29.4736843,         -10.
   4947,   -24.545454,   29.4736843,         -10.
   4948,   -25.454546,   29.4736843,         -10.
   4949,   -26.363636,   29.4736843,         -10.
   4950,   -27.272728,   29.4736843,         -10.
   4951,   -28.181818,   29.4736843,         -10.
   4952,    -29.09091,   29.4736843,         -10.
   4953,    -20.90909,   30.2631588,         -10.
   4954,   -21.818182,   30.2631588,         -10.
   4955,   -22.727272,   30.2631588,         -10.
   4956,   -23.636364,   30.2631588,         -10.
   4957,   -24.545454,   30.2631588,         -10.
   4958,   -25.454546,   30.2631588,         -10.
   4959,   -26.363636,   30.2631588,         -10.
   4960,   -27.272728,   30.2631588,         -10.
   4961,   -28.181818,   30.2631588,         -10.
   4962,    -29.09091,   30.2631588,         -10.
   4963,    -20.90909,   31.0526314,         -10.
   4964,   -21.818182,   31.0526314,         -10.
   4965,   -22.727272,   31.0526314,         -10.
   4966,   -23.636364,   31.0526314,         -10.
   4967,   -24.545454,   31.0526314,         -10.
   4968,   -25.454546,   31.0526314,         -10.
   4969,   -26.363636,   31.0526314,         -10.
   4970,   -27.272728,   31.0526314,         -10.
   4971,   -28.181818,   31.0526314,         -10.
   4972,    -29.09091,   31.0526314,         -10.
   4973,    -20.90909,   31.8421059,         -10.
   4974,   -21.818182,   31.8421059,         -10.
   4975,   -22.727272,   31.8421059,         -10.
   4976,   -23.636364,   31.8421059,         -10.
   4977,   -24.545454,   31.8421059,         -10.
   4978,   -25.454546,   31.8421059,         -10.
   4979,   -26.363636,   31.8421059,         -10.
   4980,   -27.272728,   31.8421059,         -10.
   4981,   -28.181818,   31.8421059,         -10.
   4982,    -29.09091,   31.8421059,         -10.
   4983,    -20.90909,   32.6315804,         -10.
   4984,   -21.818182,   32.6315804,         -10.
   4985,   -22.727272,   32.6315804,         -10.
   4986,   -23.636364,   32.6315804,         -10.
   4987,   -24.545454,   32.6315804,         -10.
   4988,   -25.454546,   32.6315804,         -10.
   4989,   -26.363636,   32.6315804,         -10.
   4990,   -27.272728,   32.6315804,         -10.
   4991,   -28.181818,   32.6315804,         -10.
   4992,    -29.09091,   32.6315804,         -10.
   4993,    -20.90909,    33.421051,         -10.
   4994,   -21.818182,    33.421051,         -10.
   4995,   -22.727272,    33.421051,         -10.
   4996,   -23.636364,    33.421051,         -10.
   4997,   -24.545454,    33.421051,         -10.
   4998,   -25.454546,    33.421051,         -10.
   4999,   -26.363636,    33.421051,         -10.
   5000,   -27.272728,    33.421051,         -10.
   5001,   -28.181818,    33.421051,         -10.
   5002,    -29.09091,    33.421051,         -10.
   5003,    -20.90909,   34.2105255,         -10.
   5004,   -21.818182,   34.2105255,         -10.
   5005,   -22.727272,   34.2105255,         -10.
   5006,   -23.636364,   34.2105255,         -10.
   5007,   -24.545454,   34.2105255,         -10.
   5008,   -25.454546,   34.2105255,         -10.
   5009,   -26.363636,   34.2105255,         -10.
   5010,   -27.272728,   34.2105255,         -10.
   5011,   -28.181818,   34.2105255,         -10.
   5012,    -29.09091,   34.2105255,         -10.
   5013,    -20.90909,          35.,         -10.
   5014,   -21.818182,          35.,         -10.
   5015,   -22.727272,          35.,         -10.
   5016,   -23.636364,          35.,         -10.
   5017,   -24.545454,          35.,         -10.
   5018,   -25.454546,          35.,         -10.
   5019,   -26.363636,          35.,         -10.
   5020,   -27.272728,          35.,         -10.
   5021,   -28.181818,          35.,         -10.
   5022,    -29.09091,          35.,         -10.
   5023,    -20.90909,   35.7894745,         -10.
   5024,   -21.818182,   35.7894745,         -10.
   5025,   -22.727272,   35.7894745,         -10.
   5026,   -23.636364,   35.7894745,         -10.
   5027,   -24.545454,   35.7894745,         -10.
   5028,   -25.454546,   35.7894745,         -10.
   5029,   -26.363636,   35.7894745,         -10.
   5030,   -27.272728,   35.7894745,         -10.
   5031,   -28.181818,   35.7894745,         -10.
   5032,    -29.09091,   35.7894745,         -10.
   5033,    -20.90909,    36.578949,         -10.
   5034,   -21.818182,    36.578949,         -10.
   5035,   -22.727272,    36.578949,         -10.
   5036,   -23.636364,    36.578949,         -10.
   5037,   -24.545454,    36.578949,         -10.
   5038,   -25.454546,    36.578949,         -10.
   5039,   -26.363636,    36.578949,         -10.
   5040,   -27.272728,    36.578949,         -10.
   5041,   -28.181818,    36.578949,         -10.
   5042,    -29.09091,    36.578949,         -10.
   5043,    -20.90909,   37.3684196,         -10.
   5044,   -21.818182,   37.3684196,         -10.
   5045,   -22.727272,   37.3684196,         -10.
   5046,   -23.636364,   37.3684196,         -10.
   5047,   -24.545454,   37.3684196,         -10.
   5048,   -25.454546,   37.3684196,         -10.
   5049,   -26.363636,   37.3684196,         -10.
   5050,   -27.272728,   37.3684196,         -10.
   5051,   -28.181818,   37.3684196,         -10.
   5052,    -29.09091,   37.3684196,         -10.
   5053,    -20.90909,   38.1578941,         -10.
   5054,   -21.818182,   38.1578941,         -10.
   5055,   -22.727272,   38.1578941,         -10.
   5056,   -23.636364,   38.1578941,         -10.
   5057,   -24.545454,   38.1578941,         -10.
   5058,   -25.454546,   38.1578941,         -10.
   5059,   -26.363636,   38.1578941,         -10.
   5060,   -27.272728,   38.1578941,         -10.
   5061,   -28.181818,   38.1578941,         -10.
   5062,    -29.09091,   38.1578941,         -10.
   5063,    -20.90909,   38.9473686,         -10.
   5064,   -21.818182,   38.9473686,         -10.
   5065,   -22.727272,   38.9473686,         -10.
   5066,   -23.636364,   38.9473686,         -10.
   5067,   -24.545454,   38.9473686,         -10.
   5068,   -25.454546,   38.9473686,         -10.
   5069,   -26.363636,   38.9473686,         -10.
   5070,   -27.272728,   38.9473686,         -10.
   5071,   -28.181818,   38.9473686,         -10.
   5072,    -29.09091,   38.9473686,         -10.
   5073,    -20.90909,   39.7368431,         -10.
   5074,   -21.818182,   39.7368431,         -10.
   5075,   -22.727272,   39.7368431,         -10.
   5076,   -23.636364,   39.7368431,         -10.
   5077,   -24.545454,   39.7368431,         -10.
   5078,   -25.454546,   39.7368431,         -10.
   5079,   -26.363636,   39.7368431,         -10.
   5080,   -27.272728,   39.7368431,         -10.
   5081,   -28.181818,   39.7368431,         -10.
   5082,    -29.09091,   39.7368431,         -10.
   5083,    -20.90909,   40.5263176,         -10.
   5084,   -21.818182,   40.5263176,         -10.
   5085,   -22.727272,   40.5263176,         -10.
   5086,   -23.636364,   40.5263176,         -10.
   5087,   -24.545454,   40.5263176,         -10.
   5088,   -25.454546,   40.5263176,         -10.
   5089,   -26.363636,   40.5263176,         -10.
   5090,   -27.272728,   40.5263176,         -10.
   5091,   -28.181818,   40.5263176,         -10.
   5092,    -29.09091,   40.5263176,         -10.
   5093,    -20.90909,   41.3157883,         -10.
   5094,   -21.818182,   41.3157883,         -10.
   5095,   -22.727272,   41.3157883,         -10.
   5096,   -23.636364,   41.3157883,         -10.
   5097,   -24.545454,   41.3157883,         -10.
   5098,   -25.454546,   41.3157883,         -10.
   5099,   -26.363636,   41.3157883,         -10.
   5100,   -27.272728,   41.3157883,         -10.
   5101,   -28.181818,   41.3157883,         -10.
   5102,    -29.09091,   41.3157883,         -10.
   5103,    -20.90909,   42.1052628,         -10.
   5104,   -21.818182,   42.1052628,         -10.
   5105,   -22.727272,   42.1052628,         -10.
   5106,   -23.636364,   42.1052628,         -10.
   5107,   -24.545454,   42.1052628,         -10.
   5108,   -25.454546,   42.1052628,         -10.
   5109,   -26.363636,   42.1052628,         -10.
   5110,   -27.272728,   42.1052628,         -10.
   5111,   -28.181818,   42.1052628,         -10.
   5112,    -29.09091,   42.1052628,         -10.
   5113,    -20.90909,   42.8947372,         -10.
   5114,   -21.818182,   42.8947372,         -10.
   5115,   -22.727272,   42.8947372,         -10.
   5116,   -23.636364,   42.8947372,         -10.
   5117,   -24.545454,   42.8947372,         -10.
   5118,   -25.454546,   42.8947372,         -10.
   5119,   -26.363636,   42.8947372,         -10.
   5120,   -27.272728,   42.8947372,         -10.
   5121,   -28.181818,   42.8947372,         -10.
   5122,    -29.09091,   42.8947372,         -10.
   5123,    -20.90909,   43.6842117,         -10.
   5124,   -21.818182,   43.6842117,         -10.
   5125,   -22.727272,   43.6842117,         -10.
   5126,   -23.636364,   43.6842117,         -10.
   5127,   -24.545454,   43.6842117,         -10.
   5128,   -25.454546,   43.6842117,         -10.
   5129,   -26.363636,   43.6842117,         -10.
   5130,   -27.272728,   43.6842117,         -10.
   5131,   -28.181818,   43.6842117,         -10.
   5132,    -29.09091,   43.6842117,         -10.
   5133,    -20.90909,   44.4736824,         -10.
   5134,   -21.818182,   44.4736824,         -10.
   5135,   -22.727272,   44.4736824,         -10.
   5136,   -23.636364,   44.4736824,         -10.
   5137,   -24.545454,   44.4736824,         -10.
   5138,   -25.454546,   44.4736824,         -10.
   5139,   -26.363636,   44.4736824,         -10.
   5140,   -27.272728,   44.4736824,         -10.
   5141,   -28.181818,   44.4736824,         -10.
   5142,    -29.09091,   44.4736824,         -10.
   5143,    -20.90909,   45.2631569,         -10.
   5144,   -21.818182,   45.2631569,         -10.
   5145,   -22.727272,   45.2631569,         -10.
   5146,   -23.636364,   45.2631569,         -10.
   5147,   -24.545454,   45.2631569,         -10.
   5148,   -25.454546,   45.2631569,         -10.
   5149,   -26.363636,   45.2631569,         -10.
   5150,   -27.272728,   45.2631569,         -10.
   5151,   -28.181818,   45.2631569,         -10.
   5152,    -29.09091,   45.2631569,         -10.
   5153,    -20.90909,   46.0526314,         -10.
   5154,   -21.818182,   46.0526314,         -10.
   5155,   -22.727272,   46.0526314,         -10.
   5156,   -23.636364,   46.0526314,         -10.
   5157,   -24.545454,   46.0526314,         -10.
   5158,   -25.454546,   46.0526314,         -10.
   5159,   -26.363636,   46.0526314,         -10.
   5160,   -27.272728,   46.0526314,         -10.
   5161,   -28.181818,   46.0526314,         -10.
   5162,    -29.09091,   46.0526314,         -10.
   5163,    -20.90909,   46.8421059,         -10.
   5164,   -21.818182,   46.8421059,         -10.
   5165,   -22.727272,   46.8421059,         -10.
   5166,   -23.636364,   46.8421059,         -10.
   5167,   -24.545454,   46.8421059,         -10.
   5168,   -25.454546,   46.8421059,         -10.
   5169,   -26.363636,   46.8421059,         -10.
   5170,   -27.272728,   46.8421059,         -10.
   5171,   -28.181818,   46.8421059,         -10.
   5172,    -29.09091,   46.8421059,         -10.
   5173,    -20.90909,   47.6315804,         -10.
   5174,   -21.818182,   47.6315804,         -10.
   5175,   -22.727272,   47.6315804,         -10.
   5176,   -23.636364,   47.6315804,         -10.
   5177,   -24.545454,   47.6315804,         -10.
   5178,   -25.454546,   47.6315804,         -10.
   5179,   -26.363636,   47.6315804,         -10.
   5180,   -27.272728,   47.6315804,         -10.
   5181,   -28.181818,   47.6315804,         -10.
   5182,    -29.09091,   47.6315804,         -10.
   5183,    -20.90909,    48.421051,         -10.
   5184,   -21.818182,    48.421051,         -10.
   5185,   -22.727272,    48.421051,         -10.
   5186,   -23.636364,    48.421051,         -10.
   5187,   -24.545454,    48.421051,         -10.
   5188,   -25.454546,    48.421051,         -10.
   5189,   -26.363636,    48.421051,         -10.
   5190,   -27.272728,    48.421051,         -10.
   5191,   -28.181818,    48.421051,         -10.
   5192,    -29.09091,    48.421051,         -10.
   5193,    -20.90909,   49.2105255,         -10.
   5194,   -21.818182,   49.2105255,         -10.
   5195,   -22.727272,   49.2105255,         -10.
   5196,   -23.636364,   49.2105255,         -10.
   5197,   -24.545454,   49.2105255,         -10.
   5198,   -25.454546,   49.2105255,         -10.
   5199,   -26.363636,   49.2105255,         -10.
   5200,   -27.272728,   49.2105255,         -10.
   5201,   -28.181818,   49.2105255,         -10.
   5202,    -29.09091,   49.2105255,         -10.
   5203,  -20.9016705,   20.7142849,           0.
   5204,   -21.803339,   20.7142849,           0.
   5205,  -22.7050095,   20.7142849,           0.
   5206,  -23.6066799,   20.7142849,           0.
   5207,  -24.5083485,   20.7142849,           0.
   5208,  -25.4100189,   20.7142849,           0.
   5209,  -26.3116875,   20.7142849,           0.
   5210,  -27.2337666,   20.7142849,           0.
   5211,  -28.1558437,   20.7142849,           0.
   5212,  -29.0779228,   20.7142849,           0.
   5213,   -20.894249,   21.4285717,           0.
   5214,  -21.7884979,   21.4285717,           0.
   5215,   -22.682745,   21.4285717,           0.
   5216,  -23.5769939,   21.4285717,           0.
   5217,  -24.4712429,   21.4285717,           0.
   5218,  -25.3654919,   21.4285717,           0.
   5219,  -26.2597408,   21.4285717,           0.
   5220,  -27.1948051,   21.4285717,           0.
   5221,  -28.1298695,   21.4285717,           0.
   5222,  -29.0649357,   21.4285717,           0.
   5223,  -20.8868275,   22.1428566,           0.
   5224,  -21.7736549,   22.1428566,           0.
   5225,  -22.6604824,   22.1428566,           0.
   5226,  -23.5473099,   22.1428566,           0.
   5227,  -24.4341373,   22.1428566,           0.
   5228,  -25.3209648,   22.1428566,           0.
   5229,  -26.2077923,   22.1428566,           0.
   5230,  -27.1558437,   22.1428566,           0.
   5231,  -28.1038952,   22.1428566,           0.
   5232,  -29.0519485,   22.1428566,           0.
   5233,   -20.879406,   22.8571434,           0.
   5234,   -21.758812,   22.8571434,           0.
   5235,  -22.6382198,   22.8571434,           0.
   5236,  -23.5176258,   22.8571434,           0.
   5237,  -24.3970318,   22.8571434,           0.
   5238,  -25.2764378,   22.8571434,           0.
   5239,  -26.1558437,   22.8571434,           0.
   5240,  -27.1168823,   22.8571434,           0.
   5241,  -28.0779228,   22.8571434,           0.
   5242,  -29.0389614,   22.8571434,           0.
   5243,  -20.8719845,   23.5714283,           0.
   5244,  -21.7439709,   23.5714283,           0.
   5245,  -22.6159554,   23.5714283,           0.
   5246,  -23.4879398,   23.5714283,           0.
   5247,  -24.3599262,   23.5714283,           0.
   5248,  -25.2319107,   23.5714283,           0.
   5249,  -26.1038952,   23.5714283,           0.
   5250,  -27.0779228,   23.5714283,           0.
   5251,  -28.0519485,   23.5714283,           0.
   5252,  -29.0259743,   23.5714283,           0.
   5253,  -20.8645649,   24.2857151,           0.
   5254,  -21.7291279,   24.2857151,           0.
   5255,  -22.5936928,   24.2857151,           0.
   5256,  -23.4582558,   24.2857151,           0.
   5257,  -24.3228207,   24.2857151,           0.
   5258,  -25.1873837,   24.2857151,           0.
   5259,  -26.0519485,   24.2857151,           0.
   5260,  -27.0389614,   24.2857151,           0.
   5261,  -28.0259743,   24.2857151,           0.
   5262,  -29.0129871,   24.2857151,           0.
   5263,  -25.1428566,   44.2000008,           0.
   5264,  -25.1428566,   43.4000015,           0.
   5265,  -25.1428566,   42.5999985,           0.
   5266,  -25.1428566,   41.7999992,           0.
   5267,  -25.1428566,          41.,           0.
   5268,  -25.1428566,   40.2000008,           0.
   5269,  -25.1428566,   39.4000015,           0.
   5270,  -25.1428566,   38.5999985,           0.
   5271,  -25.1428566,   37.7999992,           0.
   5272,  -25.1428566,          37.,           0.
   5273,  -25.1428566,   36.2000008,           0.
   5274,  -25.1428566,   35.4000015,           0.
   5275,  -25.1428566,   34.5999985,           0.
   5276,  -25.1428566,   33.7999992,           0.
   5277,  -25.1428566,          33.,           0.
   5278,  -25.1428566,   32.2000008,           0.
   5279,  -25.1428566,   31.3999996,           0.
   5280,  -25.1428566,   30.6000004,           0.
   5281,  -25.1428566,   29.7999992,           0.
   5282,  -25.1428566,          29.,           0.
   5283,  -25.1428566,   28.2000008,           0.
   5284,  -25.1428566,   27.3999996,           0.
   5285,  -25.1428566,   26.6000004,           0.
   5286,  -25.1428566,   25.7999992,           0.
   5287,  -24.2857151,   44.2000008,           0.
   5288,  -24.2857151,   43.4000015,           0.
   5289,  -24.2857151,   42.5999985,           0.
   5290,  -24.2857151,   41.7999992,           0.
   5291,  -24.2857151,          41.,           0.
   5292,  -24.2857151,   40.2000008,           0.
   5293,  -24.2857151,   39.4000015,           0.
   5294,  -24.2857151,   38.5999985,           0.
   5295,  -24.2857151,   37.7999992,           0.
   5296,  -24.2857151,          37.,           0.
   5297,  -24.2857151,   36.2000008,           0.
   5298,  -24.2857151,   35.4000015,           0.
   5299,  -24.2857151,   34.5999985,           0.
   5300,  -24.2857151,   33.7999992,           0.
   5301,  -24.2857151,          33.,           0.
   5302,  -24.2857151,   32.2000008,           0.
   5303,  -24.2857151,   31.3999996,           0.
   5304,  -24.2857151,   30.6000004,           0.
   5305,  -24.2857151,   29.7999992,           0.
   5306,  -24.2857151,          29.,           0.
   5307,  -24.2857151,   28.2000008,           0.
   5308,  -24.2857151,   27.3999996,           0.
   5309,  -24.2857151,   26.6000004,           0.
   5310,  -24.2857151,   25.7999992,           0.
   5311,  -23.4285717,   44.2000008,           0.
   5312,  -23.4285717,   43.4000015,           0.
   5313,  -23.4285717,   42.5999985,           0.
   5314,  -23.4285717,   41.7999992,           0.
   5315,  -23.4285717,          41.,           0.
   5316,  -23.4285717,   40.2000008,           0.
   5317,  -23.4285717,   39.4000015,           0.
   5318,  -23.4285717,   38.5999985,           0.
   5319,  -23.4285717,   37.7999992,           0.
   5320,  -23.4285717,          37.,           0.
   5321,  -23.4285717,   36.2000008,           0.
   5322,  -23.4285717,   35.4000015,           0.
   5323,  -23.4285717,   34.5999985,           0.
   5324,  -23.4285717,   33.7999992,           0.
   5325,  -23.4285717,          33.,           0.
   5326,  -23.4285717,   32.2000008,           0.
   5327,  -23.4285717,   31.3999996,           0.
   5328,  -23.4285717,   30.6000004,           0.
   5329,  -23.4285717,   29.7999992,           0.
   5330,  -23.4285717,          29.,           0.
   5331,  -23.4285717,   28.2000008,           0.
   5332,  -23.4285717,   27.3999996,           0.
   5333,  -23.4285717,   26.6000004,           0.
   5334,  -23.4285717,   25.7999992,           0.
   5335,  -22.5714283,   44.2000008,           0.
   5336,  -22.5714283,   43.4000015,           0.
   5337,  -22.5714283,   42.5999985,           0.
   5338,  -22.5714283,   41.7999992,           0.
   5339,  -22.5714283,          41.,           0.
   5340,  -22.5714283,   40.2000008,           0.
   5341,  -22.5714283,   39.4000015,           0.
   5342,  -22.5714283,   38.5999985,           0.
   5343,  -22.5714283,   37.7999992,           0.
   5344,  -22.5714283,          37.,           0.
   5345,  -22.5714283,   36.2000008,           0.
   5346,  -22.5714283,   35.4000015,           0.
   5347,  -22.5714283,   34.5999985,           0.
   5348,  -22.5714283,   33.7999992,           0.
   5349,  -22.5714283,          33.,           0.
   5350,  -22.5714283,   32.2000008,           0.
   5351,  -22.5714283,   31.3999996,           0.
   5352,  -22.5714283,   30.6000004,           0.
   5353,  -22.5714283,   29.7999992,           0.
   5354,  -22.5714283,          29.,           0.
   5355,  -22.5714283,   28.2000008,           0.
   5356,  -22.5714283,   27.3999996,           0.
   5357,  -22.5714283,   26.6000004,           0.
   5358,  -22.5714283,   25.7999992,           0.
   5359,  -21.7142849,   44.2000008,           0.
   5360,  -21.7142849,   43.4000015,           0.
   5361,  -21.7142849,   42.5999985,           0.
   5362,  -21.7142849,   41.7999992,           0.
   5363,  -21.7142849,          41.,           0.
   5364,  -21.7142849,   40.2000008,           0.
   5365,  -21.7142849,   39.4000015,           0.
   5366,  -21.7142849,   38.5999985,           0.
   5367,  -21.7142849,   37.7999992,           0.
   5368,  -21.7142849,          37.,           0.
   5369,  -21.7142849,   36.2000008,           0.
   5370,  -21.7142849,   35.4000015,           0.
   5371,  -21.7142849,   34.5999985,           0.
   5372,  -21.7142849,   33.7999992,           0.
   5373,  -21.7142849,          33.,           0.
   5374,  -21.7142849,   32.2000008,           0.
   5375,  -21.7142849,   31.3999996,           0.
   5376,  -21.7142849,   30.6000004,           0.
   5377,  -21.7142849,   29.7999992,           0.
   5378,  -21.7142849,          29.,           0.
   5379,  -21.7142849,   28.2000008,           0.
   5380,  -21.7142849,   27.3999996,           0.
   5381,  -21.7142849,   26.6000004,           0.
   5382,  -21.7142849,   25.7999992,           0.
   5383,  -20.8571434,   44.2000008,           0.
   5384,  -20.8571434,   43.4000015,           0.
   5385,  -20.8571434,   42.5999985,           0.
   5386,  -20.8571434,   41.7999992,           0.
   5387,  -20.8571434,          41.,           0.
   5388,  -20.8571434,   40.2000008,           0.
   5389,  -20.8571434,   39.4000015,           0.
   5390,  -20.8571434,   38.5999985,           0.
   5391,  -20.8571434,   37.7999992,           0.
   5392,  -20.8571434,          37.,           0.
   5393,  -20.8571434,   36.2000008,           0.
   5394,  -20.8571434,   35.4000015,           0.
   5395,  -20.8571434,   34.5999985,           0.
   5396,  -20.8571434,   33.7999992,           0.
   5397,  -20.8571434,          33.,           0.
   5398,  -20.8571434,   32.2000008,           0.
   5399,  -20.8571434,   31.3999996,           0.
   5400,  -20.8571434,   30.6000004,           0.
   5401,  -20.8571434,   29.7999992,           0.
   5402,  -20.8571434,          29.,           0.
   5403,  -20.8571434,   28.2000008,           0.
   5404,  -20.8571434,   27.3999996,           0.
   5405,  -20.8571434,   26.6000004,           0.
   5406,  -20.8571434,   25.7999992,           0.
   5407,         -27.,   25.7999992,           0.
   5408,         -27.,   26.6000004,           0.
   5409,         -27.,   27.3999996,           0.
   5410,         -27.,   28.2000008,           0.
   5411,         -27.,          29.,           0.
   5412,         -27.,   29.7999992,           0.
   5413,         -27.,   30.6000004,           0.
   5414,         -27.,   31.3999996,           0.
   5415,         -27.,   32.2000008,           0.
   5416,         -27.,          33.,           0.
   5417,         -27.,   33.7999992,           0.
   5418,         -27.,   34.5999985,           0.
   5419,         -27.,   35.4000015,           0.
   5420,         -27.,   36.2000008,           0.
   5421,         -27.,          37.,           0.
   5422,         -27.,   37.7999992,           0.
   5423,         -27.,   38.5999985,           0.
   5424,         -27.,   39.4000015,           0.
   5425,         -27.,   40.2000008,           0.
   5426,         -27.,          41.,           0.
   5427,         -27.,   41.7999992,           0.
   5428,         -27.,   42.5999985,           0.
   5429,         -27.,   43.4000015,           0.
   5430,         -27.,   44.2000008,           0.
   5431,         -28.,   25.7999992,           0.
   5432,         -28.,   26.6000004,           0.
   5433,         -28.,   27.3999996,           0.
   5434,         -28.,   28.2000008,           0.
   5435,         -28.,          29.,           0.
   5436,         -28.,   29.7999992,           0.
   5437,         -28.,   30.6000004,           0.
   5438,         -28.,   31.3999996,           0.
   5439,         -28.,   32.2000008,           0.
   5440,         -28.,          33.,           0.
   5441,         -28.,   33.7999992,           0.
   5442,         -28.,   34.5999985,           0.
   5443,         -28.,   35.4000015,           0.
   5444,         -28.,   36.2000008,           0.
   5445,         -28.,          37.,           0.
   5446,         -28.,   37.7999992,           0.
   5447,         -28.,   38.5999985,           0.
   5448,         -28.,   39.4000015,           0.
   5449,         -28.,   40.2000008,           0.
   5450,         -28.,          41.,           0.
   5451,         -28.,   41.7999992,           0.
   5452,         -28.,   42.5999985,           0.
   5453,         -28.,   43.4000015,           0.
   5454,         -28.,   44.2000008,           0.
   5455,         -29.,   25.7999992,           0.
   5456,         -29.,   26.6000004,           0.
   5457,         -29.,   27.3999996,           0.
   5458,         -29.,   28.2000008,           0.
   5459,         -29.,          29.,           0.
   5460,         -29.,   29.7999992,           0.
   5461,         -29.,   30.6000004,           0.
   5462,         -29.,   31.3999996,           0.
   5463,         -29.,   32.2000008,           0.
   5464,         -29.,          33.,           0.
   5465,         -29.,   33.7999992,           0.
   5466,         -29.,   34.5999985,           0.
   5467,         -29.,   35.4000015,           0.
   5468,         -29.,   36.2000008,           0.
   5469,         -29.,          37.,           0.
   5470,         -29.,   37.7999992,           0.
   5471,         -29.,   38.5999985,           0.
   5472,         -29.,   39.4000015,           0.
   5473,         -29.,   40.2000008,           0.
   5474,         -29.,          41.,           0.
   5475,         -29.,   41.7999992,           0.
   5476,         -29.,   42.5999985,           0.
   5477,         -29.,   43.4000015,           0.
   5478,         -29.,   44.2000008,           0.
   5479,   -29.015152,   45.8333321,           0.
   5480,   -28.030304,   45.8333321,           0.
   5481,   -27.045454,   45.8333321,           0.
   5482,   -26.060606,   45.8333321,           0.
   5483,  -25.1948051,   45.8333321,           0.
   5484,  -24.3290043,   45.8333321,           0.
   5485,  -23.4632034,   45.8333321,           0.
   5486,  -22.5974026,   45.8333321,           0.
   5487,  -21.7316017,   45.8333321,           0.
   5488,  -20.8658009,   45.8333321,           0.
   5489,   -29.030304,   46.6666679,           0.
   5490,   -28.060606,   46.6666679,           0.
   5491,    -27.09091,   46.6666679,           0.
   5492,   -26.121212,   46.6666679,           0.
   5493,  -25.2467537,   46.6666679,           0.
   5494,  -24.3722935,   46.6666679,           0.
   5495,  -23.4978352,   46.6666679,           0.
   5496,  -22.6233768,   46.6666679,           0.
   5497,  -21.7489185,   46.6666679,           0.
   5498,  -20.8744583,   46.6666679,           0.
   5499,   -29.045454,         47.5,           0.
   5500,    -28.09091,         47.5,           0.
   5501,   -27.136364,         47.5,           0.
   5502,   -26.181818,         47.5,           0.
   5503,  -25.2987022,         47.5,           0.
   5504,  -24.4155846,         47.5,           0.
   5505,  -23.5324669,         47.5,           0.
   5506,  -22.6493511,         47.5,           0.
   5507,  -21.7662334,         47.5,           0.
   5508,  -20.8831177,         47.5,           0.
   5509,   -29.060606,   48.3333321,           0.
   5510,   -28.121212,   48.3333321,           0.
   5511,   -27.181818,   48.3333321,           0.
   5512,   -26.242424,   48.3333321,           0.
   5513,  -25.3506489,   48.3333321,           0.
   5514,  -24.4588737,   48.3333321,           0.
   5515,  -23.5670986,   48.3333321,           0.
   5516,  -22.6753254,   48.3333321,           0.
   5517,  -21.7835503,   48.3333321,           0.
   5518,  -20.8917751,   48.3333321,           0.
   5519,   -29.075758,   49.1666679,           0.
   5520,   -28.151516,   49.1666679,           0.
   5521,   -27.227272,   49.1666679,           0.
   5522,    -26.30303,   49.1666679,           0.
   5523,  -25.4025974,   49.1666679,           0.
   5524,  -24.5021648,   49.1666679,           0.
   5525,  -23.6017323,   49.1666679,           0.
   5526,  -22.7012978,   49.1666679,           0.
   5527,  -21.8008652,   49.1666679,           0.
   5528,  -20.9004326,   49.1666679,           0.
   5529,   19.9897251,   50.6410332, -0.909090936
   5530,   19.9897251,   50.6410332,  -1.81818187
   5531,   19.9897251,   50.6410332,  -2.72727275
   5532,   19.9897251,   50.6410332,  -3.63636374
   5533,   19.9897251,   50.6410332,   -4.5454545
   5534,   19.9897251,   50.6410332,   -5.4545455
   5535,   19.9897251,   50.6410332,  -6.36363649
   5536,   19.9897251,   50.6410332,  -7.27272749
   5537,   19.9897251,   50.6410332,  -8.18181801
   5538,   19.9897251,   50.6410332,    -9.090909
   5539,   19.9589081,   51.2814026, -0.909090936
   5540,   19.9589081,   51.2814026,  -1.81818187
   5541,   19.9589081,   51.2814026,  -2.72727275
   5542,   19.9589081,   51.2814026,  -3.63636374
   5543,   19.9589081,   51.2814026,   -4.5454545
   5544,   19.9589081,   51.2814026,   -5.4545455
   5545,   19.9589081,   51.2814026,  -6.36363649
   5546,   19.9589081,   51.2814026,  -7.27272749
   5547,   19.9589081,   51.2814026,  -8.18181801
   5548,   19.9589081,   51.2814026,    -9.090909
   5549,   19.9075832,   51.9204597, -0.909090936
   5550,   19.9075832,   51.9204597,  -1.81818187
   5551,   19.9075832,   51.9204597,  -2.72727275
   5552,   19.9075832,   51.9204597,  -3.63636374
   5553,   19.9075832,   51.9204597,   -4.5454545
   5554,   19.9075832,   51.9204597,   -5.4545455
   5555,   19.9075832,   51.9204597,  -6.36363649
   5556,   19.9075832,   51.9204597,  -7.27272749
   5557,   19.9075832,   51.9204597,  -8.18181801
   5558,   19.9075832,   51.9204597,    -9.090909
   5559,   19.8358002,   52.5575447, -0.909090936
   5560,   19.8358002,   52.5575447,  -1.81818187
   5561,   19.8358002,   52.5575447,  -2.72727275
   5562,   19.8358002,   52.5575447,  -3.63636374
   5563,   19.8358002,   52.5575447,   -4.5454545
   5564,   19.8358002,   52.5575447,   -5.4545455
   5565,   19.8358002,   52.5575447,  -6.36363649
   5566,   19.8358002,   52.5575447,  -7.27272749
   5567,   19.8358002,   52.5575447,  -8.18181801
   5568,   19.8358002,   52.5575447,    -9.090909
   5569,   19.7436352,   53.1919975, -0.909090936
   5570,   19.7436352,   53.1919975,  -1.81818187
   5571,   19.7436352,   53.1919975,  -2.72727275
   5572,   19.7436352,   53.1919975,  -3.63636374
   5573,   19.7436352,   53.1919975,   -4.5454545
   5574,   19.7436352,   53.1919975,   -5.4545455
   5575,   19.7436352,   53.1919975,  -6.36363649
   5576,   19.7436352,   53.1919975,  -7.27272749
   5577,   19.7436352,   53.1919975,  -8.18181801
   5578,   19.7436352,   53.1919975,    -9.090909
   5579,   19.6311836,   53.8231735, -0.909090936
   5580,   19.6311836,   53.8231735,  -1.81818187
   5581,   19.6311836,   53.8231735,  -2.72727275
   5582,   19.6311836,   53.8231735,  -3.63636374
   5583,   19.6311836,   53.8231735,   -4.5454545
   5584,   19.6311836,   53.8231735,   -5.4545455
   5585,   19.6311836,   53.8231735,  -6.36363649
   5586,   19.6311836,   53.8231735,  -7.27272749
   5587,   19.6311836,   53.8231735,  -8.18181801
   5588,   19.6311836,   53.8231735,    -9.090909
   5589,    19.498558,   54.4504204, -0.909090936
   5590,    19.498558,   54.4504204,  -1.81818187
   5591,    19.498558,   54.4504204,  -2.72727275
   5592,    19.498558,   54.4504204,  -3.63636374
   5593,    19.498558,   54.4504204,   -4.5454545
   5594,    19.498558,   54.4504204,   -5.4545455
   5595,    19.498558,   54.4504204,  -6.36363649
   5596,    19.498558,   54.4504204,  -7.27272749
   5597,    19.498558,   54.4504204,  -8.18181801
   5598,    19.498558,   54.4504204,    -9.090909
   5599,   19.3458977,   55.0730934, -0.909090936
   5600,   19.3458977,   55.0730934,  -1.81818187
   5601,   19.3458977,   55.0730934,  -2.72727275
   5602,   19.3458977,   55.0730934,  -3.63636374
   5603,   19.3458977,   55.0730934,   -4.5454545
   5604,   19.3458977,   55.0730934,   -5.4545455
   5605,   19.3458977,   55.0730934,  -6.36363649
   5606,   19.3458977,   55.0730934,  -7.27272749
   5607,   19.3458977,   55.0730934,  -8.18181801
   5608,   19.3458977,   55.0730934,    -9.090909
   5609,    19.173357,   55.6905518, -0.909090936
   5610,    19.173357,   55.6905518,  -1.81818187
   5611,    19.173357,   55.6905518,  -2.72727275
   5612,    19.173357,   55.6905518,  -3.63636374
   5613,    19.173357,   55.6905518,   -4.5454545
   5614,    19.173357,   55.6905518,   -5.4545455
   5615,    19.173357,   55.6905518,  -6.36363649
   5616,    19.173357,   55.6905518,  -7.27272749
   5617,    19.173357,   55.6905518,  -8.18181801
   5618,    19.173357,   55.6905518,    -9.090909
   5619,   18.9811153,    56.302166, -0.909090936
   5620,   18.9811153,    56.302166,  -1.81818187
   5621,   18.9811153,    56.302166,  -2.72727275
   5622,   18.9811153,    56.302166,  -3.63636374
   5623,   18.9811153,    56.302166,   -4.5454545
   5624,   18.9811153,    56.302166,   -5.4545455
   5625,   18.9811153,    56.302166,  -6.36363649
   5626,   18.9811153,    56.302166,  -7.27272749
   5627,   18.9811153,    56.302166,  -8.18181801
   5628,   18.9811153,    56.302166,    -9.090909
   5629,   18.7693672,   56.9073029, -0.909090936
   5630,   18.7693672,   56.9073029,  -1.81818187
   5631,   18.7693672,   56.9073029,  -2.72727275
   5632,   18.7693672,   56.9073029,  -3.63636374
   5633,   18.7693672,   56.9073029,   -4.5454545
   5634,   18.7693672,   56.9073029,   -5.4545455
   5635,   18.7693672,   56.9073029,  -6.36363649
   5636,   18.7693672,   56.9073029,  -7.27272749
   5637,   18.7693672,   56.9073029,  -8.18181801
   5638,   18.7693672,   56.9073029,    -9.090909
   5639,   18.5383358,   57.5053406, -0.909090936
   5640,   18.5383358,   57.5053406,  -1.81818187
   5641,   18.5383358,   57.5053406,  -2.72727275
   5642,   18.5383358,   57.5053406,  -3.63636374
   5643,   18.5383358,   57.5053406,   -4.5454545
   5644,   18.5383358,   57.5053406,   -5.4545455
   5645,   18.5383358,   57.5053406,  -6.36363649
   5646,   18.5383358,   57.5053406,  -7.27272749
   5647,   18.5383358,   57.5053406,  -8.18181801
   5648,   18.5383358,   57.5053406,    -9.090909
   5649,   18.2882538,    58.095665, -0.909090936
   5650,   18.2882538,    58.095665,  -1.81818187
   5651,   18.2882538,    58.095665,  -2.72727275
   5652,   18.2882538,    58.095665,  -3.63636374
   5653,   18.2882538,    58.095665,   -4.5454545
   5654,   18.2882538,    58.095665,   -5.4545455
   5655,   18.2882538,    58.095665,  -6.36363649
   5656,   18.2882538,    58.095665,  -7.27272749
   5657,   18.2882538,    58.095665,  -8.18181801
   5658,   18.2882538,    58.095665,    -9.090909
   5659,   18.0193787,   58.6776733, -0.909090936
   5660,   18.0193787,   58.6776733,  -1.81818187
   5661,   18.0193787,   58.6776733,  -2.72727275
   5662,   18.0193787,   58.6776733,  -3.63636374
   5663,   18.0193787,   58.6776733,   -4.5454545
   5664,   18.0193787,   58.6776733,   -5.4545455
   5665,   18.0193787,   58.6776733,  -6.36363649
   5666,   18.0193787,   58.6776733,  -7.27272749
   5667,   18.0193787,   58.6776733,  -8.18181801
   5668,   18.0193787,   58.6776733,    -9.090909
   5669,   17.7319851,   59.2507668, -0.909090936
   5670,   17.7319851,   59.2507668,  -1.81818187
   5671,   17.7319851,   59.2507668,  -2.72727275
   5672,   17.7319851,   59.2507668,  -3.63636374
   5673,   17.7319851,   59.2507668,   -4.5454545
   5674,   17.7319851,   59.2507668,   -5.4545455
   5675,   17.7319851,   59.2507668,  -6.36363649
   5676,   17.7319851,   59.2507668,  -7.27272749
   5677,   17.7319851,   59.2507668,  -8.18181801
   5678,   17.7319851,   59.2507668,    -9.090909
   5679,   17.4263744,   59.8143501, -0.909090936
   5680,   17.4263744,   59.8143501,  -1.81818187
   5681,   17.4263744,   59.8143501,  -2.72727275
   5682,   17.4263744,   59.8143501,  -3.63636374
   5683,   17.4263744,   59.8143501,   -4.5454545
   5684,   17.4263744,   59.8143501,   -5.4545455
   5685,   17.4263744,   59.8143501,  -6.36363649
   5686,   17.4263744,   59.8143501,  -7.27272749
   5687,   17.4263744,   59.8143501,  -8.18181801
   5688,   17.4263744,   59.8143501,    -9.090909
   5689,   17.1028557,   60.3678513, -0.909090936
   5690,   17.1028557,   60.3678513,  -1.81818187
   5691,   17.1028557,   60.3678513,  -2.72727275
   5692,   17.1028557,   60.3678513,  -3.63636374
   5693,   17.1028557,   60.3678513,   -4.5454545
   5694,   17.1028557,   60.3678513,   -5.4545455
   5695,   17.1028557,   60.3678513,  -6.36363649
   5696,   17.1028557,   60.3678513,  -7.27272749
   5697,   17.1028557,   60.3678513,  -8.18181801
   5698,   17.1028557,   60.3678513,    -9.090909
   5699,   16.7617626,   60.9106979, -0.909090936
   5700,   16.7617626,   60.9106979,  -1.81818187
   5701,   16.7617626,   60.9106979,  -2.72727275
   5702,   16.7617626,   60.9106979,  -3.63636374
   5703,   16.7617626,   60.9106979,   -4.5454545
   5704,   16.7617626,   60.9106979,   -5.4545455
   5705,   16.7617626,   60.9106979,  -6.36363649
   5706,   16.7617626,   60.9106979,  -7.27272749
   5707,   16.7617626,   60.9106979,  -8.18181801
   5708,   16.7617626,   60.9106979,    -9.090909
   5709,   16.4034443,   61.4423332, -0.909090936
   5710,   16.4034443,   61.4423332,  -1.81818187
   5711,   16.4034443,   61.4423332,  -2.72727275
   5712,   16.4034443,   61.4423332,  -3.63636374
   5713,   16.4034443,   61.4423332,   -4.5454545
   5714,   16.4034443,   61.4423332,   -5.4545455
   5715,   16.4034443,   61.4423332,  -6.36363649
   5716,   16.4034443,   61.4423332,  -7.27272749
   5717,   16.4034443,   61.4423332,  -8.18181801
   5718,   16.4034443,   61.4423332,    -9.090909
   5719,   16.0282726,   61.9622116, -0.909090936
   5720,   16.0282726,   61.9622116,  -1.81818187
   5721,   16.0282726,   61.9622116,  -2.72727275
   5722,   16.0282726,   61.9622116,  -3.63636374
   5723,   16.0282726,   61.9622116,   -4.5454545
   5724,   16.0282726,   61.9622116,   -5.4545455
   5725,   16.0282726,   61.9622116,  -6.36363649
   5726,   16.0282726,   61.9622116,  -7.27272749
   5727,   16.0282726,   61.9622116,  -8.18181801
   5728,   16.0282726,   61.9622116,    -9.090909
   5729,   15.6366301,   62.4697952, -0.909090936
   5730,   15.6366301,   62.4697952,  -1.81818187
   5731,   15.6366301,   62.4697952,  -2.72727275
   5732,   15.6366301,   62.4697952,  -3.63636374
   5733,   15.6366301,   62.4697952,   -4.5454545
   5734,   15.6366301,   62.4697952,   -5.4545455
   5735,   15.6366301,   62.4697952,  -6.36363649
   5736,   15.6366301,   62.4697952,  -7.27272749
   5737,   15.6366301,   62.4697952,  -8.18181801
   5738,   15.6366301,   62.4697952,    -9.090909
   5739,   15.2289181,   62.9645691, -0.909090936
   5740,   15.2289181,   62.9645691,  -1.81818187
   5741,   15.2289181,   62.9645691,  -2.72727275
   5742,   15.2289181,   62.9645691,  -3.63636374
   5743,   15.2289181,   62.9645691,   -4.5454545
   5744,   15.2289181,   62.9645691,   -5.4545455
   5745,   15.2289181,   62.9645691,  -6.36363649
   5746,   15.2289181,   62.9645691,  -7.27272749
   5747,   15.2289181,   62.9645691,  -8.18181801
   5748,   15.2289181,   62.9645691,    -9.090909
   5749,   14.8055601,   63.4460182, -0.909090936
   5750,   14.8055601,   63.4460182,  -1.81818187
   5751,   14.8055601,   63.4460182,  -2.72727275
   5752,   14.8055601,   63.4460182,  -3.63636374
   5753,   14.8055601,   63.4460182,   -4.5454545
   5754,   14.8055601,   63.4460182,   -5.4545455
   5755,   14.8055601,   63.4460182,  -6.36363649
   5756,   14.8055601,   63.4460182,  -7.27272749
   5757,   14.8055601,   63.4460182,  -8.18181801
   5758,   14.8055601,   63.4460182,    -9.090909
   5759,   14.3669872,   63.9136505, -0.909090936
   5760,   14.3669872,   63.9136505,  -1.81818187
   5761,   14.3669872,   63.9136505,  -2.72727275
   5762,   14.3669872,   63.9136505,  -3.63636374
   5763,   14.3669872,   63.9136505,   -4.5454545
   5764,   14.3669872,   63.9136505,   -5.4545455
   5765,   14.3669872,   63.9136505,  -6.36363649
   5766,   14.3669872,   63.9136505,  -7.27272749
   5767,   14.3669872,   63.9136505,  -8.18181801
   5768,   14.3669872,   63.9136505,    -9.090909
   5769,   13.9136505,   64.3669891, -0.909090936
   5770,   13.9136505,   64.3669891,  -1.81818187
   5771,   13.9136505,   64.3669891,  -2.72727275
   5772,   13.9136505,   64.3669891,  -3.63636374
   5773,   13.9136505,   64.3669891,   -4.5454545
   5774,   13.9136505,   64.3669891,   -5.4545455
   5775,   13.9136505,   64.3669891,  -6.36363649
   5776,   13.9136505,   64.3669891,  -7.27272749
   5777,   13.9136505,   64.3669891,  -8.18181801
   5778,   13.9136505,   64.3669891,    -9.090909
   5779,   13.4460192,   64.8055573, -0.909090936
   5780,   13.4460192,   64.8055573,  -1.81818187
   5781,   13.4460192,   64.8055573,  -2.72727275
   5782,   13.4460192,   64.8055573,  -3.63636374
   5783,   13.4460192,   64.8055573,   -4.5454545
   5784,   13.4460192,   64.8055573,   -5.4545455
   5785,   13.4460192,   64.8055573,  -6.36363649
   5786,   13.4460192,   64.8055573,  -7.27272749
   5787,   13.4460192,   64.8055573,  -8.18181801
   5788,   13.4460192,   64.8055573,    -9.090909
   5789,   12.9645672,     65.22892, -0.909090936
   5790,   12.9645672,     65.22892,  -1.81818187
   5791,   12.9645672,     65.22892,  -2.72727275
   5792,   12.9645672,     65.22892,  -3.63636374
   5793,   12.9645672,     65.22892,   -4.5454545
   5794,   12.9645672,     65.22892,   -5.4545455
   5795,   12.9645672,     65.22892,  -6.36363649
   5796,   12.9645672,     65.22892,  -7.27272749
   5797,   12.9645672,     65.22892,  -8.18181801
   5798,   12.9645672,     65.22892,    -9.090909
   5799,   12.4697971,   65.6366272, -0.909090936
   5800,   12.4697971,   65.6366272,  -1.81818187
   5801,   12.4697971,   65.6366272,  -2.72727275
   5802,   12.4697971,   65.6366272,  -3.63636374
   5803,   12.4697971,   65.6366272,   -4.5454545
   5804,   12.4697971,   65.6366272,   -5.4545455
   5805,   12.4697971,   65.6366272,  -6.36363649
   5806,   12.4697971,   65.6366272,  -7.27272749
   5807,   12.4697971,   65.6366272,  -8.18181801
   5808,   12.4697971,   65.6366272,    -9.090909
   5809,   11.9622097,   66.0282745, -0.909090936
   5810,   11.9622097,   66.0282745,  -1.81818187
   5811,   11.9622097,   66.0282745,  -2.72727275
   5812,   11.9622097,   66.0282745,  -3.63636374
   5813,   11.9622097,   66.0282745,   -4.5454545
   5814,   11.9622097,   66.0282745,   -5.4545455
   5815,   11.9622097,   66.0282745,  -6.36363649
   5816,   11.9622097,   66.0282745,  -7.27272749
   5817,   11.9622097,   66.0282745,  -8.18181801
   5818,   11.9622097,   66.0282745,    -9.090909
   5819,   11.4423342,   66.4034424, -0.909090936
   5820,   11.4423342,   66.4034424,  -1.81818187
   5821,   11.4423342,   66.4034424,  -2.72727275
   5822,   11.4423342,   66.4034424,  -3.63636374
   5823,   11.4423342,   66.4034424,   -4.5454545
   5824,   11.4423342,   66.4034424,   -5.4545455
   5825,   11.4423342,   66.4034424,  -6.36363649
   5826,   11.4423342,   66.4034424,  -7.27272749
   5827,   11.4423342,   66.4034424,  -8.18181801
   5828,   11.4423342,   66.4034424,    -9.090909
   5829,    10.910697,   66.7617645, -0.909090936
   5830,    10.910697,   66.7617645,  -1.81818187
   5831,    10.910697,   66.7617645,  -2.72727275
   5832,    10.910697,   66.7617645,  -3.63636374
   5833,    10.910697,   66.7617645,   -4.5454545
   5834,    10.910697,   66.7617645,   -5.4545455
   5835,    10.910697,   66.7617645,  -6.36363649
   5836,    10.910697,   66.7617645,  -7.27272749
   5837,    10.910697,   66.7617645,  -8.18181801
   5838,    10.910697,   66.7617645,    -9.090909
   5839,   10.3678532,   67.1028519, -0.909090936
   5840,   10.3678532,   67.1028519,  -1.81818187
   5841,   10.3678532,   67.1028519,  -2.72727275
   5842,   10.3678532,   67.1028519,  -3.63636374
   5843,   10.3678532,   67.1028519,   -4.5454545
   5844,   10.3678532,   67.1028519,   -5.4545455
   5845,   10.3678532,   67.1028519,  -6.36363649
   5846,   10.3678532,   67.1028519,  -7.27272749
   5847,   10.3678532,   67.1028519,  -8.18181801
   5848,   10.3678532,   67.1028519,    -9.090909
   5849,   9.81435013,   67.4263763, -0.909090936
   5850,   9.81435013,   67.4263763,  -1.81818187
   5851,   9.81435013,   67.4263763,  -2.72727275
   5852,   9.81435013,   67.4263763,  -3.63636374
   5853,   9.81435013,   67.4263763,   -4.5454545
   5854,   9.81435013,   67.4263763,   -5.4545455
   5855,   9.81435013,   67.4263763,  -6.36363649
   5856,   9.81435013,   67.4263763,  -7.27272749
   5857,   9.81435013,   67.4263763,  -8.18181801
   5858,   9.81435013,   67.4263763,    -9.090909
   5859,    9.2507658,    67.731987, -0.909090936
   5860,    9.2507658,    67.731987,  -1.81818187
   5861,    9.2507658,    67.731987,  -2.72727275
   5862,    9.2507658,    67.731987,  -3.63636374
   5863,    9.2507658,    67.731987,   -4.5454545
   5864,    9.2507658,    67.731987,   -5.4545455
   5865,    9.2507658,    67.731987,  -6.36363649
   5866,    9.2507658,    67.731987,  -7.27272749
   5867,    9.2507658,    67.731987,  -8.18181801
   5868,    9.2507658,    67.731987,    -9.090909
   5869,   8.67767429,   68.0193787, -0.909090936
   5870,   8.67767429,   68.0193787,  -1.81818187
   5871,   8.67767429,   68.0193787,  -2.72727275
   5872,   8.67767429,   68.0193787,  -3.63636374
   5873,   8.67767429,   68.0193787,   -4.5454545
   5874,   8.67767429,   68.0193787,   -5.4545455
   5875,   8.67767429,   68.0193787,  -6.36363649
   5876,   8.67767429,   68.0193787,  -7.27272749
   5877,   8.67767429,   68.0193787,  -8.18181801
   5878,   8.67767429,   68.0193787,    -9.090909
   5879,   8.09566593,   68.2882538, -0.909090936
   5880,   8.09566593,   68.2882538,  -1.81818187
   5881,   8.09566593,   68.2882538,  -2.72727275
   5882,   8.09566593,   68.2882538,  -3.63636374
   5883,   8.09566593,   68.2882538,   -4.5454545
   5884,   8.09566593,   68.2882538,   -5.4545455
   5885,   8.09566593,   68.2882538,  -6.36363649
   5886,   8.09566593,   68.2882538,  -7.27272749
   5887,   8.09566593,   68.2882538,  -8.18181801
   5888,   8.09566593,   68.2882538,    -9.090909
   5889,   7.50533915,   68.5383377, -0.909090936
   5890,   7.50533915,   68.5383377,  -1.81818187
   5891,   7.50533915,   68.5383377,  -2.72727275
   5892,   7.50533915,   68.5383377,  -3.63636374
   5893,   7.50533915,   68.5383377,   -4.5454545
   5894,   7.50533915,   68.5383377,   -5.4545455
   5895,   7.50533915,   68.5383377,  -6.36363649
   5896,   7.50533915,   68.5383377,  -7.27272749
   5897,   7.50533915,   68.5383377,  -8.18181801
   5898,   7.50533915,   68.5383377,    -9.090909
   5899,       6.9073,    68.769371, -0.909090936
   5900,       6.9073,    68.769371,  -1.81818187
   5901,       6.9073,    68.769371,  -2.72727275
   5902,       6.9073,    68.769371,  -3.63636374
   5903,       6.9073,    68.769371,   -4.5454545
   5904,       6.9073,    68.769371,   -5.4545455
   5905,       6.9073,    68.769371,  -6.36363649
   5906,       6.9073,    68.769371,  -7.27272749
   5907,       6.9073,    68.769371,  -8.18181801
   5908,       6.9073,    68.769371,    -9.090909
   5909,   6.30216408,   68.9811172, -0.909090936
   5910,   6.30216408,   68.9811172,  -1.81818187
   5911,   6.30216408,   68.9811172,  -2.72727275
   5912,   6.30216408,   68.9811172,  -3.63636374
   5913,   6.30216408,   68.9811172,   -4.5454545
   5914,   6.30216408,   68.9811172,   -5.4545455
   5915,   6.30216408,   68.9811172,  -6.36363649
   5916,   6.30216408,   68.9811172,  -7.27272749
   5917,   6.30216408,   68.9811172,  -8.18181801
   5918,   6.30216408,   68.9811172,    -9.090909
   5919,   5.69055223,   69.1733551, -0.909090936
   5920,   5.69055223,   69.1733551,  -1.81818187
   5921,   5.69055223,   69.1733551,  -2.72727275
   5922,   5.69055223,   69.1733551,  -3.63636374
   5923,   5.69055223,   69.1733551,   -4.5454545
   5924,   5.69055223,   69.1733551,   -5.4545455
   5925,   5.69055223,   69.1733551,  -6.36363649
   5926,   5.69055223,   69.1733551,  -7.27272749
   5927,   5.69055223,   69.1733551,  -8.18181801
   5928,   5.69055223,   69.1733551,    -9.090909
   5929,   5.07309246,   69.3458939, -0.909090936
   5930,   5.07309246,   69.3458939,  -1.81818187
   5931,   5.07309246,   69.3458939,  -2.72727275
   5932,   5.07309246,   69.3458939,  -3.63636374
   5933,   5.07309246,   69.3458939,   -4.5454545
   5934,   5.07309246,   69.3458939,   -5.4545455
   5935,   5.07309246,   69.3458939,  -6.36363649
   5936,   5.07309246,   69.3458939,  -7.27272749
   5937,   5.07309246,   69.3458939,  -8.18181801
   5938,   5.07309246,   69.3458939,    -9.090909
   5939,   4.45041847,    69.498558, -0.909090936
   5940,   4.45041847,    69.498558,  -1.81818187
   5941,   4.45041847,    69.498558,  -2.72727275
   5942,   4.45041847,    69.498558,  -3.63636374
   5943,   4.45041847,    69.498558,   -4.5454545
   5944,   4.45041847,    69.498558,   -5.4545455
   5945,   4.45041847,    69.498558,  -6.36363649
   5946,   4.45041847,    69.498558,  -7.27272749
   5947,   4.45041847,    69.498558,  -8.18181801
   5948,   4.45041847,    69.498558,    -9.090909
   5949,   3.82317328,   69.6311798, -0.909090936
   5950,   3.82317328,   69.6311798,  -1.81818187
   5951,   3.82317328,   69.6311798,  -2.72727275
   5952,   3.82317328,   69.6311798,  -3.63636374
   5953,   3.82317328,   69.6311798,   -4.5454545
   5954,   3.82317328,   69.6311798,   -5.4545455
   5955,   3.82317328,   69.6311798,  -6.36363649
   5956,   3.82317328,   69.6311798,  -7.27272749
   5957,   3.82317328,   69.6311798,  -8.18181801
   5958,   3.82317328,   69.6311798,    -9.090909
   5959,   3.19199777,   69.7436371, -0.909090936
   5960,   3.19199777,   69.7436371,  -1.81818187
   5961,   3.19199777,   69.7436371,  -2.72727275
   5962,   3.19199777,   69.7436371,  -3.63636374
   5963,   3.19199777,   69.7436371,   -4.5454545
   5964,   3.19199777,   69.7436371,   -5.4545455
   5965,   3.19199777,   69.7436371,  -6.36363649
   5966,   3.19199777,   69.7436371,  -7.27272749
   5967,   3.19199777,   69.7436371,  -8.18181801
   5968,   3.19199777,   69.7436371,    -9.090909
   5969,   2.55754328,   69.8358002, -0.909090936
   5970,   2.55754328,   69.8358002,  -1.81818187
   5971,   2.55754328,   69.8358002,  -2.72727275
   5972,   2.55754328,   69.8358002,  -3.63636374
   5973,   2.55754328,   69.8358002,   -4.5454545
   5974,   2.55754328,   69.8358002,   -5.4545455
   5975,   2.55754328,   69.8358002,  -6.36363649
   5976,   2.55754328,   69.8358002,  -7.27272749
   5977,   2.55754328,   69.8358002,  -8.18181801
   5978,   2.55754328,   69.8358002,    -9.090909
   5979,   1.92046022,   69.9075851, -0.909090936
   5980,   1.92046022,   69.9075851,  -1.81818187
   5981,   1.92046022,   69.9075851,  -2.72727275
   5982,   1.92046022,   69.9075851,  -3.63636374
   5983,   1.92046022,   69.9075851,   -4.5454545
   5984,   1.92046022,   69.9075851,   -5.4545455
   5985,   1.92046022,   69.9075851,  -6.36363649
   5986,   1.92046022,   69.9075851,  -7.27272749
   5987,   1.92046022,   69.9075851,  -8.18181801
   5988,   1.92046022,   69.9075851,    -9.090909
   5989,   1.28140438,   69.9589081, -0.909090936
   5990,   1.28140438,   69.9589081,  -1.81818187
   5991,   1.28140438,   69.9589081,  -2.72727275
   5992,   1.28140438,   69.9589081,  -3.63636374
   5993,   1.28140438,   69.9589081,   -4.5454545
   5994,   1.28140438,   69.9589081,   -5.4545455
