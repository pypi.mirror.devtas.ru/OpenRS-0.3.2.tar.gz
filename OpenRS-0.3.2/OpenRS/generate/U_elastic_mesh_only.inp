  61995,    26.363636,   3.33333325, -0.909090936
  61996,    27.272728,   3.33333325, -0.909090936
  61997,    28.181818,   3.33333325, -0.909090936
  61998,     29.09091,   3.33333325, -0.909090936
  61999,     20.90909,          2.5, -0.909090936
  62000,    21.818182,          2.5, -0.909090936
  62001,    22.727272,          2.5, -0.909090936
  62002,    23.636364,          2.5, -0.909090936
  62003,    24.545454,          2.5, -0.909090936
  62004,    25.454546,          2.5, -0.909090936
  62005,    26.363636,          2.5, -0.909090936
  62006,    27.272728,          2.5, -0.909090936
  62007,    28.181818,          2.5, -0.909090936
  62008,     29.09091,          2.5, -0.909090936
  62009,     20.90909,   1.66666663, -0.909090936
  62010,    21.818182,   1.66666663, -0.909090936
  62011,    22.727272,   1.66666663, -0.909090936
  62012,    23.636364,   1.66666663, -0.909090936
  62013,    24.545454,   1.66666663, -0.909090936
  62014,    25.454546,   1.66666663, -0.909090936
  62015,    26.363636,   1.66666663, -0.909090936
  62016,    27.272728,   1.66666663, -0.909090936
  62017,    28.181818,   1.66666663, -0.909090936
  62018,     29.09091,   1.66666663, -0.909090936
  62019,     20.90909,  0.833333313, -0.909090936
  62020,    21.818182,  0.833333313, -0.909090936
  62021,    22.727272,  0.833333313, -0.909090936
  62022,    23.636364,  0.833333313, -0.909090936
  62023,    24.545454,  0.833333313, -0.909090936
  62024,    25.454546,  0.833333313, -0.909090936
  62025,    26.363636,  0.833333313, -0.909090936
  62026,    27.272728,  0.833333313, -0.909090936
  62027,    28.181818,  0.833333313, -0.909090936
  62028,     29.09091,  0.833333313, -0.909090936
  62029,    -29.09091,  0.833333313, -0.909090936
  62030,   -28.181818,  0.833333313, -0.909090936
  62031,   -27.272728,  0.833333313, -0.909090936
  62032,   -26.363636,  0.833333313, -0.909090936
  62033,   -25.454546,  0.833333313, -0.909090936
  62034,   -24.545454,  0.833333313, -0.909090936
  62035,   -23.636364,  0.833333313, -0.909090936
  62036,   -22.727272,  0.833333313, -0.909090936
  62037,   -21.818182,  0.833333313, -0.909090936
  62038,    -20.90909,  0.833333313, -0.909090936
  62039,    -29.09091,   1.66666663, -0.909090936
  62040,   -28.181818,   1.66666663, -0.909090936
  62041,   -27.272728,   1.66666663, -0.909090936
  62042,   -26.363636,   1.66666663, -0.909090936
  62043,   -25.454546,   1.66666663, -0.909090936
  62044,   -24.545454,   1.66666663, -0.909090936
  62045,   -23.636364,   1.66666663, -0.909090936
  62046,   -22.727272,   1.66666663, -0.909090936
  62047,   -21.818182,   1.66666663, -0.909090936
  62048,    -20.90909,   1.66666663, -0.909090936
  62049,    -29.09091,          2.5, -0.909090936
  62050,   -28.181818,          2.5, -0.909090936
  62051,   -27.272728,          2.5, -0.909090936
  62052,   -26.363636,          2.5, -0.909090936
  62053,   -25.454546,          2.5, -0.909090936
  62054,   -24.545454,          2.5, -0.909090936
  62055,   -23.636364,          2.5, -0.909090936
  62056,   -22.727272,          2.5, -0.909090936
  62057,   -21.818182,          2.5, -0.909090936
  62058,    -20.90909,          2.5, -0.909090936
  62059,    -29.09091,   3.33333325, -0.909090936
  62060,   -28.181818,   3.33333325, -0.909090936
  62061,   -27.272728,   3.33333325, -0.909090936
  62062,   -26.363636,   3.33333325, -0.909090936
  62063,   -25.454546,   3.33333325, -0.909090936
  62064,   -24.545454,   3.33333325, -0.909090936
  62065,   -23.636364,   3.33333325, -0.909090936
  62066,   -22.727272,   3.33333325, -0.909090936
  62067,   -21.818182,   3.33333325, -0.909090936
  62068,    -20.90909,   3.33333325, -0.909090936
  62069,    -29.09091,   4.16666651, -0.909090936
  62070,   -28.181818,   4.16666651, -0.909090936
  62071,   -27.272728,   4.16666651, -0.909090936
  62072,   -26.363636,   4.16666651, -0.909090936
  62073,   -25.454546,   4.16666651, -0.909090936
  62074,   -24.545454,   4.16666651, -0.909090936
  62075,   -23.636364,   4.16666651, -0.909090936
  62076,   -22.727272,   4.16666651, -0.909090936
  62077,   -21.818182,   4.16666651, -0.909090936
  62078,    -20.90909,   4.16666651, -0.909090936
  62079,    -29.09091,           5., -0.909090936
  62080,   -28.181818,           5., -0.909090936
  62081,   -27.272728,           5., -0.909090936
  62082,   -26.363636,           5., -0.909090936
  62083,   -25.454546,           5., -0.909090936
  62084,   -24.545454,           5., -0.909090936
  62085,   -23.636364,           5., -0.909090936
  62086,   -22.727272,           5., -0.909090936
  62087,   -21.818182,           5., -0.909090936
  62088,    -20.90909,           5., -0.909090936
  62089,    -29.09091,   5.83333349, -0.909090936
  62090,   -28.181818,   5.83333349, -0.909090936
  62091,   -27.272728,   5.83333349, -0.909090936
  62092,   -26.363636,   5.83333349, -0.909090936
  62093,   -25.454546,   5.83333349, -0.909090936
  62094,   -24.545454,   5.83333349, -0.909090936
  62095,   -23.636364,   5.83333349, -0.909090936
  62096,   -22.727272,   5.83333349, -0.909090936
  62097,   -21.818182,   5.83333349, -0.909090936
  62098,    -20.90909,   5.83333349, -0.909090936
  62099,    -29.09091,   6.66666651, -0.909090936
  62100,   -28.181818,   6.66666651, -0.909090936
  62101,   -27.272728,   6.66666651, -0.909090936
  62102,   -26.363636,   6.66666651, -0.909090936
  62103,   -25.454546,   6.66666651, -0.909090936
  62104,   -24.545454,   6.66666651, -0.909090936
  62105,   -23.636364,   6.66666651, -0.909090936
  62106,   -22.727272,   6.66666651, -0.909090936
  62107,   -21.818182,   6.66666651, -0.909090936
  62108,    -20.90909,   6.66666651, -0.909090936
  62109,    -29.09091,          7.5, -0.909090936
  62110,   -28.181818,          7.5, -0.909090936
  62111,   -27.272728,          7.5, -0.909090936
  62112,   -26.363636,          7.5, -0.909090936
  62113,   -25.454546,          7.5, -0.909090936
  62114,   -24.545454,          7.5, -0.909090936
  62115,   -23.636364,          7.5, -0.909090936
  62116,   -22.727272,          7.5, -0.909090936
  62117,   -21.818182,          7.5, -0.909090936
  62118,    -20.90909,          7.5, -0.909090936
  62119,    -29.09091,   8.33333302, -0.909090936
  62120,   -28.181818,   8.33333302, -0.909090936
  62121,   -27.272728,   8.33333302, -0.909090936
  62122,   -26.363636,   8.33333302, -0.909090936
  62123,   -25.454546,   8.33333302, -0.909090936
  62124,   -24.545454,   8.33333302, -0.909090936
  62125,   -23.636364,   8.33333302, -0.909090936
  62126,   -22.727272,   8.33333302, -0.909090936
  62127,   -21.818182,   8.33333302, -0.909090936
  62128,    -20.90909,   8.33333302, -0.909090936
  62129,    -29.09091,   9.16666698, -0.909090936
  62130,   -28.181818,   9.16666698, -0.909090936
  62131,   -27.272728,   9.16666698, -0.909090936
  62132,   -26.363636,   9.16666698, -0.909090936
  62133,   -25.454546,   9.16666698, -0.909090936
  62134,   -24.545454,   9.16666698, -0.909090936
  62135,   -23.636364,   9.16666698, -0.909090936
  62136,   -22.727272,   9.16666698, -0.909090936
  62137,   -21.818182,   9.16666698, -0.909090936
  62138,    -20.90909,   9.16666698, -0.909090936
  62139,    -29.09091,  0.833333313,  -1.81818187
  62140,   -28.181818,  0.833333313,  -1.81818187
  62141,   -27.272728,  0.833333313,  -1.81818187
  62142,   -26.363636,  0.833333313,  -1.81818187
  62143,   -25.454546,  0.833333313,  -1.81818187
  62144,   -24.545454,  0.833333313,  -1.81818187
  62145,   -23.636364,  0.833333313,  -1.81818187
  62146,   -22.727272,  0.833333313,  -1.81818187
  62147,   -21.818182,  0.833333313,  -1.81818187
  62148,    -20.90909,  0.833333313,  -1.81818187
  62149,    -29.09091,   1.66666663,  -1.81818187
  62150,   -28.181818,   1.66666663,  -1.81818187
  62151,   -27.272728,   1.66666663,  -1.81818187
  62152,   -26.363636,   1.66666663,  -1.81818187
  62153,   -25.454546,   1.66666663,  -1.81818187
  62154,   -24.545454,   1.66666663,  -1.81818187
  62155,   -23.636364,   1.66666663,  -1.81818187
  62156,   -22.727272,   1.66666663,  -1.81818187
  62157,   -21.818182,   1.66666663,  -1.81818187
  62158,    -20.90909,   1.66666663,  -1.81818187
  62159,    -29.09091,          2.5,  -1.81818187
  62160,   -28.181818,          2.5,  -1.81818187
  62161,   -27.272728,          2.5,  -1.81818187
  62162,   -26.363636,          2.5,  -1.81818187
  62163,   -25.454546,          2.5,  -1.81818187
  62164,   -24.545454,          2.5,  -1.81818187
  62165,   -23.636364,          2.5,  -1.81818187
  62166,   -22.727272,          2.5,  -1.81818187
  62167,   -21.818182,          2.5,  -1.81818187
  62168,    -20.90909,          2.5,  -1.81818187
  62169,    -29.09091,   3.33333325,  -1.81818187
  62170,   -28.181818,   3.33333325,  -1.81818187
  62171,   -27.272728,   3.33333325,  -1.81818187
  62172,   -26.363636,   3.33333325,  -1.81818187
  62173,   -25.454546,   3.33333325,  -1.81818187
  62174,   -24.545454,   3.33333325,  -1.81818187
  62175,   -23.636364,   3.33333325,  -1.81818187
  62176,   -22.727272,   3.33333325,  -1.81818187
  62177,   -21.818182,   3.33333325,  -1.81818187
  62178,    -20.90909,   3.33333325,  -1.81818187
  62179,    -29.09091,   4.16666651,  -1.81818187
  62180,   -28.181818,   4.16666651,  -1.81818187
  62181,   -27.272728,   4.16666651,  -1.81818187
  62182,   -26.363636,   4.16666651,  -1.81818187
  62183,   -25.454546,   4.16666651,  -1.81818187
  62184,   -24.545454,   4.16666651,  -1.81818187
  62185,   -23.636364,   4.16666651,  -1.81818187
  62186,   -22.727272,   4.16666651,  -1.81818187
  62187,   -21.818182,   4.16666651,  -1.81818187
  62188,    -20.90909,   4.16666651,  -1.81818187
  62189,    -29.09091,           5.,  -1.81818187
  62190,   -28.181818,           5.,  -1.81818187
  62191,   -27.272728,           5.,  -1.81818187
  62192,   -26.363636,           5.,  -1.81818187
  62193,   -25.454546,           5.,  -1.81818187
  62194,   -24.545454,           5.,  -1.81818187
  62195,   -23.636364,           5.,  -1.81818187
  62196,   -22.727272,           5.,  -1.81818187
  62197,   -21.818182,           5.,  -1.81818187
  62198,    -20.90909,           5.,  -1.81818187
  62199,    -29.09091,   5.83333349,  -1.81818187
  62200,   -28.181818,   5.83333349,  -1.81818187
  62201,   -27.272728,   5.83333349,  -1.81818187
  62202,   -26.363636,   5.83333349,  -1.81818187
  62203,   -25.454546,   5.83333349,  -1.81818187
  62204,   -24.545454,   5.83333349,  -1.81818187
  62205,   -23.636364,   5.83333349,  -1.81818187
  62206,   -22.727272,   5.83333349,  -1.81818187
  62207,   -21.818182,   5.83333349,  -1.81818187
  62208,    -20.90909,   5.83333349,  -1.81818187
  62209,    -29.09091,   6.66666651,  -1.81818187
  62210,   -28.181818,   6.66666651,  -1.81818187
  62211,   -27.272728,   6.66666651,  -1.81818187
  62212,   -26.363636,   6.66666651,  -1.81818187
  62213,   -25.454546,   6.66666651,  -1.81818187
  62214,   -24.545454,   6.66666651,  -1.81818187
  62215,   -23.636364,   6.66666651,  -1.81818187
  62216,   -22.727272,   6.66666651,  -1.81818187
  62217,   -21.818182,   6.66666651,  -1.81818187
  62218,    -20.90909,   6.66666651,  -1.81818187
  62219,    -29.09091,          7.5,  -1.81818187
  62220,   -28.181818,          7.5,  -1.81818187
  62221,   -27.272728,          7.5,  -1.81818187
  62222,   -26.363636,          7.5,  -1.81818187
  62223,   -25.454546,          7.5,  -1.81818187
  62224,   -24.545454,          7.5,  -1.81818187
  62225,   -23.636364,          7.5,  -1.81818187
  62226,   -22.727272,          7.5,  -1.81818187
  62227,   -21.818182,          7.5,  -1.81818187
  62228,    -20.90909,          7.5,  -1.81818187
  62229,    -29.09091,   8.33333302,  -1.81818187
  62230,   -28.181818,   8.33333302,  -1.81818187
  62231,   -27.272728,   8.33333302,  -1.81818187
  62232,   -26.363636,   8.33333302,  -1.81818187
  62233,   -25.454546,   8.33333302,  -1.81818187
  62234,   -24.545454,   8.33333302,  -1.81818187
  62235,   -23.636364,   8.33333302,  -1.81818187
  62236,   -22.727272,   8.33333302,  -1.81818187
  62237,   -21.818182,   8.33333302,  -1.81818187
  62238,    -20.90909,   8.33333302,  -1.81818187
  62239,    -29.09091,   9.16666698,  -1.81818187
  62240,   -28.181818,   9.16666698,  -1.81818187
  62241,   -27.272728,   9.16666698,  -1.81818187
  62242,   -26.363636,   9.16666698,  -1.81818187
  62243,   -25.454546,   9.16666698,  -1.81818187
  62244,   -24.545454,   9.16666698,  -1.81818187
  62245,   -23.636364,   9.16666698,  -1.81818187
  62246,   -22.727272,   9.16666698,  -1.81818187
  62247,   -21.818182,   9.16666698,  -1.81818187
  62248,    -20.90909,   9.16666698,  -1.81818187
  62249,    -29.09091,  0.833333313,  -2.72727275
  62250,   -28.181818,  0.833333313,  -2.72727275
  62251,   -27.272728,  0.833333313,  -2.72727275
  62252,   -26.363636,  0.833333313,  -2.72727275
  62253,   -25.454546,  0.833333313,  -2.72727275
  62254,   -24.545454,  0.833333313,  -2.72727275
  62255,   -23.636364,  0.833333313,  -2.72727275
  62256,   -22.727272,  0.833333313,  -2.72727275
  62257,   -21.818182,  0.833333313,  -2.72727275
  62258,    -20.90909,  0.833333313,  -2.72727275
  62259,    -29.09091,   1.66666663,  -2.72727275
  62260,   -28.181818,   1.66666663,  -2.72727275
  62261,   -27.272728,   1.66666663,  -2.72727275
  62262,   -26.363636,   1.66666663,  -2.72727275
  62263,   -25.454546,   1.66666663,  -2.72727275
  62264,   -24.545454,   1.66666663,  -2.72727275
  62265,   -23.636364,   1.66666663,  -2.72727275
  62266,   -22.727272,   1.66666663,  -2.72727275
  62267,   -21.818182,   1.66666663,  -2.72727275
  62268,    -20.90909,   1.66666663,  -2.72727275
  62269,    -29.09091,          2.5,  -2.72727275
  62270,   -28.181818,          2.5,  -2.72727275
  62271,   -27.272728,          2.5,  -2.72727275
  62272,   -26.363636,          2.5,  -2.72727275
  62273,   -25.454546,          2.5,  -2.72727275
  62274,   -24.545454,          2.5,  -2.72727275
  62275,   -23.636364,          2.5,  -2.72727275
  62276,   -22.727272,          2.5,  -2.72727275
  62277,   -21.818182,          2.5,  -2.72727275
  62278,    -20.90909,          2.5,  -2.72727275
  62279,    -29.09091,   3.33333325,  -2.72727275
  62280,   -28.181818,   3.33333325,  -2.72727275
  62281,   -27.272728,   3.33333325,  -2.72727275
  62282,   -26.363636,   3.33333325,  -2.72727275
  62283,   -25.454546,   3.33333325,  -2.72727275
  62284,   -24.545454,   3.33333325,  -2.72727275
  62285,   -23.636364,   3.33333325,  -2.72727275
  62286,   -22.727272,   3.33333325,  -2.72727275
  62287,   -21.818182,   3.33333325,  -2.72727275
  62288,    -20.90909,   3.33333325,  -2.72727275
  62289,    -29.09091,   4.16666651,  -2.72727275
  62290,   -28.181818,   4.16666651,  -2.72727275
  62291,   -27.272728,   4.16666651,  -2.72727275
  62292,   -26.363636,   4.16666651,  -2.72727275
  62293,   -25.454546,   4.16666651,  -2.72727275
  62294,   -24.545454,   4.16666651,  -2.72727275
  62295,   -23.636364,   4.16666651,  -2.72727275
  62296,   -22.727272,   4.16666651,  -2.72727275
  62297,   -21.818182,   4.16666651,  -2.72727275
  62298,    -20.90909,   4.16666651,  -2.72727275
  62299,    -29.09091,           5.,  -2.72727275
  62300,   -28.181818,           5.,  -2.72727275
  62301,   -27.272728,           5.,  -2.72727275
  62302,   -26.363636,           5.,  -2.72727275
  62303,   -25.454546,           5.,  -2.72727275
  62304,   -24.545454,           5.,  -2.72727275
  62305,   -23.636364,           5.,  -2.72727275
  62306,   -22.727272,           5.,  -2.72727275
  62307,   -21.818182,           5.,  -2.72727275
  62308,    -20.90909,           5.,  -2.72727275
  62309,    -29.09091,   5.83333349,  -2.72727275
  62310,   -28.181818,   5.83333349,  -2.72727275
  62311,   -27.272728,   5.83333349,  -2.72727275
  62312,   -26.363636,   5.83333349,  -2.72727275
  62313,   -25.454546,   5.83333349,  -2.72727275
  62314,   -24.545454,   5.83333349,  -2.72727275
  62315,   -23.636364,   5.83333349,  -2.72727275
  62316,   -22.727272,   5.83333349,  -2.72727275
  62317,   -21.818182,   5.83333349,  -2.72727275
  62318,    -20.90909,   5.83333349,  -2.72727275
  62319,    -29.09091,   6.66666651,  -2.72727275
  62320,   -28.181818,   6.66666651,  -2.72727275
  62321,   -27.272728,   6.66666651,  -2.72727275
  62322,   -26.363636,   6.66666651,  -2.72727275
  62323,   -25.454546,   6.66666651,  -2.72727275
  62324,   -24.545454,   6.66666651,  -2.72727275
  62325,   -23.636364,   6.66666651,  -2.72727275
  62326,   -22.727272,   6.66666651,  -2.72727275
  62327,   -21.818182,   6.66666651,  -2.72727275
  62328,    -20.90909,   6.66666651,  -2.72727275
  62329,    -29.09091,          7.5,  -2.72727275
  62330,   -28.181818,          7.5,  -2.72727275
  62331,   -27.272728,          7.5,  -2.72727275
  62332,   -26.363636,          7.5,  -2.72727275
  62333,   -25.454546,          7.5,  -2.72727275
  62334,   -24.545454,          7.5,  -2.72727275
  62335,   -23.636364,          7.5,  -2.72727275
  62336,   -22.727272,          7.5,  -2.72727275
  62337,   -21.818182,          7.5,  -2.72727275
  62338,    -20.90909,          7.5,  -2.72727275
  62339,    -29.09091,   8.33333302,  -2.72727275
  62340,   -28.181818,   8.33333302,  -2.72727275
  62341,   -27.272728,   8.33333302,  -2.72727275
  62342,   -26.363636,   8.33333302,  -2.72727275
  62343,   -25.454546,   8.33333302,  -2.72727275
  62344,   -24.545454,   8.33333302,  -2.72727275
  62345,   -23.636364,   8.33333302,  -2.72727275
  62346,   -22.727272,   8.33333302,  -2.72727275
  62347,   -21.818182,   8.33333302,  -2.72727275
  62348,    -20.90909,   8.33333302,  -2.72727275
  62349,    -29.09091,   9.16666698,  -2.72727275
  62350,   -28.181818,   9.16666698,  -2.72727275
  62351,   -27.272728,   9.16666698,  -2.72727275
  62352,   -26.363636,   9.16666698,  -2.72727275
  62353,   -25.454546,   9.16666698,  -2.72727275
  62354,   -24.545454,   9.16666698,  -2.72727275
  62355,   -23.636364,   9.16666698,  -2.72727275
  62356,   -22.727272,   9.16666698,  -2.72727275
  62357,   -21.818182,   9.16666698,  -2.72727275
  62358,    -20.90909,   9.16666698,  -2.72727275
  62359,    -29.09091,  0.833333313,  -3.63636374
  62360,   -28.181818,  0.833333313,  -3.63636374
  62361,   -27.272728,  0.833333313,  -3.63636374
  62362,   -26.363636,  0.833333313,  -3.63636374
  62363,   -25.454546,  0.833333313,  -3.63636374
  62364,   -24.545454,  0.833333313,  -3.63636374
  62365,   -23.636364,  0.833333313,  -3.63636374
  62366,   -22.727272,  0.833333313,  -3.63636374
  62367,   -21.818182,  0.833333313,  -3.63636374
  62368,    -20.90909,  0.833333313,  -3.63636374
  62369,    -29.09091,   1.66666663,  -3.63636374
  62370,   -28.181818,   1.66666663,  -3.63636374
  62371,   -27.272728,   1.66666663,  -3.63636374
  62372,   -26.363636,   1.66666663,  -3.63636374
  62373,   -25.454546,   1.66666663,  -3.63636374
  62374,   -24.545454,   1.66666663,  -3.63636374
  62375,   -23.636364,   1.66666663,  -3.63636374
  62376,   -22.727272,   1.66666663,  -3.63636374
  62377,   -21.818182,   1.66666663,  -3.63636374
  62378,    -20.90909,   1.66666663,  -3.63636374
  62379,    -29.09091,          2.5,  -3.63636374
  62380,   -28.181818,          2.5,  -3.63636374
  62381,   -27.272728,          2.5,  -3.63636374
  62382,   -26.363636,          2.5,  -3.63636374
  62383,   -25.454546,          2.5,  -3.63636374
  62384,   -24.545454,          2.5,  -3.63636374
  62385,   -23.636364,          2.5,  -3.63636374
  62386,   -22.727272,          2.5,  -3.63636374
  62387,   -21.818182,          2.5,  -3.63636374
  62388,    -20.90909,          2.5,  -3.63636374
  62389,    -29.09091,   3.33333325,  -3.63636374
  62390,   -28.181818,   3.33333325,  -3.63636374
  62391,   -27.272728,   3.33333325,  -3.63636374
  62392,   -26.363636,   3.33333325,  -3.63636374
  62393,   -25.454546,   3.33333325,  -3.63636374
  62394,   -24.545454,   3.33333325,  -3.63636374
  62395,   -23.636364,   3.33333325,  -3.63636374
  62396,   -22.727272,   3.33333325,  -3.63636374
  62397,   -21.818182,   3.33333325,  -3.63636374
  62398,    -20.90909,   3.33333325,  -3.63636374
  62399,    -29.09091,   4.16666651,  -3.63636374
  62400,   -28.181818,   4.16666651,  -3.63636374
  62401,   -27.272728,   4.16666651,  -3.63636374
  62402,   -26.363636,   4.16666651,  -3.63636374
  62403,   -25.454546,   4.16666651,  -3.63636374
  62404,   -24.545454,   4.16666651,  -3.63636374
  62405,   -23.636364,   4.16666651,  -3.63636374
  62406,   -22.727272,   4.16666651,  -3.63636374
  62407,   -21.818182,   4.16666651,  -3.63636374
  62408,    -20.90909,   4.16666651,  -3.63636374
  62409,    -29.09091,           5.,  -3.63636374
  62410,   -28.181818,           5.,  -3.63636374
  62411,   -27.272728,           5.,  -3.63636374
  62412,   -26.363636,           5.,  -3.63636374
  62413,   -25.454546,           5.,  -3.63636374
  62414,   -24.545454,           5.,  -3.63636374
  62415,   -23.636364,           5.,  -3.63636374
  62416,   -22.727272,           5.,  -3.63636374
  62417,   -21.818182,           5.,  -3.63636374
  62418,    -20.90909,           5.,  -3.63636374
  62419,    -29.09091,   5.83333349,  -3.63636374
  62420,   -28.181818,   5.83333349,  -3.63636374
  62421,   -27.272728,   5.83333349,  -3.63636374
  62422,   -26.363636,   5.83333349,  -3.63636374
  62423,   -25.454546,   5.83333349,  -3.63636374
  62424,   -24.545454,   5.83333349,  -3.63636374
  62425,   -23.636364,   5.83333349,  -3.63636374
  62426,   -22.727272,   5.83333349,  -3.63636374
  62427,   -21.818182,   5.83333349,  -3.63636374
  62428,    -20.90909,   5.83333349,  -3.63636374
  62429,    -29.09091,   6.66666651,  -3.63636374
  62430,   -28.181818,   6.66666651,  -3.63636374
  62431,   -27.272728,   6.66666651,  -3.63636374
  62432,   -26.363636,   6.66666651,  -3.63636374
  62433,   -25.454546,   6.66666651,  -3.63636374
  62434,   -24.545454,   6.66666651,  -3.63636374
  62435,   -23.636364,   6.66666651,  -3.63636374
  62436,   -22.727272,   6.66666651,  -3.63636374
  62437,   -21.818182,   6.66666651,  -3.63636374
  62438,    -20.90909,   6.66666651,  -3.63636374
  62439,    -29.09091,          7.5,  -3.63636374
  62440,   -28.181818,          7.5,  -3.63636374
  62441,   -27.272728,          7.5,  -3.63636374
  62442,   -26.363636,          7.5,  -3.63636374
  62443,   -25.454546,          7.5,  -3.63636374
  62444,   -24.545454,          7.5,  -3.63636374
  62445,   -23.636364,          7.5,  -3.63636374
  62446,   -22.727272,          7.5,  -3.63636374
  62447,   -21.818182,          7.5,  -3.63636374
  62448,    -20.90909,          7.5,  -3.63636374
  62449,    -29.09091,   8.33333302,  -3.63636374
  62450,   -28.181818,   8.33333302,  -3.63636374
  62451,   -27.272728,   8.33333302,  -3.63636374
  62452,   -26.363636,   8.33333302,  -3.63636374
  62453,   -25.454546,   8.33333302,  -3.63636374
  62454,   -24.545454,   8.33333302,  -3.63636374
  62455,   -23.636364,   8.33333302,  -3.63636374
  62456,   -22.727272,   8.33333302,  -3.63636374
  62457,   -21.818182,   8.33333302,  -3.63636374
  62458,    -20.90909,   8.33333302,  -3.63636374
  62459,    -29.09091,   9.16666698,  -3.63636374
  62460,   -28.181818,   9.16666698,  -3.63636374
  62461,   -27.272728,   9.16666698,  -3.63636374
  62462,   -26.363636,   9.16666698,  -3.63636374
  62463,   -25.454546,   9.16666698,  -3.63636374
  62464,   -24.545454,   9.16666698,  -3.63636374
  62465,   -23.636364,   9.16666698,  -3.63636374
  62466,   -22.727272,   9.16666698,  -3.63636374
  62467,   -21.818182,   9.16666698,  -3.63636374
  62468,    -20.90909,   9.16666698,  -3.63636374
  62469,    -29.09091,  0.833333313,   -4.5454545
  62470,   -28.181818,  0.833333313,   -4.5454545
  62471,   -27.272728,  0.833333313,   -4.5454545
  62472,   -26.363636,  0.833333313,   -4.5454545
  62473,   -25.454546,  0.833333313,   -4.5454545
  62474,   -24.545454,  0.833333313,   -4.5454545
  62475,   -23.636364,  0.833333313,   -4.5454545
  62476,   -22.727272,  0.833333313,   -4.5454545
  62477,   -21.818182,  0.833333313,   -4.5454545
  62478,    -20.90909,  0.833333313,   -4.5454545
  62479,    -29.09091,   1.66666663,   -4.5454545
  62480,   -28.181818,   1.66666663,   -4.5454545
  62481,   -27.272728,   1.66666663,   -4.5454545
  62482,   -26.363636,   1.66666663,   -4.5454545
  62483,   -25.454546,   1.66666663,   -4.5454545
  62484,   -24.545454,   1.66666663,   -4.5454545
  62485,   -23.636364,   1.66666663,   -4.5454545
  62486,   -22.727272,   1.66666663,   -4.5454545
  62487,   -21.818182,   1.66666663,   -4.5454545
  62488,    -20.90909,   1.66666663,   -4.5454545
  62489,    -29.09091,          2.5,   -4.5454545
  62490,   -28.181818,          2.5,   -4.5454545
  62491,   -27.272728,          2.5,   -4.5454545
  62492,   -26.363636,          2.5,   -4.5454545
  62493,   -25.454546,          2.5,   -4.5454545
  62494,   -24.545454,          2.5,   -4.5454545
  62495,   -23.636364,          2.5,   -4.5454545
  62496,   -22.727272,          2.5,   -4.5454545
  62497,   -21.818182,          2.5,   -4.5454545
  62498,    -20.90909,          2.5,   -4.5454545
  62499,    -29.09091,   3.33333325,   -4.5454545
  62500,   -28.181818,   3.33333325,   -4.5454545
  62501,   -27.272728,   3.33333325,   -4.5454545
  62502,   -26.363636,   3.33333325,   -4.5454545
  62503,   -25.454546,   3.33333325,   -4.5454545
  62504,   -24.545454,   3.33333325,   -4.5454545
  62505,   -23.636364,   3.33333325,   -4.5454545
  62506,   -22.727272,   3.33333325,   -4.5454545
  62507,   -21.818182,   3.33333325,   -4.5454545
  62508,    -20.90909,   3.33333325,   -4.5454545
  62509,    -29.09091,   4.16666651,   -4.5454545
  62510,   -28.181818,   4.16666651,   -4.5454545
  62511,   -27.272728,   4.16666651,   -4.5454545
  62512,   -26.363636,   4.16666651,   -4.5454545
  62513,   -25.454546,   4.16666651,   -4.5454545
  62514,   -24.545454,   4.16666651,   -4.5454545
  62515,   -23.636364,   4.16666651,   -4.5454545
  62516,   -22.727272,   4.16666651,   -4.5454545
  62517,   -21.818182,   4.16666651,   -4.5454545
  62518,    -20.90909,   4.16666651,   -4.5454545
  62519,    -29.09091,           5.,   -4.5454545
  62520,   -28.181818,           5.,   -4.5454545
  62521,   -27.272728,           5.,   -4.5454545
  62522,   -26.363636,           5.,   -4.5454545
  62523,   -25.454546,           5.,   -4.5454545
  62524,   -24.545454,           5.,   -4.5454545
  62525,   -23.636364,           5.,   -4.5454545
  62526,   -22.727272,           5.,   -4.5454545
  62527,   -21.818182,           5.,   -4.5454545
  62528,    -20.90909,           5.,   -4.5454545
  62529,    -29.09091,   5.83333349,   -4.5454545
  62530,   -28.181818,   5.83333349,   -4.5454545
  62531,   -27.272728,   5.83333349,   -4.5454545
  62532,   -26.363636,   5.83333349,   -4.5454545
  62533,   -25.454546,   5.83333349,   -4.5454545
  62534,   -24.545454,   5.83333349,   -4.5454545
  62535,   -23.636364,   5.83333349,   -4.5454545
  62536,   -22.727272,   5.83333349,   -4.5454545
  62537,   -21.818182,   5.83333349,   -4.5454545
  62538,    -20.90909,   5.83333349,   -4.5454545
  62539,    -29.09091,   6.66666651,   -4.5454545
  62540,   -28.181818,   6.66666651,   -4.5454545
  62541,   -27.272728,   6.66666651,   -4.5454545
  62542,   -26.363636,   6.66666651,   -4.5454545
  62543,   -25.454546,   6.66666651,   -4.5454545
  62544,   -24.545454,   6.66666651,   -4.5454545
  62545,   -23.636364,   6.66666651,   -4.5454545
  62546,   -22.727272,   6.66666651,   -4.5454545
  62547,   -21.818182,   6.66666651,   -4.5454545
  62548,    -20.90909,   6.66666651,   -4.5454545
  62549,    -29.09091,          7.5,   -4.5454545
  62550,   -28.181818,          7.5,   -4.5454545
  62551,   -27.272728,          7.5,   -4.5454545
  62552,   -26.363636,          7.5,   -4.5454545
  62553,   -25.454546,          7.5,   -4.5454545
  62554,   -24.545454,          7.5,   -4.5454545
  62555,   -23.636364,          7.5,   -4.5454545
  62556,   -22.727272,          7.5,   -4.5454545
  62557,   -21.818182,          7.5,   -4.5454545
  62558,    -20.90909,          7.5,   -4.5454545
  62559,    -29.09091,   8.33333302,   -4.5454545
  62560,   -28.181818,   8.33333302,   -4.5454545
  62561,   -27.272728,   8.33333302,   -4.5454545
  62562,   -26.363636,   8.33333302,   -4.5454545
  62563,   -25.454546,   8.33333302,   -4.5454545
  62564,   -24.545454,   8.33333302,   -4.5454545
  62565,   -23.636364,   8.33333302,   -4.5454545
  62566,   -22.727272,   8.33333302,   -4.5454545
  62567,   -21.818182,   8.33333302,   -4.5454545
  62568,    -20.90909,   8.33333302,   -4.5454545
  62569,    -29.09091,   9.16666698,   -4.5454545
  62570,   -28.181818,   9.16666698,   -4.5454545
  62571,   -27.272728,   9.16666698,   -4.5454545
  62572,   -26.363636,   9.16666698,   -4.5454545
  62573,   -25.454546,   9.16666698,   -4.5454545
  62574,   -24.545454,   9.16666698,   -4.5454545
  62575,   -23.636364,   9.16666698,   -4.5454545
  62576,   -22.727272,   9.16666698,   -4.5454545
  62577,   -21.818182,   9.16666698,   -4.5454545
  62578,    -20.90909,   9.16666698,   -4.5454545
  62579,    -29.09091,  0.833333313,   -5.4545455
  62580,   -28.181818,  0.833333313,   -5.4545455
  62581,   -27.272728,  0.833333313,   -5.4545455
  62582,   -26.363636,  0.833333313,   -5.4545455
  62583,   -25.454546,  0.833333313,   -5.4545455
  62584,   -24.545454,  0.833333313,   -5.4545455
  62585,   -23.636364,  0.833333313,   -5.4545455
  62586,   -22.727272,  0.833333313,   -5.4545455
  62587,   -21.818182,  0.833333313,   -5.4545455
  62588,    -20.90909,  0.833333313,   -5.4545455
  62589,    -29.09091,   1.66666663,   -5.4545455
  62590,   -28.181818,   1.66666663,   -5.4545455
  62591,   -27.272728,   1.66666663,   -5.4545455
  62592,   -26.363636,   1.66666663,   -5.4545455
  62593,   -25.454546,   1.66666663,   -5.4545455
  62594,   -24.545454,   1.66666663,   -5.4545455
  62595,   -23.636364,   1.66666663,   -5.4545455
  62596,   -22.727272,   1.66666663,   -5.4545455
  62597,   -21.818182,   1.66666663,   -5.4545455
  62598,    -20.90909,   1.66666663,   -5.4545455
  62599,    -29.09091,          2.5,   -5.4545455
  62600,   -28.181818,          2.5,   -5.4545455
  62601,   -27.272728,          2.5,   -5.4545455
  62602,   -26.363636,          2.5,   -5.4545455
  62603,   -25.454546,          2.5,   -5.4545455
  62604,   -24.545454,          2.5,   -5.4545455
  62605,   -23.636364,          2.5,   -5.4545455
  62606,   -22.727272,          2.5,   -5.4545455
  62607,   -21.818182,          2.5,   -5.4545455
  62608,    -20.90909,          2.5,   -5.4545455
  62609,    -29.09091,   3.33333325,   -5.4545455
  62610,   -28.181818,   3.33333325,   -5.4545455
  62611,   -27.272728,   3.33333325,   -5.4545455
  62612,   -26.363636,   3.33333325,   -5.4545455
  62613,   -25.454546,   3.33333325,   -5.4545455
  62614,   -24.545454,   3.33333325,   -5.4545455
  62615,   -23.636364,   3.33333325,   -5.4545455
  62616,   -22.727272,   3.33333325,   -5.4545455
  62617,   -21.818182,   3.33333325,   -5.4545455
  62618,    -20.90909,   3.33333325,   -5.4545455
  62619,    -29.09091,   4.16666651,   -5.4545455
  62620,   -28.181818,   4.16666651,   -5.4545455
  62621,   -27.272728,   4.16666651,   -5.4545455
  62622,   -26.363636,   4.16666651,   -5.4545455
  62623,   -25.454546,   4.16666651,   -5.4545455
  62624,   -24.545454,   4.16666651,   -5.4545455
  62625,   -23.636364,   4.16666651,   -5.4545455
  62626,   -22.727272,   4.16666651,   -5.4545455
  62627,   -21.818182,   4.16666651,   -5.4545455
  62628,    -20.90909,   4.16666651,   -5.4545455
  62629,    -29.09091,           5.,   -5.4545455
  62630,   -28.181818,           5.,   -5.4545455
  62631,   -27.272728,           5.,   -5.4545455
  62632,   -26.363636,           5.,   -5.4545455
  62633,   -25.454546,           5.,   -5.4545455
  62634,   -24.545454,           5.,   -5.4545455
  62635,   -23.636364,           5.,   -5.4545455
  62636,   -22.727272,           5.,   -5.4545455
  62637,   -21.818182,           5.,   -5.4545455
  62638,    -20.90909,           5.,   -5.4545455
  62639,    -29.09091,   5.83333349,   -5.4545455
  62640,   -28.181818,   5.83333349,   -5.4545455
  62641,   -27.272728,   5.83333349,   -5.4545455
  62642,   -26.363636,   5.83333349,   -5.4545455
  62643,   -25.454546,   5.83333349,   -5.4545455
  62644,   -24.545454,   5.83333349,   -5.4545455
  62645,   -23.636364,   5.83333349,   -5.4545455
  62646,   -22.727272,   5.83333349,   -5.4545455
  62647,   -21.818182,   5.83333349,   -5.4545455
  62648,    -20.90909,   5.83333349,   -5.4545455
  62649,    -29.09091,   6.66666651,   -5.4545455
  62650,   -28.181818,   6.66666651,   -5.4545455
  62651,   -27.272728,   6.66666651,   -5.4545455
  62652,   -26.363636,   6.66666651,   -5.4545455
  62653,   -25.454546,   6.66666651,   -5.4545455
  62654,   -24.545454,   6.66666651,   -5.4545455
  62655,   -23.636364,   6.66666651,   -5.4545455
  62656,   -22.727272,   6.66666651,   -5.4545455
  62657,   -21.818182,   6.66666651,   -5.4545455
  62658,    -20.90909,   6.66666651,   -5.4545455
  62659,    -29.09091,          7.5,   -5.4545455
  62660,   -28.181818,          7.5,   -5.4545455
  62661,   -27.272728,          7.5,   -5.4545455
  62662,   -26.363636,          7.5,   -5.4545455
  62663,   -25.454546,          7.5,   -5.4545455
  62664,   -24.545454,          7.5,   -5.4545455
  62665,   -23.636364,          7.5,   -5.4545455
  62666,   -22.727272,          7.5,   -5.4545455
  62667,   -21.818182,          7.5,   -5.4545455
  62668,    -20.90909,          7.5,   -5.4545455
  62669,    -29.09091,   8.33333302,   -5.4545455
  62670,   -28.181818,   8.33333302,   -5.4545455
  62671,   -27.272728,   8.33333302,   -5.4545455
  62672,   -26.363636,   8.33333302,   -5.4545455
  62673,   -25.454546,   8.33333302,   -5.4545455
  62674,   -24.545454,   8.33333302,   -5.4545455
  62675,   -23.636364,   8.33333302,   -5.4545455
  62676,   -22.727272,   8.33333302,   -5.4545455
  62677,   -21.818182,   8.33333302,   -5.4545455
  62678,    -20.90909,   8.33333302,   -5.4545455
  62679,    -29.09091,   9.16666698,   -5.4545455
  62680,   -28.181818,   9.16666698,   -5.4545455
  62681,   -27.272728,   9.16666698,   -5.4545455
  62682,   -26.363636,   9.16666698,   -5.4545455
  62683,   -25.454546,   9.16666698,   -5.4545455
  62684,   -24.545454,   9.16666698,   -5.4545455
  62685,   -23.636364,   9.16666698,   -5.4545455
  62686,   -22.727272,   9.16666698,   -5.4545455
  62687,   -21.818182,   9.16666698,   -5.4545455
  62688,    -20.90909,   9.16666698,   -5.4545455
  62689,    -29.09091,  0.833333313,  -6.36363649
  62690,   -28.181818,  0.833333313,  -6.36363649
  62691,   -27.272728,  0.833333313,  -6.36363649
  62692,   -26.363636,  0.833333313,  -6.36363649
  62693,   -25.454546,  0.833333313,  -6.36363649
  62694,   -24.545454,  0.833333313,  -6.36363649
  62695,   -23.636364,  0.833333313,  -6.36363649
  62696,   -22.727272,  0.833333313,  -6.36363649
  62697,   -21.818182,  0.833333313,  -6.36363649
  62698,    -20.90909,  0.833333313,  -6.36363649
  62699,    -29.09091,   1.66666663,  -6.36363649
  62700,   -28.181818,   1.66666663,  -6.36363649
  62701,   -27.272728,   1.66666663,  -6.36363649
  62702,   -26.363636,   1.66666663,  -6.36363649
  62703,   -25.454546,   1.66666663,  -6.36363649
  62704,   -24.545454,   1.66666663,  -6.36363649
  62705,   -23.636364,   1.66666663,  -6.36363649
  62706,   -22.727272,   1.66666663,  -6.36363649
  62707,   -21.818182,   1.66666663,  -6.36363649
  62708,    -20.90909,   1.66666663,  -6.36363649
  62709,    -29.09091,          2.5,  -6.36363649
  62710,   -28.181818,          2.5,  -6.36363649
  62711,   -27.272728,          2.5,  -6.36363649
  62712,   -26.363636,          2.5,  -6.36363649
  62713,   -25.454546,          2.5,  -6.36363649
  62714,   -24.545454,          2.5,  -6.36363649
  62715,   -23.636364,          2.5,  -6.36363649
  62716,   -22.727272,          2.5,  -6.36363649
  62717,   -21.818182,          2.5,  -6.36363649
  62718,    -20.90909,          2.5,  -6.36363649
  62719,    -29.09091,   3.33333325,  -6.36363649
  62720,   -28.181818,   3.33333325,  -6.36363649
  62721,   -27.272728,   3.33333325,  -6.36363649
  62722,   -26.363636,   3.33333325,  -6.36363649
  62723,   -25.454546,   3.33333325,  -6.36363649
  62724,   -24.545454,   3.33333325,  -6.36363649
  62725,   -23.636364,   3.33333325,  -6.36363649
  62726,   -22.727272,   3.33333325,  -6.36363649
  62727,   -21.818182,   3.33333325,  -6.36363649
  62728,    -20.90909,   3.33333325,  -6.36363649
  62729,    -29.09091,   4.16666651,  -6.36363649
  62730,   -28.181818,   4.16666651,  -6.36363649
  62731,   -27.272728,   4.16666651,  -6.36363649
  62732,   -26.363636,   4.16666651,  -6.36363649
  62733,   -25.454546,   4.16666651,  -6.36363649
  62734,   -24.545454,   4.16666651,  -6.36363649
  62735,   -23.636364,   4.16666651,  -6.36363649
  62736,   -22.727272,   4.16666651,  -6.36363649
  62737,   -21.818182,   4.16666651,  -6.36363649
  62738,    -20.90909,   4.16666651,  -6.36363649
  62739,    -29.09091,           5.,  -6.36363649
  62740,   -28.181818,           5.,  -6.36363649
  62741,   -27.272728,           5.,  -6.36363649
  62742,   -26.363636,           5.,  -6.36363649
  62743,   -25.454546,           5.,  -6.36363649
  62744,   -24.545454,           5.,  -6.36363649
  62745,   -23.636364,           5.,  -6.36363649
  62746,   -22.727272,           5.,  -6.36363649
  62747,   -21.818182,           5.,  -6.36363649
  62748,    -20.90909,           5.,  -6.36363649
  62749,    -29.09091,   5.83333349,  -6.36363649
  62750,   -28.181818,   5.83333349,  -6.36363649
  62751,   -27.272728,   5.83333349,  -6.36363649
  62752,   -26.363636,   5.83333349,  -6.36363649
  62753,   -25.454546,   5.83333349,  -6.36363649
  62754,   -24.545454,   5.83333349,  -6.36363649
  62755,   -23.636364,   5.83333349,  -6.36363649
  62756,   -22.727272,   5.83333349,  -6.36363649
  62757,   -21.818182,   5.83333349,  -6.36363649
  62758,    -20.90909,   5.83333349,  -6.36363649
  62759,    -29.09091,   6.66666651,  -6.36363649
  62760,   -28.181818,   6.66666651,  -6.36363649
  62761,   -27.272728,   6.66666651,  -6.36363649
  62762,   -26.363636,   6.66666651,  -6.36363649
  62763,   -25.454546,   6.66666651,  -6.36363649
  62764,   -24.545454,   6.66666651,  -6.36363649
  62765,   -23.636364,   6.66666651,  -6.36363649
  62766,   -22.727272,   6.66666651,  -6.36363649
  62767,   -21.818182,   6.66666651,  -6.36363649
  62768,    -20.90909,   6.66666651,  -6.36363649
  62769,    -29.09091,          7.5,  -6.36363649
  62770,   -28.181818,          7.5,  -6.36363649
  62771,   -27.272728,          7.5,  -6.36363649
  62772,   -26.363636,          7.5,  -6.36363649
  62773,   -25.454546,          7.5,  -6.36363649
  62774,   -24.545454,          7.5,  -6.36363649
  62775,   -23.636364,          7.5,  -6.36363649
  62776,   -22.727272,          7.5,  -6.36363649
  62777,   -21.818182,          7.5,  -6.36363649
  62778,    -20.90909,          7.5,  -6.36363649
  62779,    -29.09091,   8.33333302,  -6.36363649
  62780,   -28.181818,   8.33333302,  -6.36363649
  62781,   -27.272728,   8.33333302,  -6.36363649
  62782,   -26.363636,   8.33333302,  -6.36363649
  62783,   -25.454546,   8.33333302,  -6.36363649
  62784,   -24.545454,   8.33333302,  -6.36363649
  62785,   -23.636364,   8.33333302,  -6.36363649
  62786,   -22.727272,   8.33333302,  -6.36363649
  62787,   -21.818182,   8.33333302,  -6.36363649
  62788,    -20.90909,   8.33333302,  -6.36363649
  62789,    -29.09091,   9.16666698,  -6.36363649
  62790,   -28.181818,   9.16666698,  -6.36363649
  62791,   -27.272728,   9.16666698,  -6.36363649
  62792,   -26.363636,   9.16666698,  -6.36363649
  62793,   -25.454546,   9.16666698,  -6.36363649
  62794,   -24.545454,   9.16666698,  -6.36363649
  62795,   -23.636364,   9.16666698,  -6.36363649
  62796,   -22.727272,   9.16666698,  -6.36363649
  62797,   -21.818182,   9.16666698,  -6.36363649
  62798,    -20.90909,   9.16666698,  -6.36363649
  62799,    -29.09091,  0.833333313,  -7.27272749
  62800,   -28.181818,  0.833333313,  -7.27272749
  62801,   -27.272728,  0.833333313,  -7.27272749
  62802,   -26.363636,  0.833333313,  -7.27272749
  62803,   -25.454546,  0.833333313,  -7.27272749
  62804,   -24.545454,  0.833333313,  -7.27272749
  62805,   -23.636364,  0.833333313,  -7.27272749
  62806,   -22.727272,  0.833333313,  -7.27272749
  62807,   -21.818182,  0.833333313,  -7.27272749
  62808,    -20.90909,  0.833333313,  -7.27272749
  62809,    -29.09091,   1.66666663,  -7.27272749
  62810,   -28.181818,   1.66666663,  -7.27272749
  62811,   -27.272728,   1.66666663,  -7.27272749
  62812,   -26.363636,   1.66666663,  -7.27272749
  62813,   -25.454546,   1.66666663,  -7.27272749
  62814,   -24.545454,   1.66666663,  -7.27272749
  62815,   -23.636364,   1.66666663,  -7.27272749
  62816,   -22.727272,   1.66666663,  -7.27272749
  62817,   -21.818182,   1.66666663,  -7.27272749
  62818,    -20.90909,   1.66666663,  -7.27272749
  62819,    -29.09091,          2.5,  -7.27272749
  62820,   -28.181818,          2.5,  -7.27272749
  62821,   -27.272728,          2.5,  -7.27272749
  62822,   -26.363636,          2.5,  -7.27272749
  62823,   -25.454546,          2.5,  -7.27272749
  62824,   -24.545454,          2.5,  -7.27272749
  62825,   -23.636364,          2.5,  -7.27272749
  62826,   -22.727272,          2.5,  -7.27272749
  62827,   -21.818182,          2.5,  -7.27272749
  62828,    -20.90909,          2.5,  -7.27272749
  62829,    -29.09091,   3.33333325,  -7.27272749
  62830,   -28.181818,   3.33333325,  -7.27272749
  62831,   -27.272728,   3.33333325,  -7.27272749
  62832,   -26.363636,   3.33333325,  -7.27272749
  62833,   -25.454546,   3.33333325,  -7.27272749
  62834,   -24.545454,   3.33333325,  -7.27272749
  62835,   -23.636364,   3.33333325,  -7.27272749
  62836,   -22.727272,   3.33333325,  -7.27272749
  62837,   -21.818182,   3.33333325,  -7.27272749
  62838,    -20.90909,   3.33333325,  -7.27272749
  62839,    -29.09091,   4.16666651,  -7.27272749
  62840,   -28.181818,   4.16666651,  -7.27272749
  62841,   -27.272728,   4.16666651,  -7.27272749
  62842,   -26.363636,   4.16666651,  -7.27272749
  62843,   -25.454546,   4.16666651,  -7.27272749
  62844,   -24.545454,   4.16666651,  -7.27272749
  62845,   -23.636364,   4.16666651,  -7.27272749
  62846,   -22.727272,   4.16666651,  -7.27272749
  62847,   -21.818182,   4.16666651,  -7.27272749
  62848,    -20.90909,   4.16666651,  -7.27272749
  62849,    -29.09091,           5.,  -7.27272749
  62850,   -28.181818,           5.,  -7.27272749
  62851,   -27.272728,           5.,  -7.27272749
  62852,   -26.363636,           5.,  -7.27272749
  62853,   -25.454546,           5.,  -7.27272749
  62854,   -24.545454,           5.,  -7.27272749
  62855,   -23.636364,           5.,  -7.27272749
  62856,   -22.727272,           5.,  -7.27272749
  62857,   -21.818182,           5.,  -7.27272749
  62858,    -20.90909,           5.,  -7.27272749
  62859,    -29.09091,   5.83333349,  -7.27272749
  62860,   -28.181818,   5.83333349,  -7.27272749
  62861,   -27.272728,   5.83333349,  -7.27272749
  62862,   -26.363636,   5.83333349,  -7.27272749
  62863,   -25.454546,   5.83333349,  -7.27272749
  62864,   -24.545454,   5.83333349,  -7.27272749
  62865,   -23.636364,   5.83333349,  -7.27272749
  62866,   -22.727272,   5.83333349,  -7.27272749
  62867,   -21.818182,   5.83333349,  -7.27272749
  62868,    -20.90909,   5.83333349,  -7.27272749
  62869,    -29.09091,   6.66666651,  -7.27272749
  62870,   -28.181818,   6.66666651,  -7.27272749
  62871,   -27.272728,   6.66666651,  -7.27272749
  62872,   -26.363636,   6.66666651,  -7.27272749
  62873,   -25.454546,   6.66666651,  -7.27272749
  62874,   -24.545454,   6.66666651,  -7.27272749
  62875,   -23.636364,   6.66666651,  -7.27272749
  62876,   -22.727272,   6.66666651,  -7.27272749
  62877,   -21.818182,   6.66666651,  -7.27272749
  62878,    -20.90909,   6.66666651,  -7.27272749
  62879,    -29.09091,          7.5,  -7.27272749
  62880,   -28.181818,          7.5,  -7.27272749
  62881,   -27.272728,          7.5,  -7.27272749
  62882,   -26.363636,          7.5,  -7.27272749
  62883,   -25.454546,          7.5,  -7.27272749
  62884,   -24.545454,          7.5,  -7.27272749
  62885,   -23.636364,          7.5,  -7.27272749
  62886,   -22.727272,          7.5,  -7.27272749
  62887,   -21.818182,          7.5,  -7.27272749
  62888,    -20.90909,          7.5,  -7.27272749
  62889,    -29.09091,   8.33333302,  -7.27272749
  62890,   -28.181818,   8.33333302,  -7.27272749
  62891,   -27.272728,   8.33333302,  -7.27272749
  62892,   -26.363636,   8.33333302,  -7.27272749
  62893,   -25.454546,   8.33333302,  -7.27272749
  62894,   -24.545454,   8.33333302,  -7.27272749
  62895,   -23.636364,   8.33333302,  -7.27272749
  62896,   -22.727272,   8.33333302,  -7.27272749
  62897,   -21.818182,   8.33333302,  -7.27272749
  62898,    -20.90909,   8.33333302,  -7.27272749
  62899,    -29.09091,   9.16666698,  -7.27272749
  62900,   -28.181818,   9.16666698,  -7.27272749
  62901,   -27.272728,   9.16666698,  -7.27272749
  62902,   -26.363636,   9.16666698,  -7.27272749
  62903,   -25.454546,   9.16666698,  -7.27272749
  62904,   -24.545454,   9.16666698,  -7.27272749
  62905,   -23.636364,   9.16666698,  -7.27272749
  62906,   -22.727272,   9.16666698,  -7.27272749
  62907,   -21.818182,   9.16666698,  -7.27272749
  62908,    -20.90909,   9.16666698,  -7.27272749
  62909,    -29.09091,  0.833333313,  -8.18181801
  62910,   -28.181818,  0.833333313,  -8.18181801
  62911,   -27.272728,  0.833333313,  -8.18181801
  62912,   -26.363636,  0.833333313,  -8.18181801
  62913,   -25.454546,  0.833333313,  -8.18181801
  62914,   -24.545454,  0.833333313,  -8.18181801
  62915,   -23.636364,  0.833333313,  -8.18181801
  62916,   -22.727272,  0.833333313,  -8.18181801
  62917,   -21.818182,  0.833333313,  -8.18181801
  62918,    -20.90909,  0.833333313,  -8.18181801
  62919,    -29.09091,   1.66666663,  -8.18181801
  62920,   -28.181818,   1.66666663,  -8.18181801
  62921,   -27.272728,   1.66666663,  -8.18181801
  62922,   -26.363636,   1.66666663,  -8.18181801
  62923,   -25.454546,   1.66666663,  -8.18181801
  62924,   -24.545454,   1.66666663,  -8.18181801
  62925,   -23.636364,   1.66666663,  -8.18181801
  62926,   -22.727272,   1.66666663,  -8.18181801
  62927,   -21.818182,   1.66666663,  -8.18181801
  62928,    -20.90909,   1.66666663,  -8.18181801
  62929,    -29.09091,          2.5,  -8.18181801
  62930,   -28.181818,          2.5,  -8.18181801
  62931,   -27.272728,          2.5,  -8.18181801
  62932,   -26.363636,          2.5,  -8.18181801
  62933,   -25.454546,          2.5,  -8.18181801
  62934,   -24.545454,          2.5,  -8.18181801
  62935,   -23.636364,          2.5,  -8.18181801
  62936,   -22.727272,          2.5,  -8.18181801
  62937,   -21.818182,          2.5,  -8.18181801
  62938,    -20.90909,          2.5,  -8.18181801
  62939,    -29.09091,   3.33333325,  -8.18181801
  62940,   -28.181818,   3.33333325,  -8.18181801
  62941,   -27.272728,   3.33333325,  -8.18181801
  62942,   -26.363636,   3.33333325,  -8.18181801
  62943,   -25.454546,   3.33333325,  -8.18181801
  62944,   -24.545454,   3.33333325,  -8.18181801
  62945,   -23.636364,   3.33333325,  -8.18181801
  62946,   -22.727272,   3.33333325,  -8.18181801
  62947,   -21.818182,   3.33333325,  -8.18181801
  62948,    -20.90909,   3.33333325,  -8.18181801
  62949,    -29.09091,   4.16666651,  -8.18181801
  62950,   -28.181818,   4.16666651,  -8.18181801
  62951,   -27.272728,   4.16666651,  -8.18181801
  62952,   -26.363636,   4.16666651,  -8.18181801
  62953,   -25.454546,   4.16666651,  -8.18181801
  62954,   -24.545454,   4.16666651,  -8.18181801
  62955,   -23.636364,   4.16666651,  -8.18181801
  62956,   -22.727272,   4.16666651,  -8.18181801
  62957,   -21.818182,   4.16666651,  -8.18181801
  62958,    -20.90909,   4.16666651,  -8.18181801
  62959,    -29.09091,           5.,  -8.18181801
  62960,   -28.181818,           5.,  -8.18181801
  62961,   -27.272728,           5.,  -8.18181801
  62962,   -26.363636,           5.,  -8.18181801
  62963,   -25.454546,           5.,  -8.18181801
  62964,   -24.545454,           5.,  -8.18181801
  62965,   -23.636364,           5.,  -8.18181801
  62966,   -22.727272,           5.,  -8.18181801
  62967,   -21.818182,           5.,  -8.18181801
  62968,    -20.90909,           5.,  -8.18181801
  62969,    -29.09091,   5.83333349,  -8.18181801
  62970,   -28.181818,   5.83333349,  -8.18181801
  62971,   -27.272728,   5.83333349,  -8.18181801
  62972,   -26.363636,   5.83333349,  -8.18181801
  62973,   -25.454546,   5.83333349,  -8.18181801
  62974,   -24.545454,   5.83333349,  -8.18181801
  62975,   -23.636364,   5.83333349,  -8.18181801
  62976,   -22.727272,   5.83333349,  -8.18181801
  62977,   -21.818182,   5.83333349,  -8.18181801
  62978,    -20.90909,   5.83333349,  -8.18181801
  62979,    -29.09091,   6.66666651,  -8.18181801
  62980,   -28.181818,   6.66666651,  -8.18181801
  62981,   -27.272728,   6.66666651,  -8.18181801
  62982,   -26.363636,   6.66666651,  -8.18181801
  62983,   -25.454546,   6.66666651,  -8.18181801
  62984,   -24.545454,   6.66666651,  -8.18181801
  62985,   -23.636364,   6.66666651,  -8.18181801
  62986,   -22.727272,   6.66666651,  -8.18181801
  62987,   -21.818182,   6.66666651,  -8.18181801
  62988,    -20.90909,   6.66666651,  -8.18181801
  62989,    -29.09091,          7.5,  -8.18181801
  62990,   -28.181818,          7.5,  -8.18181801
  62991,   -27.272728,          7.5,  -8.18181801
  62992,   -26.363636,          7.5,  -8.18181801
  62993,   -25.454546,          7.5,  -8.18181801
  62994,   -24.545454,          7.5,  -8.18181801
  62995,   -23.636364,          7.5,  -8.18181801
  62996,   -22.727272,          7.5,  -8.18181801
  62997,   -21.818182,          7.5,  -8.18181801
  62998,    -20.90909,          7.5,  -8.18181801
  62999,    -29.09091,   8.33333302,  -8.18181801
  63000,   -28.181818,   8.33333302,  -8.18181801
  63001,   -27.272728,   8.33333302,  -8.18181801
  63002,   -26.363636,   8.33333302,  -8.18181801
  63003,   -25.454546,   8.33333302,  -8.18181801
  63004,   -24.545454,   8.33333302,  -8.18181801
  63005,   -23.636364,   8.33333302,  -8.18181801
  63006,   -22.727272,   8.33333302,  -8.18181801
  63007,   -21.818182,   8.33333302,  -8.18181801
  63008,    -20.90909,   8.33333302,  -8.18181801
  63009,    -29.09091,   9.16666698,  -8.18181801
  63010,   -28.181818,   9.16666698,  -8.18181801
  63011,   -27.272728,   9.16666698,  -8.18181801
  63012,   -26.363636,   9.16666698,  -8.18181801
  63013,   -25.454546,   9.16666698,  -8.18181801
  63014,   -24.545454,   9.16666698,  -8.18181801
  63015,   -23.636364,   9.16666698,  -8.18181801
  63016,   -22.727272,   9.16666698,  -8.18181801
  63017,   -21.818182,   9.16666698,  -8.18181801
  63018,    -20.90909,   9.16666698,  -8.18181801
  63019,    -29.09091,  0.833333313,    -9.090909
  63020,   -28.181818,  0.833333313,    -9.090909
  63021,   -27.272728,  0.833333313,    -9.090909
  63022,   -26.363636,  0.833333313,    -9.090909
  63023,   -25.454546,  0.833333313,    -9.090909
  63024,   -24.545454,  0.833333313,    -9.090909
  63025,   -23.636364,  0.833333313,    -9.090909
  63026,   -22.727272,  0.833333313,    -9.090909
  63027,   -21.818182,  0.833333313,    -9.090909
  63028,    -20.90909,  0.833333313,    -9.090909
  63029,    -29.09091,   1.66666663,    -9.090909
  63030,   -28.181818,   1.66666663,    -9.090909
  63031,   -27.272728,   1.66666663,    -9.090909
  63032,   -26.363636,   1.66666663,    -9.090909
  63033,   -25.454546,   1.66666663,    -9.090909
  63034,   -24.545454,   1.66666663,    -9.090909
  63035,   -23.636364,   1.66666663,    -9.090909
  63036,   -22.727272,   1.66666663,    -9.090909
  63037,   -21.818182,   1.66666663,    -9.090909
  63038,    -20.90909,   1.66666663,    -9.090909
  63039,    -29.09091,          2.5,    -9.090909
  63040,   -28.181818,          2.5,    -9.090909
  63041,   -27.272728,          2.5,    -9.090909
  63042,   -26.363636,          2.5,    -9.090909
  63043,   -25.454546,          2.5,    -9.090909
  63044,   -24.545454,          2.5,    -9.090909
  63045,   -23.636364,          2.5,    -9.090909
  63046,   -22.727272,          2.5,    -9.090909
  63047,   -21.818182,          2.5,    -9.090909
  63048,    -20.90909,          2.5,    -9.090909
  63049,    -29.09091,   3.33333325,    -9.090909
  63050,   -28.181818,   3.33333325,    -9.090909
  63051,   -27.272728,   3.33333325,    -9.090909
  63052,   -26.363636,   3.33333325,    -9.090909
  63053,   -25.454546,   3.33333325,    -9.090909
  63054,   -24.545454,   3.33333325,    -9.090909
  63055,   -23.636364,   3.33333325,    -9.090909
  63056,   -22.727272,   3.33333325,    -9.090909
  63057,   -21.818182,   3.33333325,    -9.090909
  63058,    -20.90909,   3.33333325,    -9.090909
  63059,    -29.09091,   4.16666651,    -9.090909
  63060,   -28.181818,   4.16666651,    -9.090909
  63061,   -27.272728,   4.16666651,    -9.090909
  63062,   -26.363636,   4.16666651,    -9.090909
  63063,   -25.454546,   4.16666651,    -9.090909
  63064,   -24.545454,   4.16666651,    -9.090909
  63065,   -23.636364,   4.16666651,    -9.090909
  63066,   -22.727272,   4.16666651,    -9.090909
  63067,   -21.818182,   4.16666651,    -9.090909
  63068,    -20.90909,   4.16666651,    -9.090909
  63069,    -29.09091,           5.,    -9.090909
  63070,   -28.181818,           5.,    -9.090909
  63071,   -27.272728,           5.,    -9.090909
  63072,   -26.363636,           5.,    -9.090909
  63073,   -25.454546,           5.,    -9.090909
  63074,   -24.545454,           5.,    -9.090909
  63075,   -23.636364,           5.,    -9.090909
  63076,   -22.727272,           5.,    -9.090909
  63077,   -21.818182,           5.,    -9.090909
  63078,    -20.90909,           5.,    -9.090909
  63079,    -29.09091,   5.83333349,    -9.090909
  63080,   -28.181818,   5.83333349,    -9.090909
  63081,   -27.272728,   5.83333349,    -9.090909
  63082,   -26.363636,   5.83333349,    -9.090909
  63083,   -25.454546,   5.83333349,    -9.090909
  63084,   -24.545454,   5.83333349,    -9.090909
  63085,   -23.636364,   5.83333349,    -9.090909
  63086,   -22.727272,   5.83333349,    -9.090909
  63087,   -21.818182,   5.83333349,    -9.090909
  63088,    -20.90909,   5.83333349,    -9.090909
  63089,    -29.09091,   6.66666651,    -9.090909
  63090,   -28.181818,   6.66666651,    -9.090909
  63091,   -27.272728,   6.66666651,    -9.090909
  63092,   -26.363636,   6.66666651,    -9.090909
  63093,   -25.454546,   6.66666651,    -9.090909
  63094,   -24.545454,   6.66666651,    -9.090909
  63095,   -23.636364,   6.66666651,    -9.090909
  63096,   -22.727272,   6.66666651,    -9.090909
  63097,   -21.818182,   6.66666651,    -9.090909
  63098,    -20.90909,   6.66666651,    -9.090909
  63099,    -29.09091,          7.5,    -9.090909
  63100,   -28.181818,          7.5,    -9.090909
  63101,   -27.272728,          7.5,    -9.090909
  63102,   -26.363636,          7.5,    -9.090909
  63103,   -25.454546,          7.5,    -9.090909
  63104,   -24.545454,          7.5,    -9.090909
  63105,   -23.636364,          7.5,    -9.090909
  63106,   -22.727272,          7.5,    -9.090909
  63107,   -21.818182,          7.5,    -9.090909
  63108,    -20.90909,          7.5,    -9.090909
  63109,    -29.09091,   8.33333302,    -9.090909
  63110,   -28.181818,   8.33333302,    -9.090909
  63111,   -27.272728,   8.33333302,    -9.090909
  63112,   -26.363636,   8.33333302,    -9.090909
  63113,   -25.454546,   8.33333302,    -9.090909
  63114,   -24.545454,   8.33333302,    -9.090909
  63115,   -23.636364,   8.33333302,    -9.090909
  63116,   -22.727272,   8.33333302,    -9.090909
  63117,   -21.818182,   8.33333302,    -9.090909
  63118,    -20.90909,   8.33333302,    -9.090909
  63119,    -29.09091,   9.16666698,    -9.090909
  63120,   -28.181818,   9.16666698,    -9.090909
  63121,   -27.272728,   9.16666698,    -9.090909
  63122,   -26.363636,   9.16666698,    -9.090909
  63123,   -25.454546,   9.16666698,    -9.090909
  63124,   -24.545454,   9.16666698,    -9.090909
  63125,   -23.636364,   9.16666698,    -9.090909
  63126,   -22.727272,   9.16666698,    -9.090909
  63127,   -21.818182,   9.16666698,    -9.090909
  63128,    -20.90909,   9.16666698,    -9.090909
  63129,  -27.6685238,   14.3461752,  -9.53731346
  63130,  -27.0755196,   14.3461752,  -9.53731346
  63131,  -26.4825134,   14.3461752,  -9.53731346
  63132,  -25.8895092,   14.3461752,  -9.53731346
  63133,  -25.2965031,   14.3461752,  -9.53731346
  63134,  -24.7034969,   14.3461742,  -9.53731346
  63135,  -24.1104908,   14.3461742,  -9.53731346
  63136,  -23.5174866,   14.3461742,  -9.53731346
  63137,  -22.9244804,   14.3461742,  -9.53731346
  63138,  -22.3314762,   14.3461742,  -9.53731346
  63139,  -27.8816261,   13.6950302,  -9.51302719
  63140,  -27.2412643,   13.6950302,  -9.51302719
  63141,  -26.6009045,   13.6950302,  -9.51302719
  63142,  -25.9605427,   13.6950302,  -9.51302719
  63143,  -25.3201809,   13.6950302,  -9.51302719
  63144,  -24.6798191,   13.6950293,  -9.51302719
  63145,  -24.0394573,   13.6950293,  -9.51302719
  63146,  -23.3990955,   13.6950293,  -9.51302719
  63147,  -22.7587357,   13.6950293,  -9.51302719
  63148,  -22.1183739,   13.6950293,  -9.51302719
  63149,  -28.0929527,   13.0493116,  -9.47304153
  63150,  -27.4056301,   13.0493116,  -9.47304153
  63151,  -26.7183075,   13.0493116,  -9.47304153
  63152,  -26.0309849,   13.0493116,  -9.47304153
  63153,  -25.3436623,   13.0493116,  -9.47304153
  63154,  -24.6563377,   13.0493116,  -9.47304153
  63155,  -23.9690151,   13.0493116,  -9.47304153
  63156,  -23.2816925,   13.0493116,  -9.47304153
  63157,  -22.5943699,   13.0493116,  -9.47304153
  63158,  -21.9070473,   13.0493116,  -9.47304153
  63159,  -28.3015709,   12.4118662,  -9.41821671
  63160,  -27.5678883,   12.4118662,  -9.41821671
  63161,  -26.8342056,   12.4118662,  -9.41821671
  63162,  -26.1005249,   12.4118662,  -9.41821671
  63163,  -25.3668404,   12.4118662,  -9.41821671
  63164,  -24.6331596,   12.4118662,  -9.41821671
  63165,  -23.8994751,   12.4118662,  -9.41821671
  63166,  -23.1657944,   12.4118662,  -9.41821671
  63167,  -22.4321117,   12.4118662,  -9.41821671
  63168,  -21.6984291,   12.4118662,  -9.41821671
  63169,  -28.5065269,   11.7856054,  -9.34998417
  63170,  -27.7273006,   11.7856054,  -9.34998417
  63171,  -26.9480705,   11.7856054,  -9.34998417
  63172,  -26.1688423,   11.7856054,  -9.34998417
  63173,  -25.3896141,   11.7856054,  -9.34998417
  63174,  -24.6103859,   11.7856054,  -9.34998417
  63175,  -23.8311577,   11.7856054,  -9.34998417
  63176,  -23.0519295,   11.7856054,  -9.34998417
  63177,  -22.2726994,   11.7856054,  -9.34998417
  63178,  -21.4934731,   11.7856054,  -9.34998417
  63179,  -28.7069016,    11.173358,  -9.27052689
  63180,  -27.8831444,    11.173358,  -9.27052689
  63181,  -27.0593891,    11.173358,  -9.27052689
  63182,  -26.2356339,    11.173358,  -9.27052689
  63183,  -25.4118767,    11.173358,  -9.27052689
  63184,  -24.5881233,    11.173358,  -9.27052689
  63185,  -23.7643661,    11.173358,  -9.27052689
  63186,  -22.9406109,    11.173358,  -9.27052689
  63187,  -22.1168556,    11.173358,  -9.27052689
  63188,  -21.2930984,    11.173358,  -9.27052689
  63189,  -28.9018822,   10.5775852,  -9.18288708
  63190,  -28.0347977,   10.5775852,  -9.18288708
  63191,  -27.1677113,   10.5775852,  -9.18288708
  63192,  -26.3006268,   10.5775852,  -9.18288708
  63193,  -25.4335423,   10.5775852,  -9.18288708
  63194,  -24.5664577,   10.5775852,  -9.18288708
  63195,  -23.6993732,   10.5775852,  -9.18288708
  63196,  -22.8322887,   10.5775852,  -9.18288708
  63197,  -21.9652023,   10.5775852,  -9.18288708
  63198,  -21.0981178,   10.5775852,  -9.18288708
  63199,  -27.6779575,   14.3173494,  -9.07462692
  63200,  -27.0828571,   14.3173494,  -9.07462692
  63201,  -26.4877548,   14.3173494,  -9.07462692
  63202,  -25.8926525,   14.3173494,  -9.07462692
  63203,  -25.2975502,   14.3173494,  -9.07462692
  63204,  -24.7024498,   14.3173494,  -9.07462692
  63205,  -24.1073475,   14.3173494,  -9.07462692
  63206,  -23.5122452,   14.3173494,  -9.07462692
  63207,  -22.9171429,   14.3173494,  -9.07462692
  63208,  -22.3220425,   14.3173494,  -9.07462692
  63209,  -27.8996162,   13.6400595,  -9.02605343
  63210,  -27.2552567,   13.6400595,  -9.02605343
  63211,   -26.610899,   13.6400595,  -9.02605343
  63212,  -25.9665394,   13.6400595,  -9.02605343
  63213,  -25.3221798,   13.6400595,  -9.02605343
  63214,  -24.6778202,   13.6400595,  -9.02605343
  63215,  -24.0334606,   13.6400595,  -9.02605343
  63216,   -23.389101,   13.6400595,  -9.02605343
  63217,  -22.7447433,   13.6400595,  -9.02605343
  63218,  -22.1003838,   13.6400595,  -9.02605343
  63219,  -28.1177235,   12.9736223,  -8.94608307
  63220,  -27.4248962,   12.9736223,  -8.94608307
  63221,   -26.732069,   12.9736223,  -8.94608307
  63222,  -26.0392418,   12.9736223,  -8.94608307
  63223,  -25.3464146,   12.9736223,  -8.94608307
  63224,  -24.6535854,   12.9736223,  -8.94608307
  63225,  -23.9607582,   12.9736223,  -8.94608307
  63226,   -23.267931,   12.9736223,  -8.94608307
  63227,  -22.5751038,   12.9736223,  -8.94608307
  63228,  -21.8822765,   12.9736223,  -8.94608307
  63229,  -28.3304157,   12.3237324,  -8.83643341
  63230,  -27.5903225,   12.3237324,  -8.83643341
  63231,  -26.8502312,   12.3237324,  -8.83643341
  63232,  -26.1101398,   12.3237324,  -8.83643341
  63233,  -25.3700466,   12.3237324,  -8.83643341
  63234,  -24.6299534,   12.3237314,  -8.83643246
  63235,  -23.8898602,   12.3237314,  -8.83643246
  63236,  -23.1497688,   12.3237314,  -8.83643246
  63237,  -22.4096775,   12.3237314,  -8.83643246
  63238,  -21.6695843,   12.3237314,  -8.83643246
  63239,  -28.5357857,   11.6962109,  -8.69996929
  63240,  -27.7500553,   11.6962109,  -8.69996929
  63241,   -26.964325,   11.6962109,  -8.69996929
  63242,  -26.1785946,   11.6962109,  -8.69996929
  63243,  -25.3928661,   11.6962109,  -8.69996929
  63244,  -24.6071339,   11.6962109,  -8.69996929
  63245,  -23.8214054,   11.6962109,  -8.69996929
  63246,   -23.035675,   11.6962109,  -8.69996929
  63247,  -22.2499447,   11.6962109,  -8.69996929
  63248,  -21.4642143,   11.6962109,  -8.69996929
  63249,  -28.7319832,   11.0967159,  -8.54105377
  63250,  -27.9026546,   11.0967159,  -8.54105377
  63251,  -27.0733242,   11.0967159,  -8.54105377
  63252,  -26.2439938,   11.0967159,  -8.54105377
  63253,  -25.4146652,   11.0967159,  -8.54105377
  63254,  -24.5853367,   11.0967159,  -8.54105377
  63255,  -23.7560062,   11.0967159,  -8.54105377
  63256,  -22.9266758,   11.0967159,  -8.54105377
  63257,  -22.0973454,   11.0967159,  -8.54105377
  63258,  -21.2680168,   11.0967159,  -8.54105377
  63259,  -28.9173985,   10.5301704,  -8.36577415
  63260,  -28.0468655,   10.5301704,  -8.36577415
  63261,  -27.1763325,   10.5301704,  -8.36577415
  63262,  -26.3057995,   10.5301704,  -8.36577415
  63263,  -25.4352665,   10.5301704,  -8.36577415
  63264,  -24.5647335,   10.5301704,  -8.36577415
  63265,  -23.6942005,   10.5301704,  -8.36577415
  63266,  -22.8236675,   10.5301704,  -8.36577415
  63267,  -21.9531345,   10.5301704,  -8.36577415
  63268,  -21.0826015,   10.5301704,  -8.36577415
  63269,  -27.6873913,   14.2885246,  -8.61194038
  63270,  -27.0901928,   14.2885246,  -8.61194038
  63271,  -26.4929943,   14.2885246,  -8.61194038
  63272,  -25.8957977,   14.2885246,  -8.61194038
  63273,  -25.2985992,   14.2885246,  -8.61194038
  63274,  -24.7014008,   14.2885237,  -8.61194038
  63275,  -24.1042023,   14.2885237,  -8.61194038
  63276,  -23.5070057,   14.2885237,  -8.61194038
  63277,  -22.9098053,   14.2885237,  -8.61194038
  63278,  -22.3126087,   14.2885237,  -8.61194038
  63279,  -27.9176064,   13.5850897,  -8.53908062
  63280,   -27.269249,   13.5850897,  -8.53908062
  63281,  -26.6208935,   13.5850897,  -8.53908062
  63282,  -25.9725361,   13.5850897,  -8.53908062
  63283,  -25.3241787,   13.5850897,  -8.53908062
  63284,  -24.6758213,   13.5850887,  -8.53908062
  63285,  -24.0274639,   13.5850887,  -8.53908062
  63286,  -23.3791065,   13.5850887,  -8.53908062
  63287,   -22.730751,   13.5850887,  -8.53908062
  63288,  -22.0823936,   13.5850887,  -8.53908062
  63289,  -28.1424942,    12.897934,   -8.4191246
  63290,  -27.4441624,    12.897934,   -8.4191246
  63291,  -26.7458305,    12.897934,   -8.4191246
  63292,  -26.0474987,    12.897934,   -8.4191246
  63293,  -25.3491669,    12.897934,   -8.4191246
  63294,  -24.6508331,    12.897934,  -8.41912365
  63295,  -23.9525013,    12.897934,  -8.41912365
  63296,  -23.2541695,    12.897934,  -8.41912365
  63297,  -22.5558376,    12.897934,  -8.41912365
  63298,  -21.8575058,    12.897934,  -8.41912365
  63299,  -28.3592587,   12.2355976,  -8.25464916
  63300,  -27.6127567,   12.2355976,  -8.25464916
  63301,  -26.8662548,   12.2355976,  -8.25464916
  63302,  -26.1197529,   12.2355976,  -8.25464916
  63303,   -25.373251,   12.2355976,  -8.25464916
  63304,   -24.626749,   12.2355976,  -8.25464916
  63305,  -23.8802471,   12.2355976,  -8.25464916
  63306,  -23.1337452,   12.2355976,  -8.25464916
  63307,  -22.3872433,   12.2355976,  -8.25464916
  63308,  -21.6407413,   12.2355976,  -8.25464916
  63309,  -28.5650406,   11.6068163,  -8.04995346
  63310,    -27.77281,   11.6068163,  -8.04995346
  63311,  -26.9805775,   11.6068163,  -8.04995346
  63312,  -26.1883469,   11.6068163,  -8.04995346
  63313,  -25.3961163,   11.6068163,  -8.04995346
  63314,  -24.6038837,   11.6068163,  -8.04995346
  63315,  -23.8116531,   11.6068163,  -8.04995346
  63316,  -23.0194225,   11.6068163,  -8.04995346
  63317,    -22.22719,   11.6068163,  -8.04995346
  63318,  -21.4349594,   11.6068163,  -8.04995346
  63319,  -28.7570667,   11.0200739,  -7.81158066
  63320,   -27.922163,   11.0200739,  -7.81158066
  63321,  -27.0872593,   11.0200739,  -7.81158066
  63322,  -26.2523556,   11.0200739,  -7.81158066
  63323,  -25.4174519,   11.0200739,  -7.81158066
  63324,  -24.5825481,   11.0200739,  -7.81158066
  63325,  -23.7476444,   11.0200739,  -7.81158113
  63326,  -22.9127407,   11.0200739,  -7.81158113
  63327,   -22.077837,   11.0200739,  -7.81158113
  63328,  -21.2429333,   11.0200739,  -7.81158113
  63329,  -28.9329166,   10.4827547,  -7.54866076
  63330,  -28.0589352,   10.4827547,  -7.54866076
  63331,  -27.1849537,   10.4827547,  -7.54866123
  63332,  -26.3109722,   10.4827547,  -7.54866123
  63333,  -25.4369907,   10.4827547,  -7.54866123
  63334,  -24.5630093,   10.4827547,  -7.54866123
  63335,  -23.6890278,   10.4827547,  -7.54866123
  63336,  -22.8150463,   10.4827547,  -7.54866123
  63337,  -21.9410648,   10.4827547,  -7.54866171
  63338,  -21.0670834,   10.4827547,  -7.54866171
  63339,   -27.696825,   14.2596989,  -8.14925385
  63340,  -27.0975304,   14.2596989,  -8.14925385
  63341,  -26.4982357,   14.2596989,  -8.14925385
  63342,   -25.898941,   14.2596989,  -8.14925385
  63343,  -25.2996464,   14.2596989,  -8.14925385
  63344,  -24.7003517,   14.2596989,  -8.14925385
  63345,   -24.101059,   14.2596989,  -8.14925385
  63346,  -23.5017643,   14.2596989,  -8.14925385
  63347,  -22.9024696,   14.2596989,  -8.14925385
  63348,   -22.303175,   14.2596989,  -8.14925385
  63349,  -27.9355965,   13.5301199,  -8.05210781
  63350,  -27.2832413,   13.5301199,  -8.05210781
  63351,   -26.630888,   13.5301199,  -8.05210781
  63352,  -25.9785328,   13.5301199,  -8.05210781
  63353,  -25.3261776,   13.5301199,  -8.05210781
  63354,  -24.6738224,   13.5301189,  -8.05210686
  63355,  -24.0214672,   13.5301189,  -8.05210686
  63356,   -23.369112,   13.5301189,  -8.05210686
  63357,  -22.7167587,   13.5301189,  -8.05210686
  63358,  -22.0644035,   13.5301189,  -8.05210686
  63359,  -28.1672649,   12.8222456,  -7.89216566
  63360,  -27.4634285,   12.8222456,  -7.89216566
  63361,  -26.7595921,   12.8222456,  -7.89216566
  63362,  -26.0557556,   12.8222456,  -7.89216566
  63363,  -25.3519192,   12.8222456,  -7.89216566
  63364,  -24.6480808,   12.8222456,  -7.89216518
  63365,  -23.9442444,   12.8222456,  -7.89216518
  63366,  -23.2404079,   12.8222456,  -7.89216518
  63367,  -22.5365715,   12.8222446,  -7.89216518
  63368,  -21.8327351,   12.8222446,  -7.89216518
  63369,  -28.3881035,   12.1474638,  -7.67286587
  63370,   -27.635191,   12.1474638,  -7.67286587
  63371,  -26.8822784,   12.1474638,  -7.67286587
  63372,  -26.1293678,   12.1474638,  -7.67286587
  63373,  -25.3764553,   12.1474638,  -7.67286587
  63374,  -24.6235447,   12.1474638,  -7.67286587
  63375,  -23.8706322,   12.1474638,  -7.67286587
  63376,  -23.1177216,   12.1474638,  -7.67286587
  63377,   -22.364809,   12.1474638,  -7.67286587
  63378,  -21.6118965,   12.1474638,  -7.67286587
  63379,  -28.5942974,   11.5174208,  -7.39993811
  63380,  -27.7955666,   11.5174208,  -7.39993811
  63381,  -26.9968319,   11.5174208,  -7.39993811
  63382,  -26.1980991,   11.5174208,  -7.39993811
  63383,  -25.3993664,   11.5174208,  -7.39993811
  63384,  -24.6006336,   11.5174208,  -7.39993811
  63385,  -23.8019009,   11.5174208,  -7.39993811
  63386,  -23.0031681,   11.5174208,  -7.39993811
  63387,  -22.2044334,   11.5174208,  -7.39993811
  63388,  -21.4057026,   11.5174208,  -7.39993811
  63389,  -28.7821503,   10.9434319,  -7.08210754
  63390,  -27.9416714,   10.9434319,  -7.08210754
  63391,  -27.1011944,   10.9434319,  -7.08210754
  63392,  -26.2607155,   10.9434319,  -7.08210754
  63393,  -25.4202385,   10.9434319,  -7.08210754
  63394,  -24.5797615,   10.9434319,  -7.08210754
  63395,  -23.7392845,   10.9434319,  -7.08210754
  63396,  -22.8988056,   10.9434319,  -7.08210802
  63397,  -22.0583286,   10.9434319,  -7.08210802
  63398,  -21.2178497,   10.9434319,  -7.08210802
  63399,  -28.9484348,   10.4353399,  -6.73154783
  63400,  -28.0710049,   10.4353399,  -6.73154783
  63401,  -27.1935749,   10.4353399,  -6.73154831
  63402,  -26.3161449,   10.4353399,  -6.73154831
  63403,   -25.438715,   10.4353399,  -6.73154831
  63404,   -24.561285,   10.4353399,  -6.73154831
  63405,  -23.6838551,   10.4353399,  -6.73154831
  63406,  -22.8064251,   10.4353399,  -6.73154831
  63407,  -21.9289951,   10.4353399,  -6.73154879
  63408,  -21.0515652,   10.4353399,  -6.73154879
  63409,  -27.7062588,   14.2308741,  -7.68656683
  63410,  -27.1048679,   14.2308741,  -7.68656683
  63411,  -26.5034771,   14.2308741,  -7.68656683
  63412,  -25.9020863,   14.2308741,  -7.68656683
  63413,  -25.3006935,   14.2308741,  -7.68656683
  63414,  -24.6993027,   14.2308731,  -7.68656683
  63415,  -24.0979118,   14.2308731,  -7.68656683
  63416,   -23.496521,   14.2308731,  -7.68656683
  63417,  -22.8951302,   14.2308731,  -7.68656683
  63418,  -22.2937393,   14.2308731,  -7.68656683
  63419,  -27.9535866,   13.4751492,  -7.56513453
  63420,  -27.2972336,   13.4751492,  -7.56513453
  63421,  -26.6408825,   13.4751492,  -7.56513453
  63422,  -25.9845295,   13.4751492,  -7.56513453
  63423,  -25.3281765,   13.4751492,  -7.56513453
  63424,  -24.6718216,   13.4751482,  -7.56513405
  63425,  -24.0154686,   13.4751482,  -7.56513405
  63426,  -23.3591156,   13.4751482,  -7.56513405
  63427,  -22.7027645,   13.4751482,  -7.56513405
  63428,  -22.0464115,   13.4751482,  -7.56513405
  63429,  -28.1920357,   12.7465563,  -7.36520672
  63430,  -27.4826946,   12.7465563,  -7.36520672
  63431,  -26.7733536,   12.7465563,  -7.36520672
  63432,  -26.0640125,   12.7465563,  -7.36520672
  63433,  -25.3546715,   12.7465563,  -7.36520672
  63434,  -24.6453285,   12.7465563,  -7.36520672
  63435,  -23.9359875,   12.7465563,  -7.36520672
  63436,  -23.2266464,   12.7465563,  -7.36520672
  63437,  -22.5173054,   12.7465563,  -7.36520672
  63438,  -21.8079643,   12.7465563,  -7.36520672
  63439,  -28.4169464,     12.05933,  -7.09108257
  63440,  -27.6576252,     12.05933,  -7.09108257
  63441,   -26.898304,     12.05933,  -7.09108257
  63442,  -26.1389828,     12.05933,  -7.09108257
  63443,  -25.3796597,     12.05933,   -7.0910821
  63444,  -24.6203403,    12.059329,   -7.0910821
  63445,  -23.8610172,    12.059329,   -7.0910821
  63446,   -23.101696,    12.059329,   -7.0910821
  63447,  -22.3423748,    12.059329,   -7.0910821
  63448,  -21.5830536,    12.059329,   -7.0910821
  63449,  -28.6235542,   11.4280262,  -6.74992228
  63450,  -27.8183212,   11.4280262,  -6.74992228
  63451,  -27.0130863,   11.4280262,  -6.74992228
  63452,  -26.2078514,   11.4280262,  -6.74992228
  63453,  -25.4026165,   11.4280262,  -6.74992228
  63454,  -24.5973835,   11.4280262,  -6.74992228
  63455,  -23.7921486,   11.4280262,  -6.74992228
  63456,  -22.9869137,   11.4280262,  -6.74992228
  63457,  -22.1816788,   11.4280262,  -6.74992228
  63458,  -21.3764458,   11.4280262,  -6.74992228
  63459,  -28.8072319,   10.8667889,  -6.35263443
  63460,  -27.9611797,   10.8667889,  -6.35263443
  63461,  -27.1151295,   10.8667889,  -6.35263443
  63462,  -26.2690773,   10.8667889,  -6.35263443
  63463,  -25.4230251,   10.8667889,  -6.35263443
  63464,  -24.5769749,   10.8667889,  -6.35263443
  63465,  -23.7309227,   10.8667889,  -6.35263443
  63466,  -22.8848705,   10.8667889,  -6.35263491
  63467,  -22.0388203,   10.8667889,  -6.35263491
  63468,  -21.1927681,   10.8667889,  -6.35263491
  63469,  -28.9639511,   10.3879251,  -5.91443491
  63470,  -28.0830746,   10.3879251,  -5.91443491
  63471,  -27.2021942,   10.3879251,  -5.91443539
  63472,  -26.3213158,   10.3879251,  -5.91443539
  63473,  -25.4404392,   10.3879251,  -5.91443539
  63474,  -24.5595608,   10.3879251,  -5.91443539
  63475,  -23.6786842,   10.3879251,  -5.91443539
  63476,  -22.7978058,   10.3879251,  -5.91443539
  63477,  -21.9169254,   10.3879251,  -5.91443586
  63478,  -21.0360489,   10.3879251,  -5.91443586
  63479,  -27.7156906,   14.2020483,  -7.22388029
  63480,  -27.1122036,   14.2020483,  -7.22388029
  63481,  -26.5087166,   14.2020483,  -7.22388029
  63482,  -25.9052296,   14.2020483,  -7.22388029
  63483,  -25.3017426,   14.2020483,  -7.22388029
  63484,  -24.6982555,   14.2020493,  -7.22388029
  63485,  -24.0947685,   14.2020493,  -7.22388029
  63486,  -23.4912815,   14.2020483,  -7.22388029
  63487,  -22.8877926,   14.2020483,  -7.22388029
  63488,  -22.2843075,   14.2020483,  -7.22388029
  63489,  -27.9715767,   13.4201794,  -7.07816124
  63490,  -27.3112259,   13.4201794,  -7.07816124
  63491,  -26.6508751,   13.4201794,  -7.07816124
  63492,  -25.9905243,   13.4201784,  -7.07816076
  63493,  -25.3301735,   13.4201784,  -7.07816076
  63494,  -24.6698246,   13.4201794,  -7.07816124
  63495,  -24.0094738,   13.4201794,  -7.07816124
  63496,   -23.349123,   13.4201794,  -7.07816124
  63497,  -22.6887722,   13.4201794,  -7.07816124
  63498,  -22.0284214,   13.4201784,  -7.07816076
  63499,  -28.2168064,   12.6708679,  -6.83824778
  63500,  -27.5019608,   12.6708679,  -6.83824778
  63501,  -26.7871151,   12.6708679,  -6.83824778
  63502,  -26.0722694,   12.6708679,  -6.83824778
  63503,  -25.3574238,   12.6708679,  -6.83824778
  63504,  -24.6425762,   12.6708679,  -6.83824825
  63505,  -23.9277306,   12.6708679,  -6.83824825
  63506,  -23.2128849,   12.6708679,  -6.83824825
  63507,  -22.4980392,   12.6708679,  -6.83824825
  63508,  -21.7831936,   12.6708679,  -6.83824825
  63509,  -28.4457893,   11.9711962,   -6.5092988
  63510,  -27.6800594,   11.9711962,   -6.5092988
  63511,  -26.9143276,   11.9711962,   -6.5092988
  63512,  -26.1485977,   11.9711962,   -6.5092988
  63513,  -25.3828659,   11.9711962,   -6.5092988
  63514,  -24.6171341,   11.9711952,   -6.5092988
  63515,  -23.8514023,   11.9711952,   -6.5092988
  63516,  -23.0856724,   11.9711952,   -6.5092988
  63517,  -22.3199406,   11.9711952,   -6.5092988
  63518,  -21.5542107,   11.9711952,   -6.5092988
  63519,  -28.6528111,   11.3386316,  -6.09990692
  63520,  -27.8410759,   11.3386316,  -6.09990692
  63521,  -27.0293388,   11.3386316,  -6.09990692
  63522,  -26.2176037,   11.3386316,  -6.09990692
  63523,  -25.4058685,   11.3386316,  -6.09990692
  63524,  -24.5941315,   11.3386316,  -6.09990692
  63525,  -23.7823963,   11.3386316,  -6.09990692
  63526,  -22.9706612,   11.3386316,  -6.09990692
  63527,  -22.1589241,   11.3386316,  -6.09990692
  63528,  -21.3471889,   11.3386316,  -6.09990692
  63529,  -28.8323154,   10.7901468,  -5.62316132
  63530,    -27.98069,   10.7901468,  -5.62316132
  63531,  -27.1290627,   10.7901468,  -5.62316132
  63532,  -26.2774372,   10.7901468,  -5.62316132
  63533,  -25.4258137,   10.7901468,  -5.62316132
  63534,  -24.5741882,   10.7901468,  -5.62316132
  63535,  -23.7225628,   10.7901468,  -5.62316132
  63536,  -22.8709373,   10.7901468,  -5.62316132
  63537,    -22.01931,   10.7901468,  -5.62316179
  63538,  -21.1676846,   10.7901468,  -5.62316179
  63539,  -28.9794712,   10.3405104,  -5.09732199
  63540,  -28.0951424,   10.3405104,  -5.09732199
  63541,  -27.2108173,   10.3405104,  -5.09732246
  63542,  -26.3264904,   10.3405104,  -5.09732246
  63543,  -25.4421635,   10.3405104,  -5.09732246
  63544,  -24.5578365,   10.3405104,  -5.09732246
  63545,  -23.6735096,   10.3405104,  -5.09732246
  63546,  -22.7891827,   10.3405104,  -5.09732246
  63547,  -21.9048576,   10.3405104,  -5.09732294
  63548,  -21.0205288,   10.3405104,  -5.09732294
  63549,  -27.7251263,   14.1732225,  -6.76119375
  63550,  -27.1195431,   14.1732225,  -6.76119375
  63551,  -26.5139599,   14.1732225,  -6.76119375
  63552,  -25.9083767,   14.1732225,  -6.76119375
  63553,  -25.3027916,   14.1732225,  -6.76119375
  63554,  -24.6972084,   14.1732235,  -6.76119375
  63555,  -24.0916233,   14.1732235,  -6.76119375
  63556,  -23.4860401,   14.1732225,  -6.76119328
  63557,   -22.880455,   14.1732225,  -6.76119328
  63558,  -22.2748737,   14.1732225,  -6.76119328
  63559,  -27.9895668,   13.3652096,  -6.59118795
  63560,  -27.3252182,   13.3652096,  -6.59118795
  63561,  -26.6608696,   13.3652096,  -6.59118795
  63562,   -25.996521,   13.3652086,  -6.59118748
  63563,  -25.3321724,   13.3652086,  -6.59118748
  63564,  -24.6678257,   13.3652086,  -6.59118795
  63565,  -24.0034771,   13.3652086,  -6.59118795
  63566,  -23.3391285,   13.3652086,  -6.59118795
  63567,  -22.6747799,   13.3652086,  -6.59118795
  63568,  -22.0104313,   13.3652077,  -6.59118748
  63569,  -28.2415752,   12.5951796,  -6.31128931
  63570,   -27.521225,   12.5951796,  -6.31128931
  63571,  -26.8008747,   12.5951796,  -6.31128931
  63572,  -26.0805244,   12.5951796,  -6.31128931
  63573,  -25.3601742,   12.5951796,  -6.31128931
  63574,  -24.6398239,   12.5951796,  -6.31128979
  63575,  -23.9194736,   12.5951796,  -6.31128979
  63576,  -23.1991234,   12.5951796,  -6.31128979
  63577,  -22.4787731,   12.5951796,  -6.31128979
  63578,  -21.7584209,   12.5951796,  -6.31128979
  63579,  -28.4746342,   11.8830614,  -5.92751551
  63580,  -27.7024937,   11.8830614,  -5.92751551
  63581,  -26.9303513,   11.8830614,  -5.92751551
  63582,  -26.1582127,   11.8830614,  -5.92751551
  63583,  -25.3860703,   11.8830614,  -5.92751503
  63584,  -24.6139297,   11.8830614,  -5.92751503
  63585,  -23.8417873,   11.8830614,  -5.92751503
  63586,  -23.0696487,   11.8830614,  -5.92751503
  63587,  -22.2975063,   11.8830614,  -5.92751503
  63588,  -21.5253658,   11.8830614,  -5.92751503
  63589,  -28.6820679,   11.2492371,  -5.44989109
  63590,  -27.8638306,   11.2492371,  -5.44989109
  63591,  -27.0455933,   11.2492371,  -5.44989109
  63592,   -26.227356,   11.2492371,  -5.44989109
  63593,  -25.4091187,   11.2492371,  -5.44989109
  63594,  -24.5908813,   11.2492371,  -5.44989109
  63595,   -23.772644,   11.2492371,  -5.44989109
  63596,  -22.9544067,   11.2492371,  -5.44989109
  63597,  -22.1361694,   11.2492371,  -5.44989157
  63598,  -21.3179321,   11.2492371,  -5.44989157
  63599,  -28.8573971,   10.7135048,   -4.8936882
  63600,  -28.0001984,   10.7135048,   -4.8936882
  63601,  -27.1429977,   10.7135048,  -4.89368868
  63602,   -26.285799,   10.7135048,  -4.89368868
  63603,  -25.4286003,   10.7135048,  -4.89368868
  63604,  -24.5714016,   10.7135048,  -4.89368868
  63605,   -23.714201,   10.7135048,  -4.89368868
  63606,  -22.8570023,   10.7135048,  -4.89368868
  63607,  -21.9998016,   10.7135048,  -4.89368868
  63608,  -21.1426029,   10.7135048,  -4.89368916
  63609,  -28.9949894,   10.2930946,  -4.28020906
  63610,   -28.107214,   10.2930946,  -4.28020906
  63611,  -27.2194386,   10.2930946,  -4.28020954
  63612,  -26.3316631,   10.2930946,  -4.28020954
  63613,  -25.4438896,   10.2930946,  -4.28020954
  63614,  -24.5561123,   10.2930956,  -4.28020954
  63615,  -23.6683388,   10.2930956,  -4.28020954
  63616,  -22.7805634,   10.2930956,  -4.28020954
  63617,  -21.8927879,   10.2930956,  -4.28021002
  63618,  -21.0050125,   10.2930956,  -4.28021002
  63619,    -27.73456,   14.1443977,  -6.29850721
  63620,  -27.1268806,   14.1443977,  -6.29850721
  63621,  -26.5192013,   14.1443977,  -6.29850721
  63622,    -25.91152,   14.1443977,  -6.29850721
  63623,  -25.3038387,   14.1443977,  -6.29850721
  63624,  -24.6961594,   14.1443987,  -6.29850721
  63625,    -24.08848,   14.1443987,  -6.29850721
  63626,  -23.4807987,   14.1443977,  -6.29850674
  63627,  -22.8731194,   14.1443977,  -6.29850674
  63628,    -22.26544,   14.1443977,  -6.29850674
  63629,  -28.0075588,   13.3102388,  -6.10421515
  63630,  -27.3392124,   13.3102388,  -6.10421515
  63631,   -26.670866,   13.3102388,  -6.10421515
  63632,  -26.0025196,   13.3102379,  -6.10421467
  63633,  -25.3341732,   13.3102379,  -6.10421467
  63634,  -24.6658268,   13.3102388,  -6.10421515
  63635,  -23.9974804,   13.3102388,  -6.10421515
  63636,   -23.329134,   13.3102388,  -6.10421515
  63637,  -22.6607876,   13.3102388,  -6.10421515
  63638,  -21.9924412,   13.3102379,  -6.10421467
  63639,  -28.2663479,   12.5194902,  -5.78433037
  63640,   -27.540493,   12.5194902,  -5.78433037
  63641,  -26.8146381,   12.5194902,  -5.78433037
  63642,  -26.0887833,   12.5194902,  -5.78433037
  63643,  -25.3629284,   12.5194902,  -5.78433037
  63644,  -24.6370716,   12.5194902,  -5.78433084
  63645,  -23.9112167,   12.5194902,  -5.78433084
  63646,  -23.1853619,   12.5194912,  -5.78433084
  63647,   -22.459507,   12.5194912,  -5.78433084
  63648,  -21.7336502,   12.5194912,  -5.78433084
  63649,  -28.5034771,   11.7949276,  -5.34573221
  63650,  -27.7249279,   11.7949276,  -5.34573221
  63651,  -26.9463768,   11.7949276,  -5.34573221
  63652,  -26.1678257,   11.7949276,  -5.34573221
  63653,  -25.3892746,   11.7949276,  -5.34573174
  63654,  -24.6107254,   11.7949276,  -5.34573174
  63655,  -23.8321743,   11.7949276,  -5.34573174
  63656,  -23.0536232,   11.7949276,  -5.34573174
  63657,  -22.2750721,   11.7949276,  -5.34573174
  63658,  -21.4965229,   11.7949276,  -5.34573174
  63659,  -28.7113228,   11.1598425,  -4.79987574
  63660,  -27.8865852,   11.1598425,  -4.79987574
  63661,  -27.0618458,   11.1598425,  -4.79987574
  63662,  -26.2371082,   11.1598425,  -4.79987574
  63663,  -25.4123688,   11.1598425,  -4.79987574
  63664,  -24.5876312,   11.1598425,  -4.79987574
  63665,  -23.7628918,   11.1598425,  -4.79987574
  63666,  -22.9381542,   11.1598425,  -4.79987574
  63667,  -22.1134148,   11.1598425,  -4.79987574
  63668,  -21.2886772,   11.1598425,  -4.79987574
  63669,  -28.8824806,   10.6368628,  -4.16421509
  63670,  -28.0197067,   10.6368628,  -4.16421509
  63671,  -27.1569328,   10.6368628,  -4.16421509
  63672,  -26.2941589,   10.6368628,  -4.16421556
  63673,  -25.4313869,   10.6368628,  -4.16421556
  63674,   -24.568615,   10.6368628,  -4.16421556
  63675,  -23.7058411,   10.6368628,  -4.16421556
  63676,  -22.8430672,   10.6368628,  -4.16421556
  63677,  -21.9802933,   10.6368628,  -4.16421556
  63678,  -21.1175194,   10.6368628,  -4.16421604
  63679,  -29.0105057,   10.2456799,  -3.46309614
  63680,  -28.1192818,   10.2456799,  -3.46309614
  63681,  -27.2280579,   10.2456799,  -3.46309638
  63682,   -26.336834,   10.2456799,  -3.46309638
  63683,   -25.445612,   10.2456799,  -3.46309662
  63684,   -24.554388,   10.2456808,  -3.46309662
  63685,   -23.663166,   10.2456808,  -3.46309686
  63686,  -22.7719421,   10.2456808,  -3.46309686
  63687,  -21.8807182,   10.2456808,   -3.4630971
  63688,  -20.9894943,   10.2456808,   -3.4630971
  63689,  -27.7439938,    14.115572,   -5.8358202
  63690,  -27.1342163,    14.115572,   -5.8358202
  63691,  -26.5244408,    14.115572,   -5.8358202
  63692,  -25.9146652,    14.115572,   -5.8358202
  63693,  -25.3048878,    14.115572,   -5.8358202
  63694,  -24.6951103,   14.1155729,   -5.8358202
  63695,  -24.0853348,   14.1155729,  -5.83582067
  63696,  -23.4755592,    14.115572,   -5.8358202
  63697,  -22.8657818,    14.115572,   -5.8358202
  63698,  -22.2560062,    14.115572,   -5.8358202
  63699,  -28.0255489,   13.2552691,  -5.61724186
  63700,  -27.3532047,   13.2552691,  -5.61724186
  63701,  -26.6808605,   13.2552691,  -5.61724186
  63702,  -26.0085163,   13.2552681,  -5.61724138
  63703,  -25.3361721,   13.2552681,  -5.61724138
  63704,  -24.6638279,   13.2552681,  -5.61724186
  63705,  -23.9914837,   13.2552681,  -5.61724186
  63706,  -23.3191395,   13.2552681,  -5.61724186
  63707,  -22.6467953,   13.2552681,  -5.61724186
  63708,  -21.9744511,   13.2552671,  -5.61724138
  63709,  -28.2911186,   12.4438019,   -5.2573719
  63710,  -27.5597591,   12.4438019,   -5.2573719
  63711,  -26.8283997,   12.4438019,   -5.2573719
  63712,  -26.0970402,   12.4438019,   -5.2573719
  63713,  -25.3656807,   12.4438019,   -5.2573719
  63714,  -24.6343193,   12.4438019,  -5.25737238
  63715,  -23.9029598,   12.4438019,  -5.25737238
  63716,  -23.1716003,   12.4438019,  -5.25737238
  63717,  -22.4402409,   12.4438019,  -5.25737238
  63718,  -21.7088795,   12.4438019,  -5.25737238
  63719,    -28.53232,   11.7067938,  -4.76394844
  63720,  -27.7473602,   11.7067938,  -4.76394844
  63721,  -26.9624004,   11.7067938,  -4.76394844
  63722,  -26.1774406,   11.7067938,  -4.76394844
  63723,  -25.3924789,   11.7067938,  -4.76394796
  63724,  -24.6075191,   11.7067928,  -4.76394796
  63725,  -23.8225574,   11.7067928,  -4.76394796
  63726,  -23.0375977,   11.7067928,  -4.76394796
  63727,  -22.2526379,   11.7067928,  -4.76394796
  63728,  -21.4676781,   11.7067928,  -4.76394796
  63729,  -28.7405796,   11.0704479,  -4.14986038
  63730,  -27.9093418,   11.0704479,  -4.14986038
  63731,  -27.0781002,   11.0704479,  -4.14986038
  63732,  -26.2468605,   11.0704479,  -4.14986038
  63733,  -25.4156189,   11.0704479,  -4.14986038
  63734,  -24.5843811,   11.0704479,  -4.14986038
  63735,  -23.7531395,   11.0704479,  -4.14986038
  63736,  -22.9218998,   11.0704479,  -4.14986038
  63737,  -22.0906582,   11.0704479,  -4.14986038
  63738,  -21.2594204,   11.0704479,  -4.14986038
  63739,  -28.9075642,   10.5602207,  -3.43474174
  63740,  -28.0392151,   10.5602207,  -3.43474197
  63741,  -27.1708679,   10.5602207,  -3.43474197
  63742,  -26.3025208,   10.5602207,  -3.43474221
  63743,  -25.4341736,   10.5602207,  -3.43474221
  63744,  -24.5658264,   10.5602207,  -3.43474221
  63745,  -23.6974792,   10.5602207,  -3.43474245
  63746,  -22.8291321,   10.5602207,  -3.43474245
  63747,  -21.9607849,   10.5602207,  -3.43474245
  63748,  -21.0924358,   10.5602207,  -3.43474269
  63749,  -29.0260239,   10.1982651,  -2.64598298
  63750,  -28.1313515,   10.1982651,  -2.64598322
  63751,  -27.2366791,   10.1982651,  -2.64598346
  63752,  -26.3420067,   10.1982651,  -2.64598346
  63753,  -25.4473362,   10.1982651,   -2.6459837
  63754,  -24.5526638,   10.1982651,   -2.6459837
  63755,  -23.6579933,   10.1982651,  -2.64598393
  63756,  -22.7633209,   10.1982651,  -2.64598417
  63757,  -21.8686485,   10.1982651,  -2.64598441
  63758,  -20.9739761,   10.1982651,  -2.64598441
  63759,  -27.7534275,   14.0867472,  -5.37313366
  63760,  -27.1415539,   14.0867472,  -5.37313366
  63761,  -26.5296822,   14.0867472,  -5.37313366
  63762,  -25.9178085,   14.0867472,  -5.37313366
  63763,  -25.3059349,   14.0867472,  -5.37313366
  63764,  -24.6940632,   14.0867472,  -5.37313366
  63765,  -24.0821915,   14.0867472,  -5.37313414
  63766,  -23.4703178,   14.0867462,  -5.37313366
  63767,  -22.8584442,   14.0867462,  -5.37313366
  63768,  -22.2465725,   14.0867462,  -5.37313366
  63769,   -28.043539,   13.2002983,  -5.13026857
  63770,   -27.367197,   13.2002983,  -5.13026857
  63771,   -26.690855,   13.2002983,  -5.13026857
  63772,   -26.014513,   13.2002974,   -5.1302681
  63773,   -25.338171,   13.2002974,   -5.1302681
  63774,   -24.661829,   13.2002983,  -5.13026857
  63775,   -23.985487,   13.2002983,  -5.13026857
  63776,   -23.309145,   13.2002983,  -5.13026857
  63777,   -22.632803,   13.2002983,  -5.13026857
  63778,   -21.956461,   13.2002974,   -5.1302681
  63779,  -28.3158894,   12.3681135,  -4.73041344
  63780,  -27.5790253,   12.3681135,  -4.73041344
  63781,  -26.8421612,   12.3681135,  -4.73041344
  63782,  -26.1052971,   12.3681135,  -4.73041344
  63783,   -25.368433,   12.3681135,  -4.73041344
  63784,   -24.631567,   12.3681135,  -4.73041391
  63785,  -23.8947029,   12.3681135,  -4.73041391
  63786,  -23.1578388,   12.3681135,  -4.73041391
  63787,  -22.4209747,   12.3681135,  -4.73041391
  63788,  -21.6841087,   12.3681135,  -4.73041391
  63789,  -28.5611649,     11.61866,  -4.18216467
  63790,  -27.7697945,     11.61866,  -4.18216467
  63791,  -26.9784241,     11.61866,  -4.18216467
  63792,  -26.1870556,     11.61866,  -4.18216467
  63793,  -25.3956833,     11.61866,  -4.18216467
  63794,  -24.6043148,    11.618659,  -4.18216467
  63795,  -23.8129425,    11.618659,  -4.18216467
  63796,   -23.021574,    11.618659,  -4.18216467
  63797,  -22.2302036,    11.618659,  -4.18216467
  63798,  -21.4388332,    11.618659,  -4.18216467
  63799,  -28.7698364,   10.9810524,  -3.49984479
  63800,  -27.9320946,   10.9810524,  -3.49984479
  63801,  -27.0943527,   10.9810524,  -3.49984479
  63802,  -26.2566128,   10.9810524,  -3.49984479
  63803,  -25.4188709,   10.9810524,  -3.49984479
  63804,  -24.5811291,   10.9810534,  -3.49984479
  63805,  -23.7433872,   10.9810534,  -3.49984479
  63806,  -22.9056473,   10.9810534,  -3.49984479
  63807,  -22.0679054,   10.9810534,  -3.49984479
  63808,  -21.2301636,   10.9810534,  -3.49984479
  63809,  -28.9326458,   10.4835787,  -2.70526886
  63810,  -28.0587254,   10.4835787,  -2.70526886
  63811,   -27.184803,   10.4835787,   -2.7052691
  63812,  -26.3108807,   10.4835787,   -2.7052691
  63813,  -25.4369621,   10.4835787,   -2.7052691
  63814,  -24.5630398,   10.4835787,  -2.70526934
  63815,  -23.6891193,   10.4835787,  -2.70526934
  63816,   -22.815197,   10.4835787,  -2.70526958
  63817,  -21.9412746,   10.4835787,  -2.70526958
  63818,  -21.0673542,   10.4835787,  -2.70526981
  63819,  -29.0415401,   10.1508503,  -1.82887018
  63820,  -28.1434193,   10.1508503,   -1.8288703
  63821,  -27.2453003,   10.1508503,  -1.82887042
  63822,  -26.3471794,   10.1508503,  -1.82887053
  63823,  -25.4490604,   10.1508503,  -1.82887065
  63824,  -24.5509396,   10.1508503,  -1.82887089
  63825,  -23.6528206,   10.1508503,  -1.82887101
  63826,  -22.7546997,   10.1508503,  -1.82887125
  63827,  -21.8565807,   10.1508503,  -1.82887137
  63828,  -20.9584599,   10.1508503,  -1.82887149
*Element, type=C3D8
   1,   324,  3693, 19829,  2953,     1,    79,  2257,   109
   2,  3693,  3694, 19830, 19829,    79,    80,  2258,  2257
   3,  3694,  3695, 19831, 19830,    80,    81,  2259,  2258
   4,  3695,  3696, 19832, 19831,    81,    82,  2260,  2259
   5,  3696,  3697, 19833, 19832,    82,    83,  2261,  2260
   6,  3697,  3698, 19834, 19833,    83,    84,  2262,  2261
   7,  3698,  3699, 19835, 19834,    84,    85,  2263,  2262
   8,  3699,  3700, 19836, 19835,    85,    86,  2264,  2263
   9,  3700,  3701, 19837, 19836,    86,    87,  2265,  2264
  10,  3701,  3702, 19838, 19837,    87,    88,  2266,  2265
  11,  3702,   335,  3323, 19838,    88,     2,    89,  2266
  12,  2953, 19829, 19839,  2954,   109,  2257,  2267,   108
  13, 19829, 19830, 19840, 19839,  2257,  2258,  2268,  2267
  14, 19830, 19831, 19841, 19840,  2258,  2259,  2269,  2268
  15, 19831, 19832, 19842, 19841,  2259,  2260,  2270,  2269
  16, 19832, 19833, 19843, 19842,  2260,  2261,  2271,  2270
  17, 19833, 19834, 19844, 19843,  2261,  2262,  2272,  2271
  18, 19834, 19835, 19845, 19844,  2262,  2263,  2273,  2272
  19, 19835, 19836, 19846, 19845,  2263,  2264,  2274,  2273
  20, 19836, 19837, 19847, 19846,  2264,  2265,  2275,  2274
  21, 19837, 19838, 19848, 19847,  2265,  2266,  2276,  2275
  22, 19838,  3323,  3324, 19848,  2266,    89,    90,  2276
  23,  2954, 19839, 19849,  2955,   108,  2267,  2277,   107
  24, 19839, 19840, 19850, 19849,  2267,  2268,  2278,  2277
  25, 19840, 19841, 19851, 19850,  2268,  2269,  2279,  2278
  26, 19841, 19842, 19852, 19851,  2269,  2270,  2280,  2279
  27, 19842, 19843, 19853, 19852,  2270,  2271,  2281,  2280
  28, 19843, 19844, 19854, 19853,  2271,  2272,  2282,  2281
  29, 19844, 19845, 19855, 19854,  2272,  2273,  2283,  2282
  30, 19845, 19846, 19856, 19855,  2273,  2274,  2284,  2283
  31, 19846, 19847, 19857, 19856,  2274,  2275,  2285,  2284
  32, 19847, 19848, 19858, 19857,  2275,  2276,  2286,  2285
  33, 19848,  3324,  3325, 19858,  2276,    90,    91,  2286
  34,  2955, 19849, 19859,  2956,   107,  2277,  2287,   106
  35, 19849, 19850, 19860, 19859,  2277,  2278,  2288,  2287
  36, 19850, 19851, 19861, 19860,  2278,  2279,  2289,  2288
  37, 19851, 19852, 19862, 19861,  2279,  2280,  2290,  2289
  38, 19852, 19853, 19863, 19862,  2280,  2281,  2291,  2290
  39, 19853, 19854, 19864, 19863,  2281,  2282,  2292,  2291
  40, 19854, 19855, 19865, 19864,  2282,  2283,  2293,  2292
  41, 19855, 19856, 19866, 19865,  2283,  2284,  2294,  2293
  42, 19856, 19857, 19867, 19866,  2284,  2285,  2295,  2294
  43, 19857, 19858, 19868, 19867,  2285,  2286,  2296,  2295
  44, 19858,  3325,  3326, 19868,  2286,    91,    92,  2296
  45,  2956, 19859, 19869,  2957,   106,  2287,  2297,   105
  46, 19859, 19860, 19870, 19869,  2287,  2288,  2298,  2297
  47, 19860, 19861, 19871, 19870,  2288,  2289,  2299,  2298
  48, 19861, 19862, 19872, 19871,  2289,  2290,  2300,  2299
  49, 19862, 19863, 19873, 19872,  2290,  2291,  2301,  2300
  50, 19863, 19864, 19874, 19873,  2291,  2292,  2302,  2301
  51, 19864, 19865, 19875, 19874,  2292,  2293,  2303,  2302
  52, 19865, 19866, 19876, 19875,  2293,  2294,  2304,  2303
  53, 19866, 19867, 19877, 19876,  2294,  2295,  2305,  2304
  54, 19867, 19868, 19878, 19877,  2295,  2296,  2306,  2305
  55, 19868,  3326,  3327, 19878,  2296,    92,    93,  2306
  56,  2957, 19869, 19879,  2958,   105,  2297,  2307,   104
  57, 19869, 19870, 19880, 19879,  2297,  2298,  2308,  2307
  58, 19870, 19871, 19881, 19880,  2298,  2299,  2309,  2308
  59, 19871, 19872, 19882, 19881,  2299,  2300,  2310,  2309
  60, 19872, 19873, 19883, 19882,  2300,  2301,  2311,  2310
  61, 19873, 19874, 19884, 19883,  2301,  2302,  2312,  2311
  62, 19874, 19875, 19885, 19884,  2302,  2303,  2313,  2312
  63, 19875, 19876, 19886, 19885,  2303,  2304,  2314,  2313
  64, 19876, 19877, 19887, 19886,  2304,  2305,  2315,  2314
  65, 19877, 19878, 19888, 19887,  2305,  2306,  2316,  2315
  66, 19878,  3327,  3328, 19888,  2306,    93,    94,  2316
  67,  2958, 19879, 19889,  2959,   104,  2307,    99,     5
  68, 19879, 19880, 19890, 19889,  2307,  2308,    98,    99
  69, 19880, 19881, 19891, 19890,  2308,  2309,    97,    98
  70, 19881, 19882, 19892, 19891,  2309,  2310,    96,    97
  71, 19882, 19883, 19893, 19892,  2310,  2311,    95,    96
  72, 19883, 19884, 19894, 19893,  2311,  2312,     3,    95
  73, 19884, 19885, 19895, 19894,  2312,  2313,   103,     3
  74, 19885, 19886, 19896, 19895,  2313,  2314,   102,   103
  75, 19886, 19887, 19897, 19896,  2314,  2315,   101,   102
  76, 19887, 19888, 19898, 19897,  2315,  2316,   100,   101
  77, 19888,  3328,  3329, 19898,  2316,    94,     4,   100
  78,  2959, 19889, 19899,  2960,     5,    99,  2413,   162
  79, 19889, 19890, 19900, 19899,    99,    98,  2389,  2413
  80, 19890, 19891, 19901, 19900,    98,    97,  2365,  2389
  81, 19891, 19892, 19902, 19901,    97,    96,  2341,  2365
  82, 19892, 19893, 19903, 19902,    96,    95,  2317,  2341
  83, 19893, 19894, 19904, 19903,    95,     3,   110,  2317
  84, 19894, 19895, 19905, 19904,     3,   103,  2460,   110
  85, 19895, 19896, 19906, 19905,   103,   102,  2484,  2460
  86, 19896, 19897, 19907, 19906,   102,   101,  2508,  2484
  87, 19897, 19898, 19908, 19907,   101,   100,  2532,  2508
  88, 19898,  3329,  3330, 19908,   100,     4,   163,  2532
  89,  2960, 19899, 19909,  2961,   162,  2413,  2414,   161
  90, 19899, 19900, 19910, 19909,  2413,  2389,  2390,  2414
  91, 19900, 19901, 19911, 19910,  2389,  2365,  2366,  2390
  92, 19901, 19902, 19912, 19911,  2365,  2341,  2342,  2366
  93, 19902, 19903, 19913, 19912,  2341,  2317,  2318,  2342
  94, 19903, 19904, 19914, 19913,  2317,   110,   111,  2318
  95, 19904, 19905, 19915, 19914,   110,  2460,  2459,   111
  96, 19905, 19906, 19916, 19915,  2460,  2484,  2483,  2459
  97, 19906, 19907, 19917, 19916,  2484,  2508,  2507,  2483
  98, 19907, 19908, 19918, 19917,  2508,  2532,  2531,  2507
  99, 19908,  3330,  3331, 19918,  2532,   163,   164,  2531
 100,  2961, 19909, 19919,  2962,   161,  2414,  2415,   160
 101, 19909, 19910, 19920, 19919,  2414,  2390,  2391,  2415
 102, 19910, 19911, 19921, 19920,  2390,  2366,  2367,  2391
 103, 19911, 19912, 19922, 19921,  2366,  2342,  2343,  2367
 104, 19912, 19913, 19923, 19922,  2342,  2318,  2319,  2343
 105, 19913, 19914, 19924, 19923,  2318,   111,   112,  2319
 106, 19914, 19915, 19925, 19924,   111,  2459,  2458,   112
 107, 19915, 19916, 19926, 19925,  2459,  2483,  2482,  2458
 108, 19916, 19917, 19927, 19926,  2483,  2507,  2506,  2482
 109, 19917, 19918, 19928, 19927,  2507,  2531,  2530,  2506
 110, 19918,  3331,  3332, 19928,  2531,   164,   165,  2530
 111,  2962, 19919, 19929,  2963,   160,  2415,  2416,   159
 112, 19919, 19920, 19930, 19929,  2415,  2391,  2392,  2416
 113, 19920, 19921, 19931, 19930,  2391,  2367,  2368,  2392
 114, 19921, 19922, 19932, 19931,  2367,  2343,  2344,  2368
 115, 19922, 19923, 19933, 19932,  2343,  2319,  2320,  2344
 116, 19923, 19924, 19934, 19933,  2319,   112,   113,  2320
 117, 19924, 19925, 19935, 19934,   112,  2458,  2457,   113
 118, 19925, 19926, 19936, 19935,  2458,  2482,  2481,  2457
 119, 19926, 19927, 19937, 19936,  2482,  2506,  2505,  2481
 120, 19927, 19928, 19938, 19937,  2506,  2530,  2529,  2505
 121, 19928,  3332,  3333, 19938,  2530,   165,   166,  2529
 122,  2963, 19929, 19939,  2964,   159,  2416,  2417,   158
 123, 19929, 19930, 19940, 19939,  2416,  2392,  2393,  2417
 124, 19930, 19931, 19941, 19940,  2392,  2368,  2369,  2393
 125, 19931, 19932, 19942, 19941,  2368,  2344,  2345,  2369
 126, 19932, 19933, 19943, 19942,  2344,  2320,  2321,  2345
 127, 19933, 19934, 19944, 19943,  2320,   113,   114,  2321
 128, 19934, 19935, 19945, 19944,   113,  2457,  2456,   114
 129, 19935, 19936, 19946, 19945,  2457,  2481,  2480,  2456
 130, 19936, 19937, 19947, 19946,  2481,  2505,  2504,  2480
 131, 19937, 19938, 19948, 19947,  2505,  2529,  2528,  2504
 132, 19938,  3333,  3334, 19948,  2529,   166,   167,  2528
 133,  2964, 19939, 19949,  2965,   158,  2417,  2418,   157
 134, 19939, 19940, 19950, 19949,  2417,  2393,  2394,  2418
 135, 19940, 19941, 19951, 19950,  2393,  2369,  2370,  2394
