  45995,   2.00775385,   70.8124695,   3.63636374
  45996,   1.33965003,   70.8661346,   3.63636374
  45997,  0.670169413,   70.8983459,   3.63636374
  45998,           0.,   70.9090881,   3.63636374
  45999, -0.670169413,   70.8983459,   3.63636374
  46000,  -1.33965003,   70.8661346,   3.63636374
  46001,  -2.00775385,   70.8124695,   3.63636374
  46002,  -2.67379522,   70.7374268,   3.63636374
  46003,  -3.33708858,   70.6410751,   3.63636374
  46004,  -3.99695396,   70.5235062,   3.63636374
  46005,  -4.65271044,   70.3848572,   3.63636374
  46006,  -5.30368757,   70.2252579,   3.63636374
  46007,   -5.9492135,   70.0448761,   3.63636374
  46008,  -6.58862591,    69.843895,   3.63636374
  46009,  -7.22126818,   69.6225204,   3.63636374
  46010,  -7.84649086,   69.3809891,   3.63636374
  46011,   -8.4636507,   69.1195374,   3.63636374
  46012,  -9.07211399,   68.8384399,   3.63636374
  46013,  -9.67125511,   68.5379868,   3.63636374
  46014,   -10.260457,    68.218483,   3.63636374
  46015,   -10.839119,   67.8802567,   3.63636374
  46016,  -11.4066381,   67.5236588,   3.63636374
  46017,  -11.9624405,   67.1490555,   3.63636374
  46018,  -12.5059462,   66.7568283,   3.63636374
  46019,  -13.0366058,   66.3473892,   3.63636374
  46020,  -13.5538654,   65.9211426,   3.63636374
  46021,  -14.0572014,   65.4785385,   3.63636374
  46022,  -14.5460892,   65.0200348,   3.63636374
  46023,  -15.0200319,   64.5460892,   3.63636374
  46024,  -15.4785395,   64.0571976,   3.63636374
  46025,  -15.9211416,   63.5538673,   3.63636374
  46026,  -16.3473854,   63.0366058,   3.63636374
  46027,  -16.7568302,   62.5059471,   3.63636374
  46028,  -17.1490555,   61.9624405,   3.63636374
  46029,  -17.5236607,   61.4066391,   3.63636374
  46030,  -17.8802586,    60.839119,   3.63636374
  46031,  -18.2184811,   60.2604561,   3.63636374
  46032,  -18.5379829,    59.671257,   3.63636374
  46033,  -18.8384418,    59.072113,   3.63636374
  46034,  -19.1195393,   58.4636536,   3.63636374
  46035,  -19.3809872,   57.8464928,   3.63636374
  46036,  -19.6225204,   57.2212677,   3.63636374
  46037,  -19.8438931,   56.5886269,   3.63636374
  46038,  -20.0448742,   55.9492149,   3.63636374
  46039,   -20.225256,    55.303688,   3.63636374
  46040,  -20.3848572,     54.65271,   3.63636374
  46041,    -20.52351,   53.9969521,   3.63636374
  46042,  -20.6410732,   53.3370895,   3.63636374
  46043,  -20.7374268,   52.6737938,   3.63636374
  46044,  -20.8124752,   52.0077553,   3.63636374
  46045,  -20.8661308,   51.3396492,   3.63636374
  46046,  -20.8983479,   50.6701698,   3.63636374
  46047,   20.8983479,   50.6701698,    4.5454545
  46048,   20.8661308,   51.3396492,    4.5454545
  46049,   20.8124752,   52.0077553,    4.5454545
  46050,   20.7374268,   52.6737938,    4.5454545
  46051,   20.6410732,   53.3370895,    4.5454545
  46052,     20.52351,   53.9969521,    4.5454545
  46053,   20.3848572,     54.65271,    4.5454545
  46054,    20.225256,    55.303688,    4.5454545
  46055,   20.0448742,   55.9492149,    4.5454545
  46056,   19.8438931,   56.5886269,    4.5454545
  46057,   19.6225204,   57.2212677,    4.5454545
  46058,   19.3809872,   57.8464928,    4.5454545
  46059,   19.1195393,   58.4636536,    4.5454545
  46060,   18.8384418,    59.072113,    4.5454545
  46061,   18.5379829,    59.671257,    4.5454545
  46062,   18.2184811,   60.2604561,    4.5454545
  46063,   17.8802586,    60.839119,    4.5454545
  46064,   17.5236607,   61.4066391,    4.5454545
  46065,   17.1490555,   61.9624405,    4.5454545
  46066,   16.7568302,   62.5059471,    4.5454545
  46067,   16.3473854,   63.0366058,    4.5454545
  46068,   15.9211416,   63.5538673,    4.5454545
  46069,   15.4785395,   64.0571976,    4.5454545
  46070,   15.0200319,   64.5460892,    4.5454545
  46071,   14.5460892,   65.0200348,    4.5454545
  46072,   14.0572014,   65.4785385,    4.5454545
  46073,   13.5538654,   65.9211426,    4.5454545
  46074,   13.0366058,   66.3473892,    4.5454545
  46075,   12.5059462,   66.7568283,    4.5454545
  46076,   11.9624405,   67.1490555,    4.5454545
  46077,   11.4066381,   67.5236588,    4.5454545
  46078,    10.839119,   67.8802567,    4.5454545
  46079,    10.260457,    68.218483,    4.5454545
  46080,   9.67125511,   68.5379868,    4.5454545
  46081,   9.07211399,   68.8384399,    4.5454545
  46082,    8.4636507,   69.1195374,    4.5454545
  46083,   7.84649086,   69.3809891,    4.5454545
  46084,   7.22126818,   69.6225204,    4.5454545
  46085,   6.58862591,    69.843895,    4.5454545
  46086,    5.9492135,   70.0448761,    4.5454545
  46087,   5.30368757,   70.2252579,    4.5454545
  46088,   4.65271044,   70.3848572,    4.5454545
  46089,   3.99695396,   70.5235062,    4.5454545
  46090,   3.33708858,   70.6410751,    4.5454545
  46091,   2.67379522,   70.7374268,    4.5454545
  46092,   2.00775385,   70.8124695,    4.5454545
  46093,   1.33965003,   70.8661346,    4.5454545
  46094,  0.670169413,   70.8983459,    4.5454545
  46095,           0.,   70.9090881,    4.5454545
  46096, -0.670169413,   70.8983459,    4.5454545
  46097,  -1.33965003,   70.8661346,    4.5454545
  46098,  -2.00775385,   70.8124695,    4.5454545
  46099,  -2.67379522,   70.7374268,    4.5454545
  46100,  -3.33708858,   70.6410751,    4.5454545
  46101,  -3.99695396,   70.5235062,    4.5454545
  46102,  -4.65271044,   70.3848572,    4.5454545
  46103,  -5.30368757,   70.2252579,    4.5454545
  46104,   -5.9492135,   70.0448761,    4.5454545
  46105,  -6.58862591,    69.843895,    4.5454545
  46106,  -7.22126818,   69.6225204,    4.5454545
  46107,  -7.84649086,   69.3809891,    4.5454545
  46108,   -8.4636507,   69.1195374,    4.5454545
  46109,  -9.07211399,   68.8384399,    4.5454545
  46110,  -9.67125511,   68.5379868,    4.5454545
  46111,   -10.260457,    68.218483,    4.5454545
  46112,   -10.839119,   67.8802567,    4.5454545
  46113,  -11.4066381,   67.5236588,    4.5454545
  46114,  -11.9624405,   67.1490555,    4.5454545
  46115,  -12.5059462,   66.7568283,    4.5454545
  46116,  -13.0366058,   66.3473892,    4.5454545
  46117,  -13.5538654,   65.9211426,    4.5454545
  46118,  -14.0572014,   65.4785385,    4.5454545
  46119,  -14.5460892,   65.0200348,    4.5454545
  46120,  -15.0200319,   64.5460892,    4.5454545
  46121,  -15.4785395,   64.0571976,    4.5454545
  46122,  -15.9211416,   63.5538673,    4.5454545
  46123,  -16.3473854,   63.0366058,    4.5454545
  46124,  -16.7568302,   62.5059471,    4.5454545
  46125,  -17.1490555,   61.9624405,    4.5454545
  46126,  -17.5236607,   61.4066391,    4.5454545
  46127,  -17.8802586,    60.839119,    4.5454545
  46128,  -18.2184811,   60.2604561,    4.5454545
  46129,  -18.5379829,    59.671257,    4.5454545
  46130,  -18.8384418,    59.072113,    4.5454545
  46131,  -19.1195393,   58.4636536,    4.5454545
  46132,  -19.3809872,   57.8464928,    4.5454545
  46133,  -19.6225204,   57.2212677,    4.5454545
  46134,  -19.8438931,   56.5886269,    4.5454545
  46135,  -20.0448742,   55.9492149,    4.5454545
  46136,   -20.225256,    55.303688,    4.5454545
  46137,  -20.3848572,     54.65271,    4.5454545
  46138,    -20.52351,   53.9969521,    4.5454545
  46139,  -20.6410732,   53.3370895,    4.5454545
  46140,  -20.7374268,   52.6737938,    4.5454545
  46141,  -20.8124752,   52.0077553,    4.5454545
  46142,  -20.8661308,   51.3396492,    4.5454545
  46143,  -20.8983479,   50.6701698,    4.5454545
  46144,   20.8983479,   50.6701698,    5.4545455
  46145,   20.8661308,   51.3396492,    5.4545455
  46146,   20.8124752,   52.0077553,    5.4545455
  46147,   20.7374268,   52.6737938,    5.4545455
  46148,   20.6410732,   53.3370895,    5.4545455
  46149,     20.52351,   53.9969521,    5.4545455
  46150,   20.3848572,     54.65271,    5.4545455
  46151,    20.225256,    55.303688,    5.4545455
  46152,   20.0448742,   55.9492149,    5.4545455
  46153,   19.8438931,   56.5886269,    5.4545455
  46154,   19.6225204,   57.2212677,    5.4545455
  46155,   19.3809872,   57.8464928,    5.4545455
  46156,   19.1195393,   58.4636536,    5.4545455
  46157,   18.8384418,    59.072113,    5.4545455
  46158,   18.5379829,    59.671257,    5.4545455
  46159,   18.2184811,   60.2604561,    5.4545455
  46160,   17.8802586,    60.839119,    5.4545455
  46161,   17.5236607,   61.4066391,    5.4545455
  46162,   17.1490555,   61.9624405,    5.4545455
  46163,   16.7568302,   62.5059471,    5.4545455
  46164,   16.3473854,   63.0366058,    5.4545455
  46165,   15.9211416,   63.5538673,    5.4545455
  46166,   15.4785395,   64.0571976,    5.4545455
  46167,   15.0200319,   64.5460892,    5.4545455
  46168,   14.5460892,   65.0200348,    5.4545455
  46169,   14.0572014,   65.4785385,    5.4545455
  46170,   13.5538654,   65.9211426,    5.4545455
  46171,   13.0366058,   66.3473892,    5.4545455
  46172,   12.5059462,   66.7568283,    5.4545455
  46173,   11.9624405,   67.1490555,    5.4545455
  46174,   11.4066381,   67.5236588,    5.4545455
  46175,    10.839119,   67.8802567,    5.4545455
  46176,    10.260457,    68.218483,    5.4545455
  46177,   9.67125511,   68.5379868,    5.4545455
  46178,   9.07211399,   68.8384399,    5.4545455
  46179,    8.4636507,   69.1195374,    5.4545455
  46180,   7.84649086,   69.3809891,    5.4545455
  46181,   7.22126818,   69.6225204,    5.4545455
  46182,   6.58862591,    69.843895,    5.4545455
  46183,    5.9492135,   70.0448761,    5.4545455
  46184,   5.30368757,   70.2252579,    5.4545455
  46185,   4.65271044,   70.3848572,    5.4545455
  46186,   3.99695396,   70.5235062,    5.4545455
  46187,   3.33708858,   70.6410751,    5.4545455
  46188,   2.67379522,   70.7374268,    5.4545455
  46189,   2.00775385,   70.8124695,    5.4545455
  46190,   1.33965003,   70.8661346,    5.4545455
  46191,  0.670169413,   70.8983459,    5.4545455
  46192,           0.,   70.9090881,    5.4545455
  46193, -0.670169413,   70.8983459,    5.4545455
  46194,  -1.33965003,   70.8661346,    5.4545455
  46195,  -2.00775385,   70.8124695,    5.4545455
  46196,  -2.67379522,   70.7374268,    5.4545455
  46197,  -3.33708858,   70.6410751,    5.4545455
  46198,  -3.99695396,   70.5235062,    5.4545455
  46199,  -4.65271044,   70.3848572,    5.4545455
  46200,  -5.30368757,   70.2252579,    5.4545455
  46201,   -5.9492135,   70.0448761,    5.4545455
  46202,  -6.58862591,    69.843895,    5.4545455
  46203,  -7.22126818,   69.6225204,    5.4545455
  46204,  -7.84649086,   69.3809891,    5.4545455
  46205,   -8.4636507,   69.1195374,    5.4545455
  46206,  -9.07211399,   68.8384399,    5.4545455
  46207,  -9.67125511,   68.5379868,    5.4545455
  46208,   -10.260457,    68.218483,    5.4545455
  46209,   -10.839119,   67.8802567,    5.4545455
  46210,  -11.4066381,   67.5236588,    5.4545455
  46211,  -11.9624405,   67.1490555,    5.4545455
  46212,  -12.5059462,   66.7568283,    5.4545455
  46213,  -13.0366058,   66.3473892,    5.4545455
  46214,  -13.5538654,   65.9211426,    5.4545455
  46215,  -14.0572014,   65.4785385,    5.4545455
  46216,  -14.5460892,   65.0200348,    5.4545455
  46217,  -15.0200319,   64.5460892,    5.4545455
  46218,  -15.4785395,   64.0571976,    5.4545455
  46219,  -15.9211416,   63.5538673,    5.4545455
  46220,  -16.3473854,   63.0366058,    5.4545455
  46221,  -16.7568302,   62.5059471,    5.4545455
  46222,  -17.1490555,   61.9624405,    5.4545455
  46223,  -17.5236607,   61.4066391,    5.4545455
  46224,  -17.8802586,    60.839119,    5.4545455
  46225,  -18.2184811,   60.2604561,    5.4545455
  46226,  -18.5379829,    59.671257,    5.4545455
  46227,  -18.8384418,    59.072113,    5.4545455
  46228,  -19.1195393,   58.4636536,    5.4545455
  46229,  -19.3809872,   57.8464928,    5.4545455
  46230,  -19.6225204,   57.2212677,    5.4545455
  46231,  -19.8438931,   56.5886269,    5.4545455
  46232,  -20.0448742,   55.9492149,    5.4545455
  46233,   -20.225256,    55.303688,    5.4545455
  46234,  -20.3848572,     54.65271,    5.4545455
  46235,    -20.52351,   53.9969521,    5.4545455
  46236,  -20.6410732,   53.3370895,    5.4545455
  46237,  -20.7374268,   52.6737938,    5.4545455
  46238,  -20.8124752,   52.0077553,    5.4545455
  46239,  -20.8661308,   51.3396492,    5.4545455
  46240,  -20.8983479,   50.6701698,    5.4545455
  46241,   20.8983479,   50.6701698,   6.36363649
  46242,   20.8661308,   51.3396492,   6.36363649
  46243,   20.8124752,   52.0077553,   6.36363649
  46244,   20.7374268,   52.6737938,   6.36363649
  46245,   20.6410732,   53.3370895,   6.36363649
  46246,     20.52351,   53.9969521,   6.36363649
  46247,   20.3848572,     54.65271,   6.36363649
  46248,    20.225256,    55.303688,   6.36363649
  46249,   20.0448742,   55.9492149,   6.36363649
  46250,   19.8438931,   56.5886269,   6.36363649
  46251,   19.6225204,   57.2212677,   6.36363649
  46252,   19.3809872,   57.8464928,   6.36363649
  46253,   19.1195393,   58.4636536,   6.36363649
  46254,   18.8384418,    59.072113,   6.36363649
  46255,   18.5379829,    59.671257,   6.36363649
  46256,   18.2184811,   60.2604561,   6.36363649
  46257,   17.8802586,    60.839119,   6.36363649
  46258,   17.5236607,   61.4066391,   6.36363649
  46259,   17.1490555,   61.9624405,   6.36363649
  46260,   16.7568302,   62.5059471,   6.36363649
  46261,   16.3473854,   63.0366058,   6.36363649
  46262,   15.9211416,   63.5538673,   6.36363649
  46263,   15.4785395,   64.0571976,   6.36363649
  46264,   15.0200319,   64.5460892,   6.36363649
  46265,   14.5460892,   65.0200348,   6.36363649
  46266,   14.0572014,   65.4785385,   6.36363649
  46267,   13.5538654,   65.9211426,   6.36363649
  46268,   13.0366058,   66.3473892,   6.36363649
  46269,   12.5059462,   66.7568283,   6.36363649
  46270,   11.9624405,   67.1490555,   6.36363649
  46271,   11.4066381,   67.5236588,   6.36363649
  46272,    10.839119,   67.8802567,   6.36363649
  46273,    10.260457,    68.218483,   6.36363649
  46274,   9.67125511,   68.5379868,   6.36363649
  46275,   9.07211399,   68.8384399,   6.36363649
  46276,    8.4636507,   69.1195374,   6.36363649
  46277,   7.84649086,   69.3809891,   6.36363649
  46278,   7.22126818,   69.6225204,   6.36363649
  46279,   6.58862591,    69.843895,   6.36363649
  46280,    5.9492135,   70.0448761,   6.36363649
  46281,   5.30368757,   70.2252579,   6.36363649
  46282,   4.65271044,   70.3848572,   6.36363649
  46283,   3.99695396,   70.5235062,   6.36363649
  46284,   3.33708858,   70.6410751,   6.36363649
  46285,   2.67379522,   70.7374268,   6.36363649
  46286,   2.00775385,   70.8124695,   6.36363649
  46287,   1.33965003,   70.8661346,   6.36363649
  46288,  0.670169413,   70.8983459,   6.36363649
  46289,           0.,   70.9090881,   6.36363649
  46290, -0.670169413,   70.8983459,   6.36363649
  46291,  -1.33965003,   70.8661346,   6.36363649
  46292,  -2.00775385,   70.8124695,   6.36363649
  46293,  -2.67379522,   70.7374268,   6.36363649
  46294,  -3.33708858,   70.6410751,   6.36363649
  46295,  -3.99695396,   70.5235062,   6.36363649
  46296,  -4.65271044,   70.3848572,   6.36363649
  46297,  -5.30368757,   70.2252579,   6.36363649
  46298,   -5.9492135,   70.0448761,   6.36363649
  46299,  -6.58862591,    69.843895,   6.36363649
  46300,  -7.22126818,   69.6225204,   6.36363649
  46301,  -7.84649086,   69.3809891,   6.36363649
  46302,   -8.4636507,   69.1195374,   6.36363649
  46303,  -9.07211399,   68.8384399,   6.36363649
  46304,  -9.67125511,   68.5379868,   6.36363649
  46305,   -10.260457,    68.218483,   6.36363649
  46306,   -10.839119,   67.8802567,   6.36363649
  46307,  -11.4066381,   67.5236588,   6.36363649
  46308,  -11.9624405,   67.1490555,   6.36363649
  46309,  -12.5059462,   66.7568283,   6.36363649
  46310,  -13.0366058,   66.3473892,   6.36363649
  46311,  -13.5538654,   65.9211426,   6.36363649
  46312,  -14.0572014,   65.4785385,   6.36363649
  46313,  -14.5460892,   65.0200348,   6.36363649
  46314,  -15.0200319,   64.5460892,   6.36363649
  46315,  -15.4785395,   64.0571976,   6.36363649
  46316,  -15.9211416,   63.5538673,   6.36363649
  46317,  -16.3473854,   63.0366058,   6.36363649
  46318,  -16.7568302,   62.5059471,   6.36363649
  46319,  -17.1490555,   61.9624405,   6.36363649
  46320,  -17.5236607,   61.4066391,   6.36363649
  46321,  -17.8802586,    60.839119,   6.36363649
  46322,  -18.2184811,   60.2604561,   6.36363649
  46323,  -18.5379829,    59.671257,   6.36363649
  46324,  -18.8384418,    59.072113,   6.36363649
  46325,  -19.1195393,   58.4636536,   6.36363649
  46326,  -19.3809872,   57.8464928,   6.36363649
  46327,  -19.6225204,   57.2212677,   6.36363649
  46328,  -19.8438931,   56.5886269,   6.36363649
  46329,  -20.0448742,   55.9492149,   6.36363649
  46330,   -20.225256,    55.303688,   6.36363649
  46331,  -20.3848572,     54.65271,   6.36363649
  46332,    -20.52351,   53.9969521,   6.36363649
  46333,  -20.6410732,   53.3370895,   6.36363649
  46334,  -20.7374268,   52.6737938,   6.36363649
  46335,  -20.8124752,   52.0077553,   6.36363649
  46336,  -20.8661308,   51.3396492,   6.36363649
  46337,  -20.8983479,   50.6701698,   6.36363649
  46338,   20.8983479,   50.6701698,   7.27272749
  46339,   20.8661308,   51.3396492,   7.27272749
  46340,   20.8124752,   52.0077553,   7.27272749
  46341,   20.7374268,   52.6737938,   7.27272749
  46342,   20.6410732,   53.3370895,   7.27272749
  46343,     20.52351,   53.9969521,   7.27272749
  46344,   20.3848572,     54.65271,   7.27272749
  46345,    20.225256,    55.303688,   7.27272749
  46346,   20.0448742,   55.9492149,   7.27272749
  46347,   19.8438931,   56.5886269,   7.27272749
  46348,   19.6225204,   57.2212677,   7.27272749
  46349,   19.3809872,   57.8464928,   7.27272749
  46350,   19.1195393,   58.4636536,   7.27272749
  46351,   18.8384418,    59.072113,   7.27272749
  46352,   18.5379829,    59.671257,   7.27272749
  46353,   18.2184811,   60.2604561,   7.27272749
  46354,   17.8802586,    60.839119,   7.27272749
  46355,   17.5236607,   61.4066391,   7.27272749
  46356,   17.1490555,   61.9624405,   7.27272749
  46357,   16.7568302,   62.5059471,   7.27272749
  46358,   16.3473854,   63.0366058,   7.27272749
  46359,   15.9211416,   63.5538673,   7.27272749
  46360,   15.4785395,   64.0571976,   7.27272749
  46361,   15.0200319,   64.5460892,   7.27272749
  46362,   14.5460892,   65.0200348,   7.27272749
  46363,   14.0572014,   65.4785385,   7.27272749
  46364,   13.5538654,   65.9211426,   7.27272749
  46365,   13.0366058,   66.3473892,   7.27272749
  46366,   12.5059462,   66.7568283,   7.27272749
  46367,   11.9624405,   67.1490555,   7.27272749
  46368,   11.4066381,   67.5236588,   7.27272749
  46369,    10.839119,   67.8802567,   7.27272749
  46370,    10.260457,    68.218483,   7.27272749
  46371,   9.67125511,   68.5379868,   7.27272749
  46372,   9.07211399,   68.8384399,   7.27272749
  46373,    8.4636507,   69.1195374,   7.27272749
  46374,   7.84649086,   69.3809891,   7.27272749
  46375,   7.22126818,   69.6225204,   7.27272749
  46376,   6.58862591,    69.843895,   7.27272749
  46377,    5.9492135,   70.0448761,   7.27272749
  46378,   5.30368757,   70.2252579,   7.27272749
  46379,   4.65271044,   70.3848572,   7.27272749
  46380,   3.99695396,   70.5235062,   7.27272749
  46381,   3.33708858,   70.6410751,   7.27272749
  46382,   2.67379522,   70.7374268,   7.27272749
  46383,   2.00775385,   70.8124695,   7.27272749
  46384,   1.33965003,   70.8661346,   7.27272749
  46385,  0.670169413,   70.8983459,   7.27272749
  46386,           0.,   70.9090881,   7.27272749
  46387, -0.670169413,   70.8983459,   7.27272749
  46388,  -1.33965003,   70.8661346,   7.27272749
  46389,  -2.00775385,   70.8124695,   7.27272749
  46390,  -2.67379522,   70.7374268,   7.27272749
  46391,  -3.33708858,   70.6410751,   7.27272749
  46392,  -3.99695396,   70.5235062,   7.27272749
  46393,  -4.65271044,   70.3848572,   7.27272749
  46394,  -5.30368757,   70.2252579,   7.27272749
  46395,   -5.9492135,   70.0448761,   7.27272749
  46396,  -6.58862591,    69.843895,   7.27272749
  46397,  -7.22126818,   69.6225204,   7.27272749
  46398,  -7.84649086,   69.3809891,   7.27272749
  46399,   -8.4636507,   69.1195374,   7.27272749
  46400,  -9.07211399,   68.8384399,   7.27272749
  46401,  -9.67125511,   68.5379868,   7.27272749
  46402,   -10.260457,    68.218483,   7.27272749
  46403,   -10.839119,   67.8802567,   7.27272749
  46404,  -11.4066381,   67.5236588,   7.27272749
  46405,  -11.9624405,   67.1490555,   7.27272749
  46406,  -12.5059462,   66.7568283,   7.27272749
  46407,  -13.0366058,   66.3473892,   7.27272749
  46408,  -13.5538654,   65.9211426,   7.27272749
  46409,  -14.0572014,   65.4785385,   7.27272749
  46410,  -14.5460892,   65.0200348,   7.27272749
  46411,  -15.0200319,   64.5460892,   7.27272749
  46412,  -15.4785395,   64.0571976,   7.27272749
  46413,  -15.9211416,   63.5538673,   7.27272749
  46414,  -16.3473854,   63.0366058,   7.27272749
  46415,  -16.7568302,   62.5059471,   7.27272749
  46416,  -17.1490555,   61.9624405,   7.27272749
  46417,  -17.5236607,   61.4066391,   7.27272749
  46418,  -17.8802586,    60.839119,   7.27272749
  46419,  -18.2184811,   60.2604561,   7.27272749
  46420,  -18.5379829,    59.671257,   7.27272749
  46421,  -18.8384418,    59.072113,   7.27272749
  46422,  -19.1195393,   58.4636536,   7.27272749
  46423,  -19.3809872,   57.8464928,   7.27272749
  46424,  -19.6225204,   57.2212677,   7.27272749
  46425,  -19.8438931,   56.5886269,   7.27272749
  46426,  -20.0448742,   55.9492149,   7.27272749
  46427,   -20.225256,    55.303688,   7.27272749
  46428,  -20.3848572,     54.65271,   7.27272749
  46429,    -20.52351,   53.9969521,   7.27272749
  46430,  -20.6410732,   53.3370895,   7.27272749
  46431,  -20.7374268,   52.6737938,   7.27272749
  46432,  -20.8124752,   52.0077553,   7.27272749
  46433,  -20.8661308,   51.3396492,   7.27272749
  46434,  -20.8983479,   50.6701698,   7.27272749
  46435,   20.8983479,   50.6701698,   8.18181801
  46436,   20.8661308,   51.3396492,   8.18181801
  46437,   20.8124752,   52.0077553,   8.18181801
  46438,   20.7374268,   52.6737938,   8.18181801
  46439,   20.6410732,   53.3370895,   8.18181801
  46440,     20.52351,   53.9969521,   8.18181801
  46441,   20.3848572,     54.65271,   8.18181801
  46442,    20.225256,    55.303688,   8.18181801
  46443,   20.0448742,   55.9492149,   8.18181801
  46444,   19.8438931,   56.5886269,   8.18181801
  46445,   19.6225204,   57.2212677,   8.18181801
  46446,   19.3809872,   57.8464928,   8.18181801
  46447,   19.1195393,   58.4636536,   8.18181801
  46448,   18.8384418,    59.072113,   8.18181801
  46449,   18.5379829,    59.671257,   8.18181801
  46450,   18.2184811,   60.2604561,   8.18181801
  46451,   17.8802586,    60.839119,   8.18181801
  46452,   17.5236607,   61.4066391,   8.18181801
  46453,   17.1490555,   61.9624405,   8.18181801
  46454,   16.7568302,   62.5059471,   8.18181801
  46455,   16.3473854,   63.0366058,   8.18181801
  46456,   15.9211416,   63.5538673,   8.18181801
  46457,   15.4785395,   64.0571976,   8.18181801
  46458,   15.0200319,   64.5460892,   8.18181801
  46459,   14.5460892,   65.0200348,   8.18181801
  46460,   14.0572014,   65.4785385,   8.18181801
  46461,   13.5538654,   65.9211426,   8.18181801
  46462,   13.0366058,   66.3473892,   8.18181801
  46463,   12.5059462,   66.7568283,   8.18181801
  46464,   11.9624405,   67.1490555,   8.18181801
  46465,   11.4066381,   67.5236588,   8.18181801
  46466,    10.839119,   67.8802567,   8.18181801
  46467,    10.260457,    68.218483,   8.18181801
  46468,   9.67125511,   68.5379868,   8.18181801
  46469,   9.07211399,   68.8384399,   8.18181801
  46470,    8.4636507,   69.1195374,   8.18181801
  46471,   7.84649086,   69.3809891,   8.18181801
  46472,   7.22126818,   69.6225204,   8.18181801
  46473,   6.58862591,    69.843895,   8.18181801
  46474,    5.9492135,   70.0448761,   8.18181801
  46475,   5.30368757,   70.2252579,   8.18181801
  46476,   4.65271044,   70.3848572,   8.18181801
  46477,   3.99695396,   70.5235062,   8.18181801
  46478,   3.33708858,   70.6410751,   8.18181801
  46479,   2.67379522,   70.7374268,   8.18181801
  46480,   2.00775385,   70.8124695,   8.18181801
  46481,   1.33965003,   70.8661346,   8.18181801
  46482,  0.670169413,   70.8983459,   8.18181801
  46483,           0.,   70.9090881,   8.18181801
  46484, -0.670169413,   70.8983459,   8.18181801
  46485,  -1.33965003,   70.8661346,   8.18181801
  46486,  -2.00775385,   70.8124695,   8.18181801
  46487,  -2.67379522,   70.7374268,   8.18181801
  46488,  -3.33708858,   70.6410751,   8.18181801
  46489,  -3.99695396,   70.5235062,   8.18181801
  46490,  -4.65271044,   70.3848572,   8.18181801
  46491,  -5.30368757,   70.2252579,   8.18181801
  46492,   -5.9492135,   70.0448761,   8.18181801
  46493,  -6.58862591,    69.843895,   8.18181801
  46494,  -7.22126818,   69.6225204,   8.18181801
  46495,  -7.84649086,   69.3809891,   8.18181801
  46496,   -8.4636507,   69.1195374,   8.18181801
  46497,  -9.07211399,   68.8384399,   8.18181801
  46498,  -9.67125511,   68.5379868,   8.18181801
  46499,   -10.260457,    68.218483,   8.18181801
  46500,   -10.839119,   67.8802567,   8.18181801
  46501,  -11.4066381,   67.5236588,   8.18181801
  46502,  -11.9624405,   67.1490555,   8.18181801
  46503,  -12.5059462,   66.7568283,   8.18181801
  46504,  -13.0366058,   66.3473892,   8.18181801
  46505,  -13.5538654,   65.9211426,   8.18181801
  46506,  -14.0572014,   65.4785385,   8.18181801
  46507,  -14.5460892,   65.0200348,   8.18181801
  46508,  -15.0200319,   64.5460892,   8.18181801
  46509,  -15.4785395,   64.0571976,   8.18181801
  46510,  -15.9211416,   63.5538673,   8.18181801
  46511,  -16.3473854,   63.0366058,   8.18181801
  46512,  -16.7568302,   62.5059471,   8.18181801
  46513,  -17.1490555,   61.9624405,   8.18181801
  46514,  -17.5236607,   61.4066391,   8.18181801
  46515,  -17.8802586,    60.839119,   8.18181801
  46516,  -18.2184811,   60.2604561,   8.18181801
  46517,  -18.5379829,    59.671257,   8.18181801
  46518,  -18.8384418,    59.072113,   8.18181801
  46519,  -19.1195393,   58.4636536,   8.18181801
  46520,  -19.3809872,   57.8464928,   8.18181801
  46521,  -19.6225204,   57.2212677,   8.18181801
  46522,  -19.8438931,   56.5886269,   8.18181801
  46523,  -20.0448742,   55.9492149,   8.18181801
  46524,   -20.225256,    55.303688,   8.18181801
  46525,  -20.3848572,     54.65271,   8.18181801
  46526,    -20.52351,   53.9969521,   8.18181801
  46527,  -20.6410732,   53.3370895,   8.18181801
  46528,  -20.7374268,   52.6737938,   8.18181801
  46529,  -20.8124752,   52.0077553,   8.18181801
  46530,  -20.8661308,   51.3396492,   8.18181801
  46531,  -20.8983479,   50.6701698,   8.18181801
  46532,   20.8983479,   50.6701698,     9.090909
  46533,   20.8661308,   51.3396492,     9.090909
  46534,   20.8124752,   52.0077553,     9.090909
  46535,   20.7374268,   52.6737938,     9.090909
  46536,   20.6410732,   53.3370895,     9.090909
  46537,     20.52351,   53.9969521,     9.090909
  46538,   20.3848572,     54.65271,     9.090909
  46539,    20.225256,    55.303688,     9.090909
  46540,   20.0448742,   55.9492149,     9.090909
  46541,   19.8438931,   56.5886269,     9.090909
  46542,   19.6225204,   57.2212677,     9.090909
  46543,   19.3809872,   57.8464928,     9.090909
  46544,   19.1195393,   58.4636536,     9.090909
  46545,   18.8384418,    59.072113,     9.090909
  46546,   18.5379829,    59.671257,     9.090909
  46547,   18.2184811,   60.2604561,     9.090909
  46548,   17.8802586,    60.839119,     9.090909
  46549,   17.5236607,   61.4066391,     9.090909
  46550,   17.1490555,   61.9624405,     9.090909
  46551,   16.7568302,   62.5059471,     9.090909
  46552,   16.3473854,   63.0366058,     9.090909
  46553,   15.9211416,   63.5538673,     9.090909
  46554,   15.4785395,   64.0571976,     9.090909
  46555,   15.0200319,   64.5460892,     9.090909
  46556,   14.5460892,   65.0200348,     9.090909
  46557,   14.0572014,   65.4785385,     9.090909
  46558,   13.5538654,   65.9211426,     9.090909
  46559,   13.0366058,   66.3473892,     9.090909
  46560,   12.5059462,   66.7568283,     9.090909
  46561,   11.9624405,   67.1490555,     9.090909
  46562,   11.4066381,   67.5236588,     9.090909
  46563,    10.839119,   67.8802567,     9.090909
  46564,    10.260457,    68.218483,     9.090909
  46565,   9.67125511,   68.5379868,     9.090909
  46566,   9.07211399,   68.8384399,     9.090909
  46567,    8.4636507,   69.1195374,     9.090909
  46568,   7.84649086,   69.3809891,     9.090909
  46569,   7.22126818,   69.6225204,     9.090909
  46570,   6.58862591,    69.843895,     9.090909
  46571,    5.9492135,   70.0448761,     9.090909
  46572,   5.30368757,   70.2252579,     9.090909
  46573,   4.65271044,   70.3848572,     9.090909
  46574,   3.99695396,   70.5235062,     9.090909
  46575,   3.33708858,   70.6410751,     9.090909
  46576,   2.67379522,   70.7374268,     9.090909
  46577,   2.00775385,   70.8124695,     9.090909
  46578,   1.33965003,   70.8661346,     9.090909
  46579,  0.670169413,   70.8983459,     9.090909
  46580,           0.,   70.9090881,     9.090909
  46581, -0.670169413,   70.8983459,     9.090909
  46582,  -1.33965003,   70.8661346,     9.090909
  46583,  -2.00775385,   70.8124695,     9.090909
  46584,  -2.67379522,   70.7374268,     9.090909
  46585,  -3.33708858,   70.6410751,     9.090909
  46586,  -3.99695396,   70.5235062,     9.090909
  46587,  -4.65271044,   70.3848572,     9.090909
  46588,  -5.30368757,   70.2252579,     9.090909
  46589,   -5.9492135,   70.0448761,     9.090909
  46590,  -6.58862591,    69.843895,     9.090909
  46591,  -7.22126818,   69.6225204,     9.090909
  46592,  -7.84649086,   69.3809891,     9.090909
  46593,   -8.4636507,   69.1195374,     9.090909
  46594,  -9.07211399,   68.8384399,     9.090909
  46595,  -9.67125511,   68.5379868,     9.090909
  46596,   -10.260457,    68.218483,     9.090909
  46597,   -10.839119,   67.8802567,     9.090909
  46598,  -11.4066381,   67.5236588,     9.090909
  46599,  -11.9624405,   67.1490555,     9.090909
  46600,  -12.5059462,   66.7568283,     9.090909
  46601,  -13.0366058,   66.3473892,     9.090909
  46602,  -13.5538654,   65.9211426,     9.090909
  46603,  -14.0572014,   65.4785385,     9.090909
  46604,  -14.5460892,   65.0200348,     9.090909
  46605,  -15.0200319,   64.5460892,     9.090909
  46606,  -15.4785395,   64.0571976,     9.090909
  46607,  -15.9211416,   63.5538673,     9.090909
  46608,  -16.3473854,   63.0366058,     9.090909
  46609,  -16.7568302,   62.5059471,     9.090909
  46610,  -17.1490555,   61.9624405,     9.090909
  46611,  -17.5236607,   61.4066391,     9.090909
  46612,  -17.8802586,    60.839119,     9.090909
  46613,  -18.2184811,   60.2604561,     9.090909
  46614,  -18.5379829,    59.671257,     9.090909
  46615,  -18.8384418,    59.072113,     9.090909
  46616,  -19.1195393,   58.4636536,     9.090909
  46617,  -19.3809872,   57.8464928,     9.090909
  46618,  -19.6225204,   57.2212677,     9.090909
  46619,  -19.8438931,   56.5886269,     9.090909
  46620,  -20.0448742,   55.9492149,     9.090909
  46621,   -20.225256,    55.303688,     9.090909
  46622,  -20.3848572,     54.65271,     9.090909
  46623,    -20.52351,   53.9969521,     9.090909
  46624,  -20.6410732,   53.3370895,     9.090909
  46625,  -20.7374268,   52.6737938,     9.090909
  46626,  -20.8124752,   52.0077553,     9.090909
  46627,  -20.8661308,   51.3396492,     9.090909
  46628,  -20.8983479,   50.6701698,     9.090909
  46629,   29.0925636,   49.2065392,     9.090909
  46630,   28.1851234,   49.2065392,     9.090909
  46631,   27.2776871,   49.2065392,     9.090909
  46632,   26.3702469,   49.2065392,     9.090909
  46633,   25.4628105,   49.2065392,     9.090909
  46634,   24.5523415,   49.2065392,     9.090909
  46635,   23.6418743,   49.2065392,     9.090909
  46636,   22.7314053,   49.2065392,     9.090909
  46637,   21.8209362,   49.2065392,     9.090909
  46638,   20.9104671,   49.2065392,     9.090909
  46639,   29.0942154,   48.4130783,     9.090909
  46640,   28.1884289,   48.4130783,     9.090909
  46641,   27.2826462,   48.4130783,     9.090909
  46642,   26.3768597,   48.4130783,     9.090909
  46643,   25.4710751,   48.4130783,     9.090909
  46644,   24.5592289,   48.4130783,     9.090909
  46645,   23.6473827,   48.4130783,     9.090909
  46646,   22.7355366,   48.4130783,     9.090909
  46647,   21.8236923,   48.4130783,     9.090909
  46648,   20.9118443,   48.4130783,     9.090909
  46649,   29.0958691,   47.6196175,     9.090909
  46650,   28.1917362,   47.6196175,     9.090909
  46651,   27.2876034,   47.6196175,     9.090909
  46652,   26.3834705,   47.6196175,     9.090909
  46653,   25.4793396,   47.6196175,     9.090909
  46654,   24.5661144,   47.6196175,     9.090909
  46655,   23.6528931,   47.6196175,     9.090909
  46656,   22.7396679,   47.6196175,     9.090909
  46657,   21.8264465,   47.6196175,     9.090909
  46658,   20.9132233,   47.6196175,     9.090909
  46659,   29.0975208,   46.8261566,     9.090909
  46660,   28.1950417,   46.8261566,     9.090909
  46661,   27.2925625,   46.8261566,     9.090909
  46662,   26.3900814,   46.8261566,     9.090909
  46663,   25.4876041,   46.8261566,     9.090909
  46664,   24.5730019,   46.8261566,     9.090909
  46665,   23.6584034,   46.8261566,     9.090909
  46666,   22.7438011,   46.8261566,     9.090909
  46667,   21.8292007,   46.8261566,     9.090909
  46668,   20.9146004,   46.8261566,     9.090909
  46669,   29.0991745,   46.0326958,     9.090909
  46670,   28.1983471,   46.0326958,     9.090909
  46671,   27.2975216,   46.0326958,     9.090909
  46672,   26.3966942,   46.0326958,     9.090909
  46673,   25.4958687,   46.0326958,     9.090909
  46674,   24.5798893,   46.0326958,     9.090909
  46675,   23.6639118,   46.0326958,     9.090909
  46676,   22.7479324,   46.0326958,     9.090909
  46677,   21.8319569,   46.0326958,     9.090909
  46678,   20.9159775,   46.0326958,     9.090909
  46679,   29.1008282,   45.2392349,     9.090909
  46680,   28.2016525,   45.2392349,     9.090909
  46681,   27.3024807,   45.2392349,     9.090909
  46682,   26.4033051,   45.2392349,     9.090909
  46683,   25.5041332,   45.2392349,     9.090909
  46684,   24.5867767,   45.2392349,     9.090909
  46685,   23.6694221,   45.2392349,     9.090909
  46686,   22.7520657,   45.2392349,     9.090909
  46687,   21.8347111,   45.2392349,     9.090909
  46688,   20.9173546,   45.2392349,     9.090909
  46689,   29.1008282,   44.4488029,     9.090909
  46690,   28.2016525,   44.4488029,     9.090909
  46691,   27.3024807,   44.4488029,     9.090909
  46692,   26.4033051,   44.4488029,     9.090909
  46693,   25.5041332,   44.4488029,     9.090909
  46694,   24.5867767,   44.4488029,     9.090909
  46695,   23.6694221,   44.4488029,     9.090909
  46696,   22.7520657,   44.4488029,     9.090909
  46697,   21.8347111,   44.4488029,     9.090909
  46698,   20.9173546,   44.4488029,     9.090909
  46699,   29.1008282,   43.6583748,     9.090909
  46700,   28.2016525,   43.6583748,     9.090909
  46701,   27.3024807,   43.6583748,     9.090909
  46702,   26.4033051,   43.6583748,     9.090909
  46703,   25.5041332,   43.6583748,     9.090909
  46704,   24.5867767,   43.6583748,     9.090909
  46705,   23.6694221,   43.6583748,     9.090909
  46706,   22.7520657,   43.6583748,     9.090909
  46707,   21.8347111,   43.6583748,     9.090909
  46708,   20.9173546,   43.6583748,     9.090909
  46709,   29.1008282,   42.8679428,     9.090909
  46710,   28.2016525,   42.8679428,     9.090909
  46711,   27.3024807,   42.8679428,     9.090909
  46712,   26.4033051,   42.8679428,     9.090909
  46713,   25.5041332,   42.8679428,     9.090909
  46714,   24.5867767,   42.8679428,     9.090909
  46715,   23.6694221,   42.8679428,     9.090909
  46716,   22.7520657,   42.8679428,     9.090909
  46717,   21.8347111,   42.8679428,     9.090909
  46718,   20.9173546,   42.8679428,     9.090909
  46719,   29.1008282,   42.0775108,     9.090909
  46720,   28.2016525,   42.0775108,     9.090909
  46721,   27.3024807,   42.0775108,     9.090909
  46722,   26.4033051,   42.0775108,     9.090909
  46723,   25.5041332,   42.0775108,     9.090909
  46724,   24.5867767,   42.0775108,     9.090909
  46725,   23.6694221,   42.0775108,     9.090909
  46726,   22.7520657,   42.0775108,     9.090909
  46727,   21.8347111,   42.0775108,     9.090909
  46728,   20.9173546,   42.0775108,     9.090909
  46729,   29.1008282,   41.2870827,     9.090909
  46730,   28.2016525,   41.2870827,     9.090909
  46731,   27.3024807,   41.2870827,     9.090909
  46732,   26.4033051,   41.2870827,     9.090909
  46733,   25.5041332,   41.2870827,     9.090909
  46734,   24.5867767,   41.2870827,     9.090909
  46735,   23.6694221,   41.2870827,     9.090909
  46736,   22.7520657,   41.2870827,     9.090909
  46737,   21.8347111,   41.2870827,     9.090909
  46738,   20.9173546,   41.2870827,     9.090909
  46739,   29.1008282,   40.4966507,     9.090909
  46740,   28.2016525,   40.4966507,     9.090909
  46741,   27.3024807,   40.4966507,     9.090909
  46742,   26.4033051,   40.4966507,     9.090909
  46743,   25.5041332,   40.4966507,     9.090909
  46744,   24.5867767,   40.4966507,     9.090909
  46745,   23.6694221,   40.4966507,     9.090909
  46746,   22.7520657,   40.4966507,     9.090909
  46747,   21.8347111,   40.4966507,     9.090909
  46748,   20.9173546,   40.4966507,     9.090909
  46749,   29.1008282,   39.7062187,     9.090909
  46750,   28.2016525,   39.7062187,     9.090909
  46751,   27.3024807,   39.7062187,     9.090909
  46752,   26.4033051,   39.7062187,     9.090909
  46753,   25.5041332,   39.7062187,     9.090909
  46754,   24.5867767,   39.7062187,     9.090909
  46755,   23.6694221,   39.7062187,     9.090909
  46756,   22.7520657,   39.7062187,     9.090909
  46757,   21.8347111,   39.7062187,     9.090909
  46758,   20.9173546,   39.7062187,     9.090909
  46759,   29.1008282,   38.9157906,     9.090909
  46760,   28.2016525,   38.9157906,     9.090909
  46761,   27.3024807,   38.9157906,     9.090909
  46762,   26.4033051,   38.9157906,     9.090909
  46763,   25.5041332,   38.9157906,     9.090909
  46764,   24.5867767,   38.9157906,     9.090909
  46765,   23.6694221,   38.9157906,     9.090909
  46766,   22.7520657,   38.9157906,     9.090909
  46767,   21.8347111,   38.9157906,     9.090909
  46768,   20.9173546,   38.9157906,     9.090909
  46769,   29.1008282,   38.1253586,     9.090909
  46770,   28.2016525,   38.1253586,     9.090909
  46771,   27.3024807,   38.1253586,     9.090909
  46772,   26.4033051,   38.1253586,     9.090909
  46773,   25.5041332,   38.1253586,     9.090909
  46774,   24.5867767,   38.1253586,     9.090909
  46775,   23.6694221,   38.1253586,     9.090909
  46776,   22.7520657,   38.1253586,     9.090909
  46777,   21.8347111,   38.1253586,     9.090909
  46778,   20.9173546,   38.1253586,     9.090909
  46779,   29.1008282,   37.3349266,     9.090909
  46780,   28.2016525,   37.3349266,     9.090909
  46781,   27.3024807,   37.3349266,     9.090909
  46782,   26.4033051,   37.3349266,     9.090909
  46783,   25.5041332,   37.3349266,     9.090909
  46784,   24.5867767,   37.3349266,     9.090909
  46785,   23.6694221,   37.3349266,     9.090909
  46786,   22.7520657,   37.3349266,     9.090909
  46787,   21.8347111,   37.3349266,     9.090909
  46788,   20.9173546,   37.3349266,     9.090909
  46789,   29.1008282,   36.5444984,     9.090909
  46790,   28.2016525,   36.5444984,     9.090909
  46791,   27.3024807,   36.5444984,     9.090909
  46792,   26.4033051,   36.5444984,     9.090909
  46793,   25.5041332,   36.5444984,     9.090909
  46794,   24.5867767,   36.5444984,     9.090909
  46795,   23.6694221,   36.5444984,     9.090909
  46796,   22.7520657,   36.5444984,     9.090909
  46797,   21.8347111,   36.5444984,     9.090909
  46798,   20.9173546,   36.5444984,     9.090909
  46799,   29.1008282,   35.7540665,     9.090909
  46800,   28.2016525,   35.7540665,     9.090909
  46801,   27.3024807,   35.7540665,     9.090909
  46802,   26.4033051,   35.7540665,     9.090909
  46803,   25.5041332,   35.7540665,     9.090909
  46804,   24.5867767,   35.7540665,     9.090909
  46805,   23.6694221,   35.7540665,     9.090909
  46806,   22.7520657,   35.7540665,     9.090909
  46807,   21.8347111,   35.7540665,     9.090909
  46808,   20.9173546,   35.7540665,     9.090909
  46809,   29.1008282,   34.9636345,     9.090909
  46810,   28.2016525,   34.9636345,     9.090909
  46811,   27.3024807,   34.9636345,     9.090909
  46812,   26.4033051,   34.9636345,     9.090909
  46813,   25.5041332,   34.9636345,     9.090909
  46814,   24.5867767,   34.9636345,     9.090909
  46815,   23.6694221,   34.9636345,     9.090909
  46816,   22.7520657,   34.9636345,     9.090909
  46817,   21.8347111,   34.9636345,     9.090909
  46818,   20.9173546,   34.9636345,     9.090909
  46819,   29.1008282,   34.1732063,     9.090909
  46820,   28.2016525,   34.1732063,     9.090909
  46821,   27.3024807,   34.1732063,     9.090909
  46822,   26.4033051,   34.1732063,     9.090909
  46823,   25.5041332,   34.1732063,     9.090909
  46824,   24.5867767,   34.1732063,     9.090909
  46825,   23.6694221,   34.1732063,     9.090909
  46826,   22.7520657,   34.1732063,     9.090909
  46827,   21.8347111,   34.1732063,     9.090909
  46828,   20.9173546,   34.1732063,     9.090909
  46829,   29.1008282,   33.3827744,     9.090909
  46830,   28.2016525,   33.3827744,     9.090909
  46831,   27.3024807,   33.3827744,     9.090909
  46832,   26.4033051,   33.3827744,     9.090909
  46833,   25.5041332,   33.3827744,     9.090909
  46834,   24.5867767,   33.3827744,     9.090909
  46835,   23.6694221,   33.3827744,     9.090909
  46836,   22.7520657,   33.3827744,     9.090909
  46837,   21.8347111,   33.3827744,     9.090909
  46838,   20.9173546,   33.3827744,     9.090909
  46839,   29.1008282,   32.5923462,     9.090909
  46840,   28.2016525,   32.5923462,     9.090909
  46841,   27.3024807,   32.5923462,     9.090909
  46842,   26.4033051,   32.5923462,     9.090909
  46843,   25.5041332,   32.5923462,     9.090909
  46844,   24.5867767,   32.5923462,     9.090909
  46845,   23.6694221,   32.5923462,     9.090909
  46846,   22.7520657,   32.5923462,     9.090909
  46847,   21.8347111,   32.5923462,     9.090909
  46848,   20.9173546,   32.5923462,     9.090909
  46849,   29.1008282,   31.8019142,     9.090909
  46850,   28.2016525,   31.8019142,     9.090909
  46851,   27.3024807,   31.8019142,     9.090909
  46852,   26.4033051,   31.8019142,     9.090909
  46853,   25.5041332,   31.8019142,     9.090909
  46854,   24.5867767,   31.8019142,     9.090909
  46855,   23.6694221,   31.8019142,     9.090909
  46856,   22.7520657,   31.8019142,     9.090909
  46857,   21.8347111,   31.8019142,     9.090909
  46858,   20.9173546,   31.8019142,     9.090909
  46859,   29.1008282,   31.0114841,     9.090909
  46860,   28.2016525,   31.0114841,     9.090909
  46861,   27.3024807,   31.0114841,     9.090909
  46862,   26.4033051,   31.0114841,     9.090909
  46863,   25.5041332,   31.0114841,     9.090909
  46864,   24.5867767,   31.0114841,     9.090909
  46865,   23.6694221,   31.0114841,     9.090909
  46866,   22.7520657,   31.0114841,     9.090909
  46867,   21.8347111,   31.0114841,     9.090909
  46868,   20.9173546,   31.0114841,     9.090909
  46869,   29.1008282,   30.2210522,     9.090909
  46870,   28.2016525,   30.2210522,     9.090909
  46871,   27.3024807,   30.2210522,     9.090909
  46872,   26.4033051,   30.2210522,     9.090909
  46873,   25.5041332,   30.2210522,     9.090909
  46874,   24.5867767,   30.2210522,     9.090909
  46875,   23.6694221,   30.2210522,     9.090909
  46876,   22.7520657,   30.2210522,     9.090909
  46877,   21.8347111,   30.2210522,     9.090909
  46878,   20.9173546,   30.2210522,     9.090909
  46879,   29.1008282,   29.4306221,     9.090909
  46880,   28.2016525,   29.4306221,     9.090909
  46881,   27.3024807,   29.4306221,     9.090909
  46882,   26.4033051,   29.4306221,     9.090909
  46883,   25.5041332,   29.4306221,     9.090909
  46884,   24.5867767,   29.4306221,     9.090909
  46885,   23.6694221,   29.4306221,     9.090909
  46886,   22.7520657,   29.4306221,     9.090909
  46887,   21.8347111,   29.4306221,     9.090909
  46888,   20.9173546,   29.4306221,     9.090909
  46889,   29.1008282,    28.640192,     9.090909
  46890,   28.2016525,    28.640192,     9.090909
  46891,   27.3024807,    28.640192,     9.090909
  46892,   26.4033051,    28.640192,     9.090909
  46893,   25.5041332,    28.640192,     9.090909
  46894,   24.5867767,    28.640192,     9.090909
  46895,   23.6694221,    28.640192,     9.090909
  46896,   22.7520657,    28.640192,     9.090909
  46897,   21.8347111,    28.640192,     9.090909
  46898,   20.9173546,    28.640192,     9.090909
  46899,   29.1008282,   27.8497601,     9.090909
  46900,   28.2016525,   27.8497601,     9.090909
  46901,   27.3024807,   27.8497601,     9.090909
  46902,   26.4033051,   27.8497601,     9.090909
  46903,   25.5041332,   27.8497601,     9.090909
  46904,   24.5867767,   27.8497601,     9.090909
  46905,   23.6694221,   27.8497601,     9.090909
  46906,   22.7520657,   27.8497601,     9.090909
  46907,   21.8347111,   27.8497601,     9.090909
  46908,   20.9173546,   27.8497601,     9.090909
  46909,   29.1008282,     27.05933,     9.090909
  46910,   28.2016525,     27.05933,     9.090909
  46911,   27.3024807,     27.05933,     9.090909
  46912,   26.4033051,     27.05933,     9.090909
  46913,   25.5041332,     27.05933,     9.090909
  46914,   24.5867767,     27.05933,     9.090909
  46915,   23.6694221,     27.05933,     9.090909
  46916,   22.7520657,     27.05933,     9.090909
  46917,   21.8347111,     27.05933,     9.090909
  46918,   20.9173546,     27.05933,     9.090909
  46919,   29.1008282,   26.2688999,     9.090909
  46920,   28.2016525,   26.2688999,     9.090909
  46921,   27.3024807,   26.2688999,     9.090909
  46922,   26.4033051,   26.2688999,     9.090909
  46923,   25.5041332,   26.2688999,     9.090909
  46924,   24.5867767,   26.2688999,     9.090909
  46925,   23.6694221,   26.2688999,     9.090909
  46926,   22.7520657,   26.2688999,     9.090909
  46927,   21.8347111,   26.2688999,     9.090909
  46928,   20.9173546,   26.2688999,     9.090909
  46929,   29.1008282,   25.4784698,     9.090909
  46930,   28.2016525,   25.4784698,     9.090909
  46931,   27.3024807,   25.4784698,     9.090909
  46932,   26.4033051,   25.4784698,     9.090909
  46933,   25.5041332,   25.4784698,     9.090909
  46934,   24.5867767,   25.4784698,     9.090909
  46935,   23.6694221,   25.4784698,     9.090909
  46936,   22.7520657,   25.4784698,     9.090909
  46937,   21.8347111,   25.4784698,     9.090909
  46938,   20.9173546,   25.4784698,     9.090909
  46939,    29.099411,   24.6958313,     9.090909
  46940,   28.1988201,   24.6958313,     9.090909
  46941,   27.2982292,   24.6958313,     9.090909
  46942,   26.3976383,   24.6958313,     9.090909
  46943,   25.4970493,   24.6958313,     9.090909
  46944,   24.5808735,   24.6958313,     9.090909
  46945,   23.6646996,   24.6958313,     9.090909
  46946,   22.7485237,   24.6958313,     9.090909
  46947,   21.8323498,   24.6958313,     9.090909
  46948,   20.9161739,   24.6958313,     9.090909
  46949,   29.0979939,   23.9131927,     9.090909
  46950,   28.1959858,   23.9131927,     9.090909
  46951,   27.2939796,   23.9131927,     9.090909
  46952,   26.3919716,   23.9131927,     9.090909
  46953,   25.4899654,   23.9131927,     9.090909
  46954,   24.5749702,   23.9131927,     9.090909
  46955,    23.659977,   23.9131927,     9.090909
  46956,   22.7449818,   23.9131927,     9.090909
  46957,   21.8299885,   23.9131927,     9.090909
  46958,   20.9149933,   23.9131927,     9.090909
  46959,   29.0965767,   23.1305542,     9.090909
  46960,   28.1931515,   23.1305542,     9.090909
  46961,   27.2897282,   23.1305542,     9.090909
  46962,   26.3863049,   23.1305542,     9.090909
  46963,   25.4828815,   23.1305542,     9.090909
  46964,    24.569067,   23.1305542,     9.090909
  46965,   23.6552544,   23.1305542,     9.090909
  46966,   22.7414398,   23.1305542,     9.090909
  46967,   21.8276272,   23.1305542,     9.090909
  46968,   20.9138126,   23.1305542,     9.090909
  46969,   29.0951595,   22.3479156,     9.090909
  46970,   28.1903191,   22.3479156,     9.090909
  46971,   27.2854786,   22.3479156,     9.090909
  46972,   26.3806381,   22.3479156,     9.090909
  46973,   25.4757977,   22.3479156,     9.090909
  46974,   24.5631638,   22.3479156,     9.090909
  46975,   23.6505318,   22.3479156,     9.090909
  46976,   22.7378979,   22.3479156,     9.090909
  46977,   21.8252659,   22.3479156,     9.090909
  46978,    20.912632,   22.3479156,     9.090909
  46979,   29.0937443,   21.5652771,     9.090909
  46980,   28.1874847,   21.5652771,     9.090909
  46981,    27.281229,   21.5652771,     9.090909
  46982,   26.3749695,   21.5652771,     9.090909
  46983,   25.4687138,   21.5652771,     9.090909
  46984,   24.5572605,   21.5652771,     9.090909
  46985,   23.6458092,   21.5652771,     9.090909
  46986,   22.7343559,   21.5652771,     9.090909
  46987,   21.8229046,   21.5652771,     9.090909
  46988,   20.9114513,   21.5652771,     9.090909
  46989,   29.0923271,   20.7826385,     9.090909
  46990,   28.1846523,   20.7826385,     9.090909
  46991,   27.2769775,   20.7826385,     9.090909
  46992,   26.3693027,   20.7826385,     9.090909
  46993,   25.4616299,   20.7826385,     9.090909
  46994,   24.5513573,   20.7826385,     9.090909
  46995,   23.6410866,   20.7826385,     9.090909
  46996,    22.730814,   20.7826385,     9.090909
  46997,   21.8205433,   20.7826385,     9.090909
  46998,   20.9102707,   20.7826385,     9.090909
  46999,   29.0942154,   49.2025528,   8.18181801
  47000,   28.1884289,   49.2025528,   8.18181801
  47001,   27.2826443,   49.2025528,   8.18181801
  47002,   26.3768597,   49.2025528,   8.18181801
  47003,   25.4710751,   49.2025528,   8.18181801
  47004,   24.5592289,   49.2025528,   8.18181801
  47005,   23.6473827,   49.2025528,   8.18181801
  47006,   22.7355366,   49.2025528,   8.18181801
  47007,   21.8236923,   49.2025528,   8.18181801
  47008,   20.9118443,   49.2025528,   8.18181801
  47009,   29.0975208,   48.4051018,   8.18181801
  47010,   28.1950417,   48.4051018,   8.18181801
  47011,   27.2925625,   48.4051018,   8.18181801
  47012,   26.3900814,   48.4051018,   8.18181801
  47013,   25.4876041,   48.4051018,   8.18181801
  47014,   24.5730019,   48.4051018,   8.18181801
  47015,   23.6584034,   48.4051018,   8.18181801
  47016,   22.7438011,   48.4051018,   8.18181801
  47017,   21.8292007,   48.4051018,   8.18181801
  47018,   20.9146004,   48.4051018,   8.18181801
  47019,   29.1008263,   47.6076546,   8.18181801
  47020,   28.2016525,   47.6076546,   8.18181801
  47021,   27.3024807,   47.6076546,   8.18181801
  47022,   26.4033051,   47.6076546,   8.18181801
  47023,   25.5041332,   47.6076546,   8.18181801
  47024,   24.5867767,   47.6076546,   8.18181801
  47025,   23.6694221,   47.6076546,   8.18181801
  47026,   22.7520657,   47.6076546,   8.18181801
  47027,   21.8347111,   47.6076546,   8.18181801
  47028,   20.9173546,   47.6076546,   8.18181801
  47029,   29.1041336,   46.8102074,   8.18181801
  47030,   28.2082634,   46.8102074,   8.18181801
  47031,    27.312397,   46.8102074,   8.18181801
  47032,   26.4165287,   46.8102074,   8.18181801
  47033,   25.5206623,   46.8102074,   8.18181801
  47034,   24.6005497,   46.8102074,   8.18181801
  47035,   23.6804409,   46.8102074,   8.18181801
  47036,   22.7603302,   46.8102074,   8.18181801
  47037,   21.8402214,   46.8102074,   8.18181801
  47038,   20.9201088,   46.8102074,   8.18181801
  47039,    29.107439,   46.0127602,   8.18181801
  47040,   28.2148762,   46.0127602,   8.18181801
  47041,   27.3223152,   46.0127602,   8.18181801
  47042,   26.4297523,   46.0127602,   8.18181801
  47043,   25.5371895,   46.0127602,   8.18181801
  47044,   24.6143246,   46.0127602,   8.18181801
  47045,   23.6914597,   46.0127602,   8.18181801
  47046,   22.7685947,   46.0127602,   8.18181801
  47047,   21.8457298,   46.0127602,   8.18181801
  47048,   20.9228649,   46.0127602,   8.18181801
  47049,   29.1107445,   45.2153091,   8.18181801
  47050,    28.221487,   45.2153091,   8.18181801
  47051,   27.3322315,   45.2153091,   8.18181801
  47052,   26.4429741,   45.2153091,   8.18181801
  47053,   25.5537186,   45.2153091,   8.18181801
  47054,   24.6280994,   45.2153091,   8.18181801
  47055,   23.7024803,   45.2153091,   8.18181801
  47056,   22.7768593,   45.2153091,   8.18181801
  47057,   21.8512402,   45.2153091,   8.18181801
  47058,   20.9256191,   45.2153091,   8.18181801
  47059,   29.1107445,   44.4239235,   8.18181801
  47060,    28.221487,   44.4239235,   8.18181801
  47061,   27.3322315,   44.4239235,   8.18181801
  47062,   26.4429741,   44.4239235,   8.18181801
  47063,   25.5537186,   44.4239235,   8.18181801
  47064,   24.6280994,   44.4239235,   8.18181801
  47065,   23.7024803,   44.4239235,   8.18181801
  47066,   22.7768593,   44.4239235,   8.18181801
  47067,   21.8512402,   44.4239235,   8.18181801
  47068,   20.9256191,   44.4239235,   8.18181801
  47069,   29.1107445,    43.632534,   8.18181801
  47070,    28.221487,    43.632534,   8.18181801
  47071,   27.3322315,    43.632534,   8.18181801
  47072,   26.4429741,    43.632534,   8.18181801
  47073,   25.5537186,    43.632534,   8.18181801
  47074,   24.6280994,    43.632534,   8.18181801
  47075,   23.7024803,    43.632534,   8.18181801
  47076,   22.7768593,    43.632534,   8.18181801
  47077,   21.8512402,    43.632534,   8.18181801
  47078,   20.9256191,    43.632534,   8.18181801
  47079,   29.1107445,   42.8411484,   8.18181801
  47080,    28.221487,   42.8411484,   8.18181801
  47081,   27.3322315,   42.8411484,   8.18181801
  47082,   26.4429741,   42.8411484,   8.18181801
  47083,   25.5537186,   42.8411484,   8.18181801
  47084,   24.6280994,   42.8411484,   8.18181801
  47085,   23.7024803,   42.8411484,   8.18181801
  47086,   22.7768593,   42.8411484,   8.18181801
  47087,   21.8512402,   42.8411484,   8.18181801
  47088,   20.9256191,   42.8411484,   8.18181801
  47089,   29.1107445,   42.0497589,   8.18181801
  47090,    28.221487,   42.0497589,   8.18181801
  47091,   27.3322315,   42.0497589,   8.18181801
  47092,   26.4429741,   42.0497589,   8.18181801
  47093,   25.5537186,   42.0497589,   8.18181801
  47094,   24.6280994,   42.0497589,   8.18181801
  47095,   23.7024803,   42.0497589,   8.18181801
  47096,   22.7768593,   42.0497589,   8.18181801
  47097,   21.8512402,   42.0497589,   8.18181801
  47098,   20.9256191,   42.0497589,   8.18181801
  47099,   29.1107445,   41.2583733,   8.18181801
  47100,    28.221487,   41.2583733,   8.18181801
  47101,   27.3322315,   41.2583733,   8.18181801
  47102,   26.4429741,   41.2583733,   8.18181801
  47103,   25.5537186,   41.2583733,   8.18181801
  47104,   24.6280994,   41.2583733,   8.18181801
  47105,   23.7024803,   41.2583733,   8.18181801
  47106,   22.7768593,   41.2583733,   8.18181801
  47107,   21.8512402,   41.2583733,   8.18181801
  47108,   20.9256191,   41.2583733,   8.18181801
  47109,   29.1107445,   40.4669838,   8.18181801
  47110,    28.221487,   40.4669838,   8.18181801
  47111,   27.3322315,   40.4669838,   8.18181801
  47112,   26.4429741,   40.4669838,   8.18181801
  47113,   25.5537186,   40.4669838,   8.18181801
  47114,   24.6280994,   40.4669838,   8.18181801
  47115,   23.7024803,   40.4669838,   8.18181801
  47116,   22.7768593,   40.4669838,   8.18181801
  47117,   21.8512402,   40.4669838,   8.18181801
  47118,   20.9256191,   40.4669838,   8.18181801
  47119,   29.1107445,   39.6755981,   8.18181801
  47120,    28.221487,   39.6755981,   8.18181801
  47121,   27.3322315,   39.6755981,   8.18181801
  47122,   26.4429741,   39.6755981,   8.18181801
  47123,   25.5537186,   39.6755981,   8.18181801
  47124,   24.6280994,   39.6755981,   8.18181801
  47125,   23.7024803,   39.6755981,   8.18181801
  47126,   22.7768593,   39.6755981,   8.18181801
  47127,   21.8512402,   39.6755981,   8.18181801
  47128,   20.9256191,   39.6755981,   8.18181801
  47129,   29.1107445,   38.8842087,   8.18181801
  47130,    28.221487,   38.8842087,   8.18181801
  47131,   27.3322315,   38.8842087,   8.18181801
  47132,   26.4429741,   38.8842087,   8.18181801
  47133,   25.5537186,   38.8842087,   8.18181801
  47134,   24.6280994,   38.8842087,   8.18181801
  47135,   23.7024803,   38.8842087,   8.18181801
  47136,   22.7768593,   38.8842087,   8.18181801
  47137,   21.8512402,   38.8842087,   8.18181801
  47138,   20.9256191,   38.8842087,   8.18181801
  47139,   29.1107445,    38.092823,   8.18181801
  47140,    28.221487,    38.092823,   8.18181801
  47141,   27.3322315,    38.092823,   8.18181801
  47142,   26.4429741,    38.092823,   8.18181801
  47143,   25.5537186,    38.092823,   8.18181801
  47144,   24.6280994,    38.092823,   8.18181801
  47145,   23.7024803,    38.092823,   8.18181801
  47146,   22.7768593,    38.092823,   8.18181801
  47147,   21.8512402,    38.092823,   8.18181801
  47148,   20.9256191,    38.092823,   8.18181801
  47149,   29.1107445,   37.3014336,   8.18181801
  47150,    28.221487,   37.3014336,   8.18181801
  47151,   27.3322315,   37.3014336,   8.18181801
  47152,   26.4429741,   37.3014336,   8.18181801
  47153,   25.5537186,   37.3014336,   8.18181801
  47154,   24.6280994,   37.3014336,   8.18181801
  47155,   23.7024803,   37.3014336,   8.18181801
  47156,   22.7768593,   37.3014336,   8.18181801
  47157,   21.8512402,   37.3014336,   8.18181801
  47158,   20.9256191,   37.3014336,   8.18181801
  47159,   29.1107445,   36.5100479,   8.18181801
  47160,    28.221487,   36.5100479,   8.18181801
  47161,   27.3322315,   36.5100479,   8.18181801
  47162,   26.4429741,   36.5100479,   8.18181801
  47163,   25.5537186,   36.5100479,   8.18181801
  47164,   24.6280994,   36.5100479,   8.18181801
  47165,   23.7024803,   36.5100479,   8.18181801
  47166,   22.7768593,   36.5100479,   8.18181801
  47167,   21.8512402,   36.5100479,   8.18181801
  47168,   20.9256191,   36.5100479,   8.18181801
  47169,   29.1107445,   35.7186584,   8.18181801
  47170,    28.221487,   35.7186584,   8.18181801
  47171,   27.3322315,   35.7186584,   8.18181801
  47172,   26.4429741,   35.7186584,   8.18181801
  47173,   25.5537186,   35.7186584,   8.18181801
  47174,   24.6280994,   35.7186584,   8.18181801
  47175,   23.7024803,   35.7186584,   8.18181801
  47176,   22.7768593,   35.7186584,   8.18181801
  47177,   21.8512402,   35.7186584,   8.18181801
  47178,   20.9256191,   35.7186584,   8.18181801
  47179,   29.1107445,   34.9272728,   8.18181801
  47180,    28.221487,   34.9272728,   8.18181801
  47181,   27.3322315,   34.9272728,   8.18181801
  47182,   26.4429741,   34.9272728,   8.18181801
  47183,   25.5537186,   34.9272728,   8.18181801
  47184,   24.6280994,   34.9272728,   8.18181801
  47185,   23.7024803,   34.9272728,   8.18181801
  47186,   22.7768593,   34.9272728,   8.18181801
  47187,   21.8512402,   34.9272728,   8.18181801
  47188,   20.9256191,   34.9272728,   8.18181801
  47189,   29.1107445,   34.1358833,   8.18181801
  47190,    28.221487,   34.1358833,   8.18181801
  47191,   27.3322315,   34.1358833,   8.18181801
  47192,   26.4429741,   34.1358833,   8.18181801
  47193,   25.5537186,   34.1358833,   8.18181801
  47194,   24.6280994,   34.1358833,   8.18181801
  47195,   23.7024803,   34.1358833,   8.18181801
  47196,   22.7768593,   34.1358833,   8.18181801
  47197,   21.8512402,   34.1358833,   8.18181801
  47198,   20.9256191,   34.1358833,   8.18181801
  47199,   29.1107445,   33.3444977,   8.18181801
  47200,    28.221487,   33.3444977,   8.18181801
  47201,   27.3322315,   33.3444977,   8.18181801
  47202,   26.4429741,   33.3444977,   8.18181801
  47203,   25.5537186,   33.3444977,   8.18181801
  47204,   24.6280994,   33.3444977,   8.18181801
  47205,   23.7024803,   33.3444977,   8.18181801
  47206,   22.7768593,   33.3444977,   8.18181801
  47207,   21.8512402,   33.3444977,   8.18181801
  47208,   20.9256191,   33.3444977,   8.18181801
  47209,   29.1107445,   32.5531082,   8.18181801
  47210,    28.221487,   32.5531082,   8.18181801
  47211,   27.3322315,   32.5531082,   8.18181801
  47212,   26.4429741,   32.5531082,   8.18181801
  47213,   25.5537186,   32.5531082,   8.18181801
  47214,   24.6280994,   32.5531082,   8.18181801
  47215,   23.7024803,   32.5531082,   8.18181801
  47216,   22.7768593,   32.5531082,   8.18181801
  47217,   21.8512402,   32.5531082,   8.18181801
  47218,   20.9256191,   32.5531082,   8.18181801
  47219,   29.1107445,   31.7617226,   8.18181801
  47220,    28.221487,   31.7617226,   8.18181801
  47221,   27.3322315,   31.7617226,   8.18181801
  47222,   26.4429741,   31.7617226,   8.18181801
  47223,   25.5537186,   31.7617226,   8.18181801
  47224,   24.6280994,   31.7617226,   8.18181801
  47225,   23.7024803,   31.7617226,   8.18181801
  47226,   22.7768593,   31.7617226,   8.18181801
  47227,   21.8512402,   31.7617226,   8.18181801
  47228,   20.9256191,   31.7617226,   8.18181801
  47229,   29.1107445,    30.970335,   8.18181801
  47230,    28.221487,    30.970335,   8.18181801
  47231,   27.3322315,    30.970335,   8.18181801
  47232,   26.4429741,    30.970335,   8.18181801
  47233,   25.5537186,    30.970335,   8.18181801
  47234,   24.6280994,    30.970335,   8.18181801
  47235,   23.7024803,    30.970335,   8.18181801
  47236,   22.7768593,    30.970335,   8.18181801
  47237,   21.8512402,    30.970335,   8.18181801
  47238,   20.9256191,    30.970335,   8.18181801
  47239,   29.1107445,   30.1789474,   8.18181801
  47240,    28.221487,   30.1789474,   8.18181801
  47241,   27.3322315,   30.1789474,   8.18181801
  47242,   26.4429741,   30.1789474,   8.18181801
  47243,   25.5537186,   30.1789474,   8.18181801
  47244,   24.6280994,   30.1789474,   8.18181801
  47245,   23.7024803,   30.1789474,   8.18181801
  47246,   22.7768593,   30.1789474,   8.18181801
  47247,   21.8512402,   30.1789474,   8.18181801
  47248,   20.9256191,   30.1789474,   8.18181801
  47249,   29.1107445,   29.3875599,   8.18181801
  47250,    28.221487,   29.3875599,   8.18181801
  47251,   27.3322315,   29.3875599,   8.18181801
  47252,   26.4429741,   29.3875599,   8.18181801
  47253,   25.5537186,   29.3875599,   8.18181801
  47254,   24.6280994,   29.3875599,   8.18181801
  47255,   23.7024803,   29.3875599,   8.18181801
  47256,   22.7768593,   29.3875599,   8.18181801
  47257,   21.8512402,   29.3875599,   8.18181801
  47258,   20.9256191,   29.3875599,   8.18181801
  47259,   29.1107445,   28.5961723,   8.18181801
  47260,    28.221487,   28.5961723,   8.18181801
  47261,   27.3322315,   28.5961723,   8.18181801
  47262,   26.4429741,   28.5961723,   8.18181801
  47263,   25.5537186,   28.5961723,   8.18181801
  47264,   24.6280994,   28.5961723,   8.18181801
  47265,   23.7024803,   28.5961723,   8.18181801
  47266,   22.7768593,   28.5961723,   8.18181801
  47267,   21.8512402,   28.5961723,   8.18181801
  47268,   20.9256191,   28.5961723,   8.18181801
  47269,   29.1107445,   27.8047848,   8.18181801
  47270,    28.221487,   27.8047848,   8.18181801
  47271,   27.3322315,   27.8047848,   8.18181801
  47272,   26.4429741,   27.8047848,   8.18181801
  47273,   25.5537186,   27.8047848,   8.18181801
  47274,   24.6280994,   27.8047848,   8.18181801
  47275,   23.7024803,   27.8047848,   8.18181801
  47276,   22.7768593,   27.8047848,   8.18181801
  47277,   21.8512402,   27.8047848,   8.18181801
  47278,   20.9256191,   27.8047848,   8.18181801
  47279,   29.1107445,   27.0133972,   8.18181801
  47280,    28.221487,   27.0133972,   8.18181801
  47281,   27.3322315,   27.0133972,   8.18181801
  47282,   26.4429741,   27.0133972,   8.18181801
  47283,   25.5537186,   27.0133972,   8.18181801
  47284,   24.6280994,   27.0133972,   8.18181801
  47285,   23.7024803,   27.0133972,   8.18181801
  47286,   22.7768593,   27.0133972,   8.18181801
  47287,   21.8512402,   27.0133972,   8.18181801
  47288,   20.9256191,   27.0133972,   8.18181801
  47289,   29.1107445,   26.2220097,   8.18181801
  47290,    28.221487,   26.2220097,   8.18181801
  47291,   27.3322315,   26.2220097,   8.18181801
  47292,   26.4429741,   26.2220097,   8.18181801
  47293,   25.5537186,   26.2220097,   8.18181801
  47294,   24.6280994,   26.2220097,   8.18181801
  47295,   23.7024803,   26.2220097,   8.18181801
  47296,   22.7768593,   26.2220097,   8.18181801
  47297,   21.8512402,   26.2220097,   8.18181801
  47298,   20.9256191,   26.2220097,   8.18181801
  47299,   29.1107445,   25.4306221,   8.18181801
  47300,    28.221487,   25.4306221,   8.18181801
  47301,   27.3322315,   25.4306221,   8.18181801
  47302,   26.4429741,   25.4306221,   8.18181801
  47303,   25.5537186,   25.4306221,   8.18181801
  47304,   24.6280994,   25.4306221,   8.18181801
  47305,   23.7024803,   25.4306221,   8.18181801
  47306,   22.7768593,   25.4306221,   8.18181801
  47307,   21.8512402,   25.4306221,   8.18181801
  47308,   20.9256191,   25.4306221,   8.18181801
  47309,   29.1079102,   24.6548195,   8.18181801
  47310,   28.2158203,   24.6548195,   8.18181801
  47311,   27.3237324,   24.6548195,   8.18181801
  47312,   26.4316406,   24.6548195,   8.18181801
  47313,   25.5395508,   24.6548195,   8.18181801
  47314,    24.616293,   24.6548195,   8.18181801
  47315,   23.6930351,   24.6548195,   8.18181801
  47316,   22.7697754,   24.6548195,   8.18181801
  47317,   21.8465176,   24.6548195,   8.18181801
  47318,   20.9232578,   24.6548195,   8.18181801
  47319,   29.1050777,    23.879015,   8.18181801
  47320,   28.2101536,    23.879015,   8.18181801
  47321,   27.3152313,    23.879015,   8.18181801
  47322,   26.4203072,    23.879015,   8.18181801
  47323,   25.5253849,    23.879015,   8.18181801
  47324,   24.6044865,    23.879015,   8.18181801
  47325,   23.6835899,    23.879015,   8.18181801
  47326,   22.7626915,    23.879015,   8.18181801
  47327,    21.841795,    23.879015,   8.18181801
  47328,   20.9208965,    23.879015,   8.18181801
  47329,   29.1022434,   23.1032124,   8.18181801
  47330,   28.2044868,   23.1032124,   8.18181801
  47331,   27.3067303,   23.1032124,   8.18181801
  47332,   26.4089718,   23.1032124,   8.18181801
  47333,   25.5112171,   23.1032124,   8.18181801
  47334,     24.59268,   23.1032124,   8.18181801
  47335,   23.6741447,   23.1032124,   8.18181801
  47336,   22.7556076,   23.1032124,   8.18181801
  47337,   21.8370724,   23.1032124,   8.18181801
  47338,   20.9185352,   23.1032124,   8.18181801
  47339,    29.099411,   22.3274097,   8.18181801
  47340,   28.1988182,   22.3274097,   8.18181801
  47341,   27.2982292,   22.3274097,   8.18181801
  47342,   26.3976383,   22.3274097,   8.18181801
  47343,   25.4970493,   22.3274097,   8.18181801
  47344,   24.5808735,   22.3274097,   8.18181801
  47345,   23.6646996,   22.3274097,   8.18181801
  47346,   22.7485237,   22.3274097,   8.18181801
  47347,   21.8323498,   22.3274097,   8.18181801
  47348,   20.9161739,   22.3274097,   8.18181801
  47349,   29.0965767,   21.5516071,   8.18181801
  47350,   28.1931515,   21.5516071,   8.18181801
  47351,   27.2897282,   21.5516071,   8.18181801
  47352,   26.3863049,   21.5516071,   8.18181801
  47353,   25.4828815,   21.5516071,   8.18181801
  47354,    24.569067,   21.5516071,   8.18181801
  47355,   23.6552544,   21.5516071,   8.18181801
  47356,   22.7414398,   21.5516071,   8.18181801
  47357,   21.8276272,   21.5516071,   8.18181801
  47358,   20.9138126,   21.5516071,   8.18181801
  47359,   29.0937424,   20.7758026,   8.18181801
  47360,   28.1874847,   20.7758026,   8.18181801
  47361,    27.281229,   20.7758026,   8.18181801
  47362,   26.3749695,   20.7758026,   8.18181801
  47363,   25.4687138,   20.7758026,   8.18181801
  47364,   24.5572605,   20.7758026,   8.18181801
  47365,   23.6458092,   20.7758026,   8.18181801
  47366,   22.7343559,   20.7758026,   8.18181801
  47367,   21.8229046,   20.7758026,   8.18181801
  47368,   20.9114513,   20.7758026,   8.18181801
  47369,   29.0958691,   49.1985664,   7.27272749
  47370,   28.1917362,   49.1985664,   7.27272749
  47371,   27.2876034,   49.1985664,   7.27272749
  47372,   26.3834705,   49.1985664,   7.27272749
  47373,   25.4793396,   49.1985664,   7.27272749
  47374,   24.5661144,   49.1985664,   7.27272749
  47375,   23.6528931,   49.1985664,   7.27272749
  47376,   22.7396698,   49.1985664,   7.27272749
  47377,   21.8264465,   49.1985664,   7.27272749
  47378,   20.9132233,   49.1985664,   7.27272749
  47379,   29.1008282,   48.3971291,   7.27272749
  47380,   28.2016525,   48.3971291,   7.27272749
  47381,   27.3024807,   48.3971291,   7.27272749
  47382,   26.4033051,   48.3971291,   7.27272749
  47383,   25.5041332,   48.3971291,   7.27272749
  47384,   24.5867767,   48.3971291,   7.27272749
  47385,   23.6694221,   48.3971291,   7.27272749
  47386,   22.7520657,   48.3971291,   7.27272749
  47387,   21.8347111,   48.3971291,   7.27272749
  47388,   20.9173546,   48.3971291,   7.27272749
  47389,   29.1057854,   47.5956955,   7.27272749
  47390,   28.2115707,   47.5956955,   7.27272749
  47391,   27.3173561,   47.5956955,   7.27272749
  47392,   26.4231396,   47.5956955,   7.27272749
  47393,   25.5289249,   47.5956955,   7.27272749
  47394,   24.6074371,   47.5956955,   7.27272749
  47395,   23.6859512,   47.5956955,   7.27272749
  47396,   22.7644615,   47.5956955,   7.27272749
  47397,   21.8429756,   47.5956955,   7.27272749
  47398,   20.9214878,   47.5956955,   7.27272749
  47399,   29.1107445,   46.7942581,   7.27272749
  47400,    28.221487,   46.7942581,   7.27272749
  47401,   27.3322315,   46.7942581,   7.27272749
  47402,   26.4429741,   46.7942581,   7.27272749
  47403,   25.5537186,   46.7942581,   7.27272749
  47404,   24.6280994,   46.7942581,   7.27272749
  47405,   23.7024803,   46.7942581,   7.27272749
  47406,   22.7768593,   46.7942581,   7.27272749
  47407,   21.8512402,   46.7942581,   7.27272749
  47408,   20.9256191,   46.7942581,   7.27272749
  47409,   29.1157036,   45.9928246,   7.27272749
  47410,   28.2314053,   45.9928246,   7.27272749
  47411,   27.3471069,   45.9928246,   7.27272749
  47412,   26.4628086,   45.9928246,   7.27272749
  47413,   25.5785122,   45.9928246,   7.27272749
  47414,   24.6487598,   45.9928246,   7.27272749
  47415,   23.7190094,   45.9928246,   7.27272749
  47416,   22.7892551,   45.9928246,   7.27272749
  47417,   21.8595047,   45.9928246,   7.27272749
  47418,   20.9297504,   45.9928246,   7.27272749
  47419,   29.1206627,   45.1913872,   7.27272749
  47420,   28.2413216,   45.1913872,   7.27272749
  47421,   27.3619843,   45.1913872,   7.27272749
  47422,    26.482645,   45.1913872,   7.27272749
  47423,   25.6033058,   45.1913872,   7.27272749
  47424,   24.6694202,   45.1913872,   7.27272749
  47425,   23.7355366,   45.1913872,   7.27272749
  47426,   22.8016529,   45.1913872,   7.27272749
  47427,   21.8677692,   45.1913872,   7.27272749
  47428,   20.9338837,   45.1913872,   7.27272749
  47429,   29.1206627,    44.399044,   7.27272749
  47430,   28.2413216,    44.399044,   7.27272749
  47431,   27.3619843,    44.399044,   7.27272749
  47432,    26.482645,    44.399044,   7.27272749
  47433,   25.6033058,    44.399044,   7.27272749
  47434,   24.6694202,    44.399044,   7.27272749
  47435,   23.7355366,    44.399044,   7.27272749
  47436,   22.8016529,    44.399044,   7.27272749
  47437,   21.8677692,    44.399044,   7.27272749
  47438,   20.9338837,    44.399044,   7.27272749
  47439,   29.1206627,   43.6066971,   7.27272749
  47440,   28.2413216,   43.6066971,   7.27272749
  47441,   27.3619843,   43.6066971,   7.27272749
  47442,    26.482645,   43.6066971,   7.27272749
  47443,   25.6033058,   43.6066971,   7.27272749
  47444,   24.6694202,   43.6066971,   7.27272749
  47445,   23.7355366,   43.6066971,   7.27272749
  47446,   22.8016529,   43.6066971,   7.27272749
  47447,   21.8677692,   43.6066971,   7.27272749
  47448,   20.9338837,   43.6066971,   7.27272749
  47449,   29.1206627,   42.8143539,   7.27272749
  47450,   28.2413216,   42.8143539,   7.27272749
  47451,   27.3619843,   42.8143539,   7.27272749
  47452,    26.482645,   42.8143539,   7.27272749
  47453,   25.6033058,   42.8143539,   7.27272749
  47454,   24.6694202,   42.8143539,   7.27272749
  47455,   23.7355366,   42.8143539,   7.27272749
  47456,   22.8016529,   42.8143539,   7.27272749
  47457,   21.8677692,   42.8143539,   7.27272749
  47458,   20.9338837,   42.8143539,   7.27272749
  47459,   29.1206627,   42.0220108,   7.27272749
  47460,   28.2413216,   42.0220108,   7.27272749
  47461,   27.3619843,   42.0220108,   7.27272749
  47462,    26.482645,   42.0220108,   7.27272749
  47463,   25.6033058,   42.0220108,   7.27272749
  47464,   24.6694202,   42.0220108,   7.27272749
  47465,   23.7355366,   42.0220108,   7.27272749
  47466,   22.8016529,   42.0220108,   7.27272749
  47467,   21.8677692,   42.0220108,   7.27272749
  47468,   20.9338837,   42.0220108,   7.27272749
  47469,   29.1206627,   41.2296638,   7.27272749
  47470,   28.2413216,   41.2296638,   7.27272749
  47471,   27.3619843,   41.2296638,   7.27272749
  47472,    26.482645,   41.2296638,   7.27272749
  47473,   25.6033058,   41.2296638,   7.27272749
  47474,   24.6694202,   41.2296638,   7.27272749
  47475,   23.7355366,   41.2296638,   7.27272749
  47476,   22.8016529,   41.2296638,   7.27272749
  47477,   21.8677692,   41.2296638,   7.27272749
  47478,   20.9338837,   41.2296638,   7.27272749
  47479,   29.1206627,   40.4373207,   7.27272749
  47480,   28.2413216,   40.4373207,   7.27272749
  47481,   27.3619843,   40.4373207,   7.27272749
  47482,    26.482645,   40.4373207,   7.27272749
  47483,   25.6033058,   40.4373207,   7.27272749
  47484,   24.6694202,   40.4373207,   7.27272749
  47485,   23.7355366,   40.4373207,   7.27272749
  47486,   22.8016529,   40.4373207,   7.27272749
  47487,   21.8677692,   40.4373207,   7.27272749
  47488,   20.9338837,   40.4373207,   7.27272749
  47489,   29.1206627,   39.6449776,   7.27272749
  47490,   28.2413216,   39.6449776,   7.27272749
  47491,   27.3619843,   39.6449776,   7.27272749
  47492,    26.482645,   39.6449776,   7.27272749
  47493,   25.6033058,   39.6449776,   7.27272749
  47494,   24.6694202,   39.6449776,   7.27272749
  47495,   23.7355366,   39.6449776,   7.27272749
  47496,   22.8016529,   39.6449776,   7.27272749
  47497,   21.8677692,   39.6449776,   7.27272749
  47498,   20.9338837,   39.6449776,   7.27272749
  47499,   29.1206627,   38.8526306,   7.27272749
  47500,   28.2413216,   38.8526306,   7.27272749
  47501,   27.3619843,   38.8526306,   7.27272749
  47502,    26.482645,   38.8526306,   7.27272749
  47503,   25.6033058,   38.8526306,   7.27272749
  47504,   24.6694202,   38.8526306,   7.27272749
  47505,   23.7355366,   38.8526306,   7.27272749
  47506,   22.8016529,   38.8526306,   7.27272749
  47507,   21.8677692,   38.8526306,   7.27272749
  47508,   20.9338837,   38.8526306,   7.27272749
  47509,   29.1206627,   38.0602875,   7.27272749
  47510,   28.2413216,   38.0602875,   7.27272749
  47511,   27.3619843,   38.0602875,   7.27272749
  47512,    26.482645,   38.0602875,   7.27272749
  47513,   25.6033058,   38.0602875,   7.27272749
  47514,   24.6694202,   38.0602875,   7.27272749
  47515,   23.7355366,   38.0602875,   7.27272749
  47516,   22.8016529,   38.0602875,   7.27272749
  47517,   21.8677692,   38.0602875,   7.27272749
  47518,   20.9338837,   38.0602875,   7.27272749
  47519,   29.1206627,   37.2679443,   7.27272749
  47520,   28.2413216,   37.2679443,   7.27272749
  47521,   27.3619843,   37.2679443,   7.27272749
  47522,    26.482645,   37.2679443,   7.27272749
  47523,   25.6033058,   37.2679443,   7.27272749
  47524,   24.6694202,   37.2679443,   7.27272749
  47525,   23.7355366,   37.2679443,   7.27272749
  47526,   22.8016529,   37.2679443,   7.27272749
  47527,   21.8677692,   37.2679443,   7.27272749
  47528,   20.9338837,   37.2679443,   7.27272749
  47529,   29.1206627,   36.4755974,   7.27272749
  47530,   28.2413216,   36.4755974,   7.27272749
  47531,   27.3619843,   36.4755974,   7.27272749
  47532,    26.482645,   36.4755974,   7.27272749
  47533,   25.6033058,   36.4755974,   7.27272749
  47534,   24.6694202,   36.4755974,   7.27272749
  47535,   23.7355366,   36.4755974,   7.27272749
  47536,   22.8016529,   36.4755974,   7.27272749
  47537,   21.8677692,   36.4755974,   7.27272749
  47538,   20.9338837,   36.4755974,   7.27272749
  47539,   29.1206627,   35.6832542,   7.27272749
  47540,   28.2413216,   35.6832542,   7.27272749
  47541,   27.3619843,   35.6832542,   7.27272749
  47542,    26.482645,   35.6832542,   7.27272749
  47543,   25.6033058,   35.6832542,   7.27272749
  47544,   24.6694202,   35.6832542,   7.27272749
  47545,   23.7355366,   35.6832542,   7.27272749
  47546,   22.8016529,   35.6832542,   7.27272749
  47547,   21.8677692,   35.6832542,   7.27272749
  47548,   20.9338837,   35.6832542,   7.27272749
  47549,   29.1206627,   34.8909073,   7.27272749
  47550,   28.2413216,   34.8909073,   7.27272749
  47551,   27.3619843,   34.8909073,   7.27272749
  47552,    26.482645,   34.8909073,   7.27272749
  47553,   25.6033058,   34.8909073,   7.27272749
  47554,   24.6694202,   34.8909073,   7.27272749
  47555,   23.7355366,   34.8909073,   7.27272749
  47556,   22.8016529,   34.8909073,   7.27272749
  47557,   21.8677692,   34.8909073,   7.27272749
  47558,   20.9338837,   34.8909073,   7.27272749
  47559,   29.1206627,   34.0985641,   7.27272749
  47560,   28.2413216,   34.0985641,   7.27272749
  47561,   27.3619843,   34.0985641,   7.27272749
  47562,    26.482645,   34.0985641,   7.27272749
  47563,   25.6033058,   34.0985641,   7.27272749
  47564,   24.6694202,   34.0985641,   7.27272749
  47565,   23.7355366,   34.0985641,   7.27272749
  47566,   22.8016529,   34.0985641,   7.27272749
  47567,   21.8677692,   34.0985641,   7.27272749
  47568,   20.9338837,   34.0985641,   7.27272749
  47569,   29.1206627,    33.306221,   7.27272749
  47570,   28.2413216,    33.306221,   7.27272749
  47571,   27.3619843,    33.306221,   7.27272749
  47572,    26.482645,    33.306221,   7.27272749
  47573,   25.6033058,    33.306221,   7.27272749
  47574,   24.6694202,    33.306221,   7.27272749
  47575,   23.7355366,    33.306221,   7.27272749
  47576,   22.8016529,    33.306221,   7.27272749
  47577,   21.8677692,    33.306221,   7.27272749
  47578,   20.9338837,    33.306221,   7.27272749
  47579,   29.1206627,   32.5138741,   7.27272749
  47580,   28.2413216,   32.5138741,   7.27272749
  47581,   27.3619843,   32.5138741,   7.27272749
  47582,    26.482645,   32.5138741,   7.27272749
  47583,   25.6033058,   32.5138741,   7.27272749
  47584,   24.6694202,   32.5138741,   7.27272749
  47585,   23.7355366,   32.5138741,   7.27272749
  47586,   22.8016529,   32.5138741,   7.27272749
  47587,   21.8677692,   32.5138741,   7.27272749
  47588,   20.9338837,   32.5138741,   7.27272749
  47589,   29.1206627,   31.7215309,   7.27272749
  47590,   28.2413216,   31.7215309,   7.27272749
  47591,   27.3619843,   31.7215309,   7.27272749
  47592,    26.482645,   31.7215309,   7.27272749
  47593,   25.6033058,   31.7215309,   7.27272749
  47594,   24.6694202,   31.7215309,   7.27272749
  47595,   23.7355366,   31.7215309,   7.27272749
  47596,   22.8016529,   31.7215309,   7.27272749
  47597,   21.8677692,   31.7215309,   7.27272749
  47598,   20.9338837,   31.7215309,   7.27272749
  47599,   29.1206627,   30.9291859,   7.27272749
  47600,   28.2413216,   30.9291859,   7.27272749
  47601,   27.3619843,   30.9291859,   7.27272749
  47602,    26.482645,   30.9291859,   7.27272749
  47603,   25.6033058,   30.9291859,   7.27272749
  47604,   24.6694202,   30.9291859,   7.27272749
  47605,   23.7355366,   30.9291859,   7.27272749
  47606,   22.8016529,   30.9291859,   7.27272749
  47607,   21.8677692,   30.9291859,   7.27272749
  47608,   20.9338837,   30.9291859,   7.27272749
  47609,   29.1206627,   30.1368427,   7.27272749
  47610,   28.2413216,   30.1368427,   7.27272749
  47611,   27.3619843,   30.1368427,   7.27272749
  47612,    26.482645,   30.1368427,   7.27272749
  47613,   25.6033058,   30.1368427,   7.27272749
  47614,   24.6694202,   30.1368427,   7.27272749
  47615,   23.7355366,   30.1368427,   7.27272749
  47616,   22.8016529,   30.1368427,   7.27272749
  47617,   21.8677692,   30.1368427,   7.27272749
  47618,   20.9338837,   30.1368427,   7.27272749
  47619,   29.1206627,   29.3444977,   7.27272749
  47620,   28.2413216,   29.3444977,   7.27272749
  47621,   27.3619843,   29.3444977,   7.27272749
  47622,    26.482645,   29.3444977,   7.27272749
  47623,   25.6033058,   29.3444977,   7.27272749
  47624,   24.6694202,   29.3444977,   7.27272749
  47625,   23.7355366,   29.3444977,   7.27272749
  47626,   22.8016529,   29.3444977,   7.27272749
  47627,   21.8677692,   29.3444977,   7.27272749
  47628,   20.9338837,   29.3444977,   7.27272749
  47629,   29.1206627,   28.5521526,   7.27272749
  47630,   28.2413216,   28.5521526,   7.27272749
  47631,   27.3619843,   28.5521526,   7.27272749
  47632,    26.482645,   28.5521526,   7.27272749
  47633,   25.6033058,   28.5521526,   7.27272749
  47634,   24.6694202,   28.5521526,   7.27272749
  47635,   23.7355366,   28.5521526,   7.27272749
  47636,   22.8016529,   28.5521526,   7.27272749
  47637,   21.8677692,   28.5521526,   7.27272749
  47638,   20.9338837,   28.5521526,   7.27272749
  47639,   29.1206627,   27.7598095,   7.27272749
  47640,   28.2413216,   27.7598095,   7.27272749
  47641,   27.3619843,   27.7598095,   7.27272749
  47642,    26.482645,   27.7598095,   7.27272749
  47643,   25.6033058,   27.7598095,   7.27272749
  47644,   24.6694202,   27.7598095,   7.27272749
  47645,   23.7355366,   27.7598095,   7.27272749
  47646,   22.8016529,   27.7598095,   7.27272749
  47647,   21.8677692,   27.7598095,   7.27272749
  47648,   20.9338837,   27.7598095,   7.27272749
  47649,   29.1206627,   26.9674644,   7.27272749
  47650,   28.2413216,   26.9674644,   7.27272749
  47651,   27.3619843,   26.9674644,   7.27272749
  47652,    26.482645,   26.9674644,   7.27272749
  47653,   25.6033058,   26.9674644,   7.27272749
  47654,   24.6694202,   26.9674644,   7.27272749
  47655,   23.7355366,   26.9674644,   7.27272749
  47656,   22.8016529,   26.9674644,   7.27272749
  47657,   21.8677692,   26.9674644,   7.27272749
  47658,   20.9338837,   26.9674644,   7.27272749
  47659,   29.1206627,   26.1751194,   7.27272749
  47660,   28.2413216,   26.1751194,   7.27272749
  47661,   27.3619843,   26.1751194,   7.27272749
  47662,    26.482645,   26.1751194,   7.27272749
  47663,   25.6033058,   26.1751194,   7.27272749
  47664,   24.6694202,   26.1751194,   7.27272749
  47665,   23.7355366,   26.1751194,   7.27272749
  47666,   22.8016529,   26.1751194,   7.27272749
  47667,   21.8677692,   26.1751194,   7.27272749
  47668,   20.9338837,   26.1751194,   7.27272749
  47669,   29.1206627,   25.3827744,   7.27272749
  47670,   28.2413216,   25.3827744,   7.27272749
  47671,   27.3619843,   25.3827744,   7.27272749
  47672,    26.482645,   25.3827744,   7.27272749
  47673,   25.6033058,   25.3827744,   7.27272749
  47674,   24.6694202,   25.3827744,   7.27272749
  47675,   23.7355366,   25.3827744,   7.27272749
  47676,   22.8016529,   25.3827744,   7.27272749
  47677,   21.8677692,   25.3827744,   7.27272749
  47678,   20.9338837,   25.3827744,   7.27272749
  47679,   29.1164112,   24.6138077,   7.27272749
  47680,   28.2328224,   24.6138077,   7.27272749
  47681,   27.3492336,   24.6138077,   7.27272749
  47682,   26.4656429,   24.6138077,   7.27272749
  47683,   25.5820541,   24.6138077,   7.27272749
  47684,   24.6517105,   24.6138077,   7.27272749
  47685,   23.7213688,   24.6138077,   7.27272749
  47686,   22.7910271,   24.6138077,   7.27272749
  47687,   21.8606853,   24.6138077,   7.27272749
  47688,   20.9303417,   24.6138077,   7.27272749
  47689,   29.1121616,   23.8448391,   7.27272749
  47690,   28.2243214,   23.8448391,   7.27272749
  47691,   27.3364811,   23.8448391,   7.27272749
  47692,   26.4486427,   23.8448391,   7.27272749
  47693,   25.5608025,   23.8448391,   7.27272749
  47694,   24.6340027,   23.8448391,   7.27272749
  47695,   23.7072029,   23.8448391,   7.27272749
  47696,   22.7804012,   23.8448391,   7.27272749
  47697,   21.8536015,   23.8448391,   7.27272749
  47698,   20.9267998,   23.8448391,   7.27272749
  47699,   29.1079102,   23.0758724,   7.27272749
  47700,   28.2158203,   23.0758724,   7.27272749
  47701,   27.3237305,   23.0758724,   7.27272749
  47702,   26.4316406,   23.0758724,   7.27272749
  47703,   25.5395508,   23.0758724,   7.27272749
  47704,    24.616293,   23.0758724,   7.27272749
  47705,   23.6930351,   23.0758724,   7.27272749
  47706,   22.7697754,   23.0758724,   7.27272749
  47707,   21.8465176,   23.0758724,   7.27272749
  47708,   20.9232578,   23.0758724,   7.27272749
  47709,   29.1036606,   22.3069038,   7.27272749
  47710,   28.2073193,   22.3069038,   7.27272749
  47711,   27.3109798,   22.3069038,   7.27272749
  47712,   26.4146404,   22.3069038,   7.27272749
  47713,    25.518301,   22.3069038,   7.27272749
  47714,   24.5985832,   22.3069038,   7.27272749
  47715,   23.6788673,   22.3069038,   7.27272749
  47716,   22.7591496,   22.3069038,   7.27272749
  47717,   21.8394337,   22.3069038,   7.27272749
  47718,   20.9197159,   22.3069038,   7.27272749
  47719,    29.099411,   21.5379353,   7.27272749
  47720,   28.1988201,   21.5379353,   7.27272749
  47721,   27.2982292,   21.5379353,   7.27272749
  47722,   26.3976383,   21.5379353,   7.27272749
  47723,   25.4970493,   21.5379353,   7.27272749
  47724,   24.5808735,   21.5379353,   7.27272749
  47725,   23.6646996,   21.5379353,   7.27272749
  47726,   22.7485237,   21.5379353,   7.27272749
  47727,   21.8323498,   21.5379353,   7.27272749
  47728,   20.9161739,   21.5379353,   7.27272749
  47729,   29.0951595,   20.7689686,   7.27272749
  47730,   28.1903191,   20.7689686,   7.27272749
  47731,   27.2854786,   20.7689686,   7.27272749
  47732,   26.3806381,   20.7689686,   7.27272749
  47733,   25.4757977,   20.7689686,   7.27272749
  47734,   24.5631638,   20.7689686,   7.27272749
  47735,   23.6505318,   20.7689686,   7.27272749
  47736,   22.7378979,   20.7689686,   7.27272749
  47737,   21.8252659,   20.7689686,   7.27272749
  47738,    20.912632,   20.7689686,   7.27272749
  47739,   29.0975208,   49.1945763,   6.36363649
  47740,   28.1950417,   49.1945763,   6.36363649
  47741,   27.2925625,   49.1945763,   6.36363649
  47742,   26.3900814,   49.1945763,   6.36363649
  47743,   25.4876041,   49.1945763,   6.36363649
  47744,   24.5730019,   49.1945763,   6.36363649
  47745,   23.6584034,   49.1945763,   6.36363649
  47746,   22.7438011,   49.1945763,   6.36363649
  47747,   21.8292007,   49.1945763,   6.36363649
  47748,   20.9146004,   49.1945763,   6.36363649
  47749,   29.1041336,   48.3891563,   6.36363649
  47750,   28.2082634,   48.3891563,   6.36363649
  47751,    27.312397,   48.3891563,   6.36363649
  47752,   26.4165287,   48.3891563,   6.36363649
  47753,   25.5206623,   48.3891563,   6.36363649
  47754,   24.6005516,   48.3891563,   6.36363649
  47755,   23.6804409,   48.3891563,   6.36363649
  47756,   22.7603302,   48.3891563,   6.36363649
  47757,   21.8402214,   48.3891563,   6.36363649
  47758,   20.9201088,   48.3891563,   6.36363649
  47759,   29.1107445,   47.5837326,   6.36363649
  47760,    28.221487,   47.5837326,   6.36363649
  47761,   27.3322315,   47.5837326,   6.36363649
  47762,   26.4429741,   47.5837326,   6.36363649
  47763,   25.5537186,   47.5837326,   6.36363649
  47764,   24.6280994,   47.5837326,   6.36363649
  47765,   23.7024803,   47.5837326,   6.36363649
  47766,   22.7768593,   47.5837326,   6.36363649
  47767,   21.8512402,   47.5837326,   6.36363649
  47768,   20.9256191,   47.5837326,   6.36363649
  47769,   29.1173553,   46.7783089,   6.36363649
  47770,   28.2347107,   46.7783089,   6.36363649
  47771,    27.352066,   46.7783089,   6.36363649
  47772,   26.4694214,   46.7783089,   6.36363649
  47773,   25.5867767,   46.7783089,   6.36363649
  47774,   24.6556473,   46.7783089,   6.36363649
  47775,   23.7245178,   46.7783089,   6.36363649
  47776,   22.7933884,   46.7783089,   6.36363649
  47777,   21.8622589,   46.7783089,   6.36363649
  47778,   20.9311295,   46.7783089,   6.36363649
  47779,   29.1239681,   45.9728851,   6.36363649
  47780,   28.2479343,   45.9728851,   6.36363649
  47781,   27.3719006,   45.9728851,   6.36363649
  47782,   26.4958668,   45.9728851,   6.36363649
  47783,   25.6198349,   45.9728851,   6.36363649
  47784,   24.6831951,   45.9728851,   6.36363649
  47785,   23.7465572,   45.9728851,   6.36363649
  47786,   22.8099174,   45.9728851,   6.36363649
  47787,   21.8732777,   45.9728851,   6.36363649
  47788,   20.9366379,   45.9728851,   6.36363649
  47789,    29.130579,   45.1674652,   6.36363649
  47790,   28.2611561,   45.1674652,   6.36363649
  47791,    27.391737,   45.1674652,   6.36363649
  47792,   26.5223141,   45.1674652,   6.36363649
  47793,   25.6528931,   45.1674652,   6.36363649
  47794,    24.710743,   45.1674652,   6.36363649
  47795,   23.7685947,   45.1674652,   6.36363649
  47796,   22.8264465,   45.1674652,   6.36363649
  47797,   21.8842983,   45.1674652,   6.36363649
  47798,   20.9421482,   45.1674652,   6.36363649
  47799,    29.130579,   44.3741646,   6.36363649
  47800,   28.2611561,   44.3741646,   6.36363649
  47801,    27.391737,   44.3741646,   6.36363649
  47802,   26.5223141,   44.3741646,   6.36363649
  47803,   25.6528931,   44.3741646,   6.36363649
  47804,    24.710743,   44.3741646,   6.36363649
  47805,   23.7685947,   44.3741646,   6.36363649
  47806,   22.8264465,   44.3741646,   6.36363649
  47807,   21.8842983,   44.3741646,   6.36363649
  47808,   20.9421482,   44.3741646,   6.36363649
  47809,    29.130579,   43.5808601,   6.36363649
  47810,   28.2611561,   43.5808601,   6.36363649
  47811,    27.391737,   43.5808601,   6.36363649
  47812,   26.5223141,   43.5808601,   6.36363649
  47813,   25.6528931,   43.5808601,   6.36363649
  47814,    24.710743,   43.5808601,   6.36363649
  47815,   23.7685947,   43.5808601,   6.36363649
  47816,   22.8264465,   43.5808601,   6.36363649
  47817,   21.8842983,   43.5808601,   6.36363649
  47818,   20.9421482,   43.5808601,   6.36363649
  47819,    29.130579,   42.7875595,   6.36363649
  47820,   28.2611561,   42.7875595,   6.36363649
  47821,    27.391737,   42.7875595,   6.36363649
  47822,   26.5223141,   42.7875595,   6.36363649
  47823,   25.6528931,   42.7875595,   6.36363649
  47824,    24.710743,   42.7875595,   6.36363649
  47825,   23.7685947,   42.7875595,   6.36363649
  47826,   22.8264465,   42.7875595,   6.36363649
  47827,   21.8842983,   42.7875595,   6.36363649
  47828,   20.9421482,   42.7875595,   6.36363649
  47829,    29.130579,   41.9942589,   6.36363649
  47830,   28.2611561,   41.9942589,   6.36363649
  47831,    27.391737,   41.9942589,   6.36363649
  47832,   26.5223141,   41.9942589,   6.36363649
  47833,   25.6528931,   41.9942589,   6.36363649
  47834,    24.710743,   41.9942589,   6.36363649
  47835,   23.7685947,   41.9942589,   6.36363649
  47836,   22.8264465,   41.9942589,   6.36363649
  47837,   21.8842983,   41.9942589,   6.36363649
  47838,   20.9421482,   41.9942589,   6.36363649
  47839,    29.130579,   41.2009583,   6.36363649
  47840,   28.2611561,   41.2009583,   6.36363649
  47841,    27.391737,   41.2009583,   6.36363649
  47842,   26.5223141,   41.2009583,   6.36363649
  47843,   25.6528931,   41.2009583,   6.36363649
  47844,    24.710743,   41.2009583,   6.36363649
  47845,   23.7685947,   41.2009583,   6.36363649
  47846,   22.8264465,   41.2009583,   6.36363649
  47847,   21.8842983,   41.2009583,   6.36363649
  47848,   20.9421482,   41.2009583,   6.36363649
  47849,    29.130579,   40.4076538,   6.36363649
  47850,   28.2611561,   40.4076538,   6.36363649
  47851,    27.391737,   40.4076538,   6.36363649
  47852,   26.5223141,   40.4076538,   6.36363649
  47853,   25.6528931,   40.4076538,   6.36363649
  47854,    24.710743,   40.4076538,   6.36363649
  47855,   23.7685947,   40.4076538,   6.36363649
  47856,   22.8264465,   40.4076538,   6.36363649
  47857,   21.8842983,   40.4076538,   6.36363649
  47858,   20.9421482,   40.4076538,   6.36363649
  47859,    29.130579,   39.6143532,   6.36363649
  47860,   28.2611561,   39.6143532,   6.36363649
  47861,    27.391737,   39.6143532,   6.36363649
  47862,   26.5223141,   39.6143532,   6.36363649
  47863,   25.6528931,   39.6143532,   6.36363649
  47864,    24.710743,   39.6143532,   6.36363649
  47865,   23.7685947,   39.6143532,   6.36363649
  47866,   22.8264465,   39.6143532,   6.36363649
  47867,   21.8842983,   39.6143532,   6.36363649
  47868,   20.9421482,   39.6143532,   6.36363649
  47869,    29.130579,   38.8210526,   6.36363649
  47870,   28.2611561,   38.8210526,   6.36363649
  47871,    27.391737,   38.8210526,   6.36363649
  47872,   26.5223141,   38.8210526,   6.36363649
  47873,   25.6528931,   38.8210526,   6.36363649
  47874,    24.710743,   38.8210526,   6.36363649
  47875,   23.7685947,   38.8210526,   6.36363649
  47876,   22.8264465,   38.8210526,   6.36363649
  47877,   21.8842983,   38.8210526,   6.36363649
  47878,   20.9421482,   38.8210526,   6.36363649
  47879,    29.130579,   38.0277519,   6.36363649
  47880,   28.2611561,   38.0277519,   6.36363649
  47881,    27.391737,   38.0277519,   6.36363649
  47882,   26.5223141,   38.0277519,   6.36363649
  47883,   25.6528931,   38.0277519,   6.36363649
  47884,    24.710743,   38.0277519,   6.36363649
  47885,   23.7685947,   38.0277519,   6.36363649
  47886,   22.8264465,   38.0277519,   6.36363649
  47887,   21.8842983,   38.0277519,   6.36363649
  47888,   20.9421482,   38.0277519,   6.36363649
  47889,    29.130579,   37.2344513,   6.36363649
  47890,   28.2611561,   37.2344513,   6.36363649
  47891,    27.391737,   37.2344513,   6.36363649
  47892,   26.5223141,   37.2344513,   6.36363649
  47893,   25.6528931,   37.2344513,   6.36363649
  47894,    24.710743,   37.2344513,   6.36363649
  47895,   23.7685947,   37.2344513,   6.36363649
  47896,   22.8264465,   37.2344513,   6.36363649
  47897,   21.8842983,   37.2344513,   6.36363649
  47898,   20.9421482,   37.2344513,   6.36363649
  47899,    29.130579,   36.4411469,   6.36363649
  47900,   28.2611561,   36.4411469,   6.36363649
  47901,    27.391737,   36.4411469,   6.36363649
  47902,   26.5223141,   36.4411469,   6.36363649
  47903,   25.6528931,   36.4411469,   6.36363649
  47904,    24.710743,   36.4411469,   6.36363649
  47905,   23.7685947,   36.4411469,   6.36363649
  47906,   22.8264465,   36.4411469,   6.36363649
  47907,   21.8842983,   36.4411469,   6.36363649
  47908,   20.9421482,   36.4411469,   6.36363649
  47909,    29.130579,   35.6478462,   6.36363649
  47910,   28.2611561,   35.6478462,   6.36363649
  47911,    27.391737,   35.6478462,   6.36363649
  47912,   26.5223141,   35.6478462,   6.36363649
  47913,   25.6528931,   35.6478462,   6.36363649
  47914,    24.710743,   35.6478462,   6.36363649
  47915,   23.7685947,   35.6478462,   6.36363649
  47916,   22.8264465,   35.6478462,   6.36363649
  47917,   21.8842983,   35.6478462,   6.36363649
  47918,   20.9421482,   35.6478462,   6.36363649
  47919,    29.130579,   34.8545456,   6.36363649
  47920,   28.2611561,   34.8545456,   6.36363649
  47921,    27.391737,   34.8545456,   6.36363649
  47922,   26.5223141,   34.8545456,   6.36363649
  47923,   25.6528931,   34.8545456,   6.36363649
  47924,    24.710743,   34.8545456,   6.36363649
  47925,   23.7685947,   34.8545456,   6.36363649
  47926,   22.8264465,   34.8545456,   6.36363649
  47927,   21.8842983,   34.8545456,   6.36363649
  47928,   20.9421482,   34.8545456,   6.36363649
  47929,    29.130579,    34.061245,   6.36363649
  47930,   28.2611561,    34.061245,   6.36363649
  47931,    27.391737,    34.061245,   6.36363649
  47932,   26.5223141,    34.061245,   6.36363649
  47933,   25.6528931,    34.061245,   6.36363649
  47934,    24.710743,    34.061245,   6.36363649
  47935,   23.7685947,    34.061245,   6.36363649
  47936,   22.8264465,    34.061245,   6.36363649
  47937,   21.8842983,    34.061245,   6.36363649
  47938,   20.9421482,    34.061245,   6.36363649
  47939,    29.130579,   33.2679443,   6.36363649
  47940,   28.2611561,   33.2679443,   6.36363649
  47941,    27.391737,   33.2679443,   6.36363649
  47942,   26.5223141,   33.2679443,   6.36363649
  47943,   25.6528931,   33.2679443,   6.36363649
  47944,    24.710743,   33.2679443,   6.36363649
  47945,   23.7685947,   33.2679443,   6.36363649
  47946,   22.8264465,   33.2679443,   6.36363649
  47947,   21.8842983,   33.2679443,   6.36363649
  47948,   20.9421482,   33.2679443,   6.36363649
  47949,    29.130579,   32.4746399,   6.36363649
  47950,   28.2611561,   32.4746399,   6.36363649
  47951,    27.391737,   32.4746399,   6.36363649
  47952,   26.5223141,   32.4746399,   6.36363649
  47953,   25.6528931,   32.4746399,   6.36363649
  47954,    24.710743,   32.4746399,   6.36363649
  47955,   23.7685947,   32.4746399,   6.36363649
  47956,   22.8264465,   32.4746399,   6.36363649
  47957,   21.8842983,   32.4746399,   6.36363649
  47958,   20.9421482,   32.4746399,   6.36363649
  47959,    29.130579,   31.6813393,   6.36363649
  47960,   28.2611561,   31.6813393,   6.36363649
  47961,    27.391737,   31.6813393,   6.36363649
  47962,   26.5223141,   31.6813393,   6.36363649
  47963,   25.6528931,   31.6813393,   6.36363649
  47964,    24.710743,   31.6813393,   6.36363649
  47965,   23.7685947,   31.6813393,   6.36363649
  47966,   22.8264465,   31.6813393,   6.36363649
  47967,   21.8842983,   31.6813393,   6.36363649
  47968,   20.9421482,   31.6813393,   6.36363649
  47969,    29.130579,   30.8880386,   6.36363649
  47970,   28.2611561,   30.8880386,   6.36363649
  47971,    27.391737,   30.8880386,   6.36363649
  47972,   26.5223141,   30.8880386,   6.36363649
  47973,   25.6528931,   30.8880386,   6.36363649
  47974,    24.710743,   30.8880386,   6.36363649
  47975,   23.7685947,   30.8880386,   6.36363649
  47976,   22.8264465,   30.8880386,   6.36363649
  47977,   21.8842983,   30.8880386,   6.36363649
  47978,   20.9421482,   30.8880386,   6.36363649
  47979,    29.130579,   30.0947361,   6.36363649
  47980,   28.2611561,   30.0947361,   6.36363649
  47981,    27.391737,   30.0947361,   6.36363649
  47982,   26.5223141,   30.0947361,   6.36363649
  47983,   25.6528931,   30.0947361,   6.36363649
  47984,    24.710743,   30.0947361,   6.36363649
  47985,   23.7685947,   30.0947361,   6.36363649
  47986,   22.8264465,   30.0947361,   6.36363649
  47987,   21.8842983,   30.0947361,   6.36363649
  47988,   20.9421482,   30.0947361,   6.36363649
  47989,    29.130579,   29.3014355,   6.36363649
  47990,   28.2611561,   29.3014355,   6.36363649
  47991,    27.391737,   29.3014355,   6.36363649
  47992,   26.5223141,   29.3014355,   6.36363649
  47993,   25.6528931,   29.3014355,   6.36363649
  47994,    24.710743,   29.3014355,   6.36363649
