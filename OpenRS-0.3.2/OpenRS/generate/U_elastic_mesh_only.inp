  49995,   23.8567486,   46.6826172,  0.909090936
  49996,    22.892561,   46.6826172,  0.909090936
  49997,   21.9283752,   46.6826172,  0.909090936
  49998,   20.9641857,   46.6826172,  0.909090936
  49999,   29.1735535,   45.8532677,  0.909090936
  50000,   28.3471069,   45.8532677,  0.909090936
  50001,   27.5206604,   45.8532677,  0.909090936
  50002,   26.6942139,   45.8532677,  0.909090936
  50003,   25.8677673,   45.8532677,  0.909090936
  50004,   24.8898067,   45.8532677,  0.909090936
  50005,   23.9118462,   45.8532677,  0.909090936
  50006,   22.9338856,   45.8532677,  0.909090936
  50007,   21.9559212,   45.8532677,  0.909090936
  50008,   20.9779606,   45.8532677,  0.909090936
  50009,   29.1900826,    45.023922,  0.909090936
  50010,   28.3801651,    45.023922,  0.909090936
  50011,   27.5702477,    45.023922,  0.909090936
  50012,   26.7603302,    45.023922,  0.909090936
  50013,   25.9504128,    45.023922,  0.909090936
  50014,   24.9586773,    45.023922,  0.909090936
  50015,   23.9669418,    45.023922,  0.909090936
  50016,   22.9752064,    45.023922,  0.909090936
  50017,   21.9834709,    45.023922,  0.909090936
  50018,   20.9917355,    45.023922,  0.909090936
  50019,   29.1900826,   44.2248802,  0.909090936
  50020,   28.3801651,   44.2248802,  0.909090936
  50021,   27.5702477,   44.2248802,  0.909090936
  50022,   26.7603302,   44.2248802,  0.909090936
  50023,   25.9504128,   44.2248802,  0.909090936
  50024,   24.9586773,   44.2248802,  0.909090936
  50025,   23.9669418,   44.2248802,  0.909090936
  50026,   22.9752064,   44.2248802,  0.909090936
  50027,   21.9834709,   44.2248802,  0.909090936
  50028,   20.9917355,   44.2248802,  0.909090936
  50029,   29.1900826,   43.4258385,  0.909090936
  50030,   28.3801651,   43.4258385,  0.909090936
  50031,   27.5702477,   43.4258385,  0.909090936
  50032,   26.7603302,   43.4258385,  0.909090936
  50033,   25.9504128,   43.4258385,  0.909090936
  50034,   24.9586773,   43.4258385,  0.909090936
  50035,   23.9669418,   43.4258385,  0.909090936
  50036,   22.9752064,   43.4258385,  0.909090936
  50037,   21.9834709,   43.4258385,  0.909090936
  50038,   20.9917355,   43.4258385,  0.909090936
  50039,   29.1900826,   42.6267929,  0.909090936
  50040,   28.3801651,   42.6267929,  0.909090936
  50041,   27.5702477,   42.6267929,  0.909090936
  50042,   26.7603302,   42.6267929,  0.909090936
  50043,   25.9504128,   42.6267929,  0.909090936
  50044,   24.9586773,   42.6267929,  0.909090936
  50045,   23.9669418,   42.6267929,  0.909090936
  50046,   22.9752064,   42.6267929,  0.909090936
  50047,   21.9834709,   42.6267929,  0.909090936
  50048,   20.9917355,   42.6267929,  0.909090936
  50049,   29.1900826,   41.8277512,  0.909090936
  50050,   28.3801651,   41.8277512,  0.909090936
  50051,   27.5702477,   41.8277512,  0.909090936
  50052,   26.7603302,   41.8277512,  0.909090936
  50053,   25.9504128,   41.8277512,  0.909090936
  50054,   24.9586773,   41.8277512,  0.909090936
  50055,   23.9669418,   41.8277512,  0.909090936
  50056,   22.9752064,   41.8277512,  0.909090936
  50057,   21.9834709,   41.8277512,  0.909090936
  50058,   20.9917355,   41.8277512,  0.909090936
  50059,   29.1900826,   41.0287094,  0.909090936
  50060,   28.3801651,   41.0287094,  0.909090936
  50061,   27.5702477,   41.0287094,  0.909090936
  50062,   26.7603302,   41.0287094,  0.909090936
  50063,   25.9504128,   41.0287094,  0.909090936
  50064,   24.9586773,   41.0287094,  0.909090936
  50065,   23.9669418,   41.0287094,  0.909090936
  50066,   22.9752064,   41.0287094,  0.909090936
  50067,   21.9834709,   41.0287094,  0.909090936
  50068,   20.9917355,   41.0287094,  0.909090936
  50069,   29.1900826,   40.2296638,  0.909090936
  50070,   28.3801651,   40.2296638,  0.909090936
  50071,   27.5702477,   40.2296638,  0.909090936
  50072,   26.7603302,   40.2296638,  0.909090936
  50073,   25.9504128,   40.2296638,  0.909090936
  50074,   24.9586773,   40.2296638,  0.909090936
  50075,   23.9669418,   40.2296638,  0.909090936
  50076,   22.9752064,   40.2296638,  0.909090936
  50077,   21.9834709,   40.2296638,  0.909090936
  50078,   20.9917355,   40.2296638,  0.909090936
  50079,   29.1900826,   39.4306221,  0.909090936
  50080,   28.3801651,   39.4306221,  0.909090936
  50081,   27.5702477,   39.4306221,  0.909090936
  50082,   26.7603302,   39.4306221,  0.909090936
  50083,   25.9504128,   39.4306221,  0.909090936
  50084,   24.9586773,   39.4306221,  0.909090936
  50085,   23.9669418,   39.4306221,  0.909090936
  50086,   22.9752064,   39.4306221,  0.909090936
  50087,   21.9834709,   39.4306221,  0.909090936
  50088,   20.9917355,   39.4306221,  0.909090936
  50089,   29.1900826,   38.6315804,  0.909090936
  50090,   28.3801651,   38.6315804,  0.909090936
  50091,   27.5702477,   38.6315804,  0.909090936
  50092,   26.7603302,   38.6315804,  0.909090936
  50093,   25.9504128,   38.6315804,  0.909090936
  50094,   24.9586773,   38.6315804,  0.909090936
  50095,   23.9669418,   38.6315804,  0.909090936
  50096,   22.9752064,   38.6315804,  0.909090936
  50097,   21.9834709,   38.6315804,  0.909090936
  50098,   20.9917355,   38.6315804,  0.909090936
  50099,   29.1900826,   37.8325348,  0.909090936
  50100,   28.3801651,   37.8325348,  0.909090936
  50101,   27.5702477,   37.8325348,  0.909090936
  50102,   26.7603302,   37.8325348,  0.909090936
  50103,   25.9504128,   37.8325348,  0.909090936
  50104,   24.9586773,   37.8325348,  0.909090936
  50105,   23.9669418,   37.8325348,  0.909090936
  50106,   22.9752064,   37.8325348,  0.909090936
  50107,   21.9834709,   37.8325348,  0.909090936
  50108,   20.9917355,   37.8325348,  0.909090936
  50109,   29.1900826,    37.033493,  0.909090936
  50110,   28.3801651,    37.033493,  0.909090936
  50111,   27.5702477,    37.033493,  0.909090936
  50112,   26.7603302,    37.033493,  0.909090936
  50113,   25.9504128,    37.033493,  0.909090936
  50114,   24.9586773,    37.033493,  0.909090936
  50115,   23.9669418,    37.033493,  0.909090936
  50116,   22.9752064,    37.033493,  0.909090936
  50117,   21.9834709,    37.033493,  0.909090936
  50118,   20.9917355,    37.033493,  0.909090936
  50119,   29.1900826,   36.2344513,  0.909090936
  50120,   28.3801651,   36.2344513,  0.909090936
  50121,   27.5702477,   36.2344513,  0.909090936
  50122,   26.7603302,   36.2344513,  0.909090936
  50123,   25.9504128,   36.2344513,  0.909090936
  50124,   24.9586773,   36.2344513,  0.909090936
  50125,   23.9669418,   36.2344513,  0.909090936
  50126,   22.9752064,   36.2344513,  0.909090936
  50127,   21.9834709,   36.2344513,  0.909090936
  50128,   20.9917355,   36.2344513,  0.909090936
  50129,   29.1900826,   35.4354057,  0.909090936
  50130,   28.3801651,   35.4354057,  0.909090936
  50131,   27.5702477,   35.4354057,  0.909090936
  50132,   26.7603302,   35.4354057,  0.909090936
  50133,   25.9504128,   35.4354057,  0.909090936
  50134,   24.9586773,   35.4354057,  0.909090936
  50135,   23.9669418,   35.4354057,  0.909090936
  50136,   22.9752064,   35.4354057,  0.909090936
  50137,   21.9834709,   35.4354057,  0.909090936
  50138,   20.9917355,   35.4354057,  0.909090936
  50139,   29.1900826,    34.636364,  0.909090936
  50140,   28.3801651,    34.636364,  0.909090936
  50141,   27.5702477,    34.636364,  0.909090936
  50142,   26.7603302,    34.636364,  0.909090936
  50143,   25.9504128,    34.636364,  0.909090936
  50144,   24.9586773,    34.636364,  0.909090936
  50145,   23.9669418,    34.636364,  0.909090936
  50146,   22.9752064,    34.636364,  0.909090936
  50147,   21.9834709,    34.636364,  0.909090936
  50148,   20.9917355,    34.636364,  0.909090936
  50149,   29.1900826,   33.8373222,  0.909090936
  50150,   28.3801651,   33.8373222,  0.909090936
  50151,   27.5702477,   33.8373222,  0.909090936
  50152,   26.7603302,   33.8373222,  0.909090936
  50153,   25.9504128,   33.8373222,  0.909090936
  50154,   24.9586773,   33.8373222,  0.909090936
  50155,   23.9669418,   33.8373222,  0.909090936
  50156,   22.9752064,   33.8373222,  0.909090936
  50157,   21.9834709,   33.8373222,  0.909090936
  50158,   20.9917355,   33.8373222,  0.909090936
  50159,   29.1900826,   33.0382767,  0.909090936
  50160,   28.3801651,   33.0382767,  0.909090936
  50161,   27.5702477,   33.0382767,  0.909090936
  50162,   26.7603302,   33.0382767,  0.909090936
  50163,   25.9504128,   33.0382767,  0.909090936
  50164,   24.9586773,   33.0382767,  0.909090936
  50165,   23.9669418,   33.0382767,  0.909090936
  50166,   22.9752064,   33.0382767,  0.909090936
  50167,   21.9834709,   33.0382767,  0.909090936
  50168,   20.9917355,   33.0382767,  0.909090936
  50169,   29.1900826,   32.2392349,  0.909090936
  50170,   28.3801651,   32.2392349,  0.909090936
  50171,   27.5702477,   32.2392349,  0.909090936
  50172,   26.7603302,   32.2392349,  0.909090936
  50173,   25.9504128,   32.2392349,  0.909090936
  50174,   24.9586773,   32.2392349,  0.909090936
  50175,   23.9669418,   32.2392349,  0.909090936
  50176,   22.9752064,   32.2392349,  0.909090936
  50177,   21.9834709,   32.2392349,  0.909090936
  50178,   20.9917355,   32.2392349,  0.909090936
  50179,   29.1900826,   31.4401913,  0.909090936
  50180,   28.3801651,   31.4401913,  0.909090936
  50181,   27.5702477,   31.4401913,  0.909090936
  50182,   26.7603302,   31.4401913,  0.909090936
  50183,   25.9504128,   31.4401913,  0.909090936
  50184,   24.9586773,   31.4401913,  0.909090936
  50185,   23.9669418,   31.4401913,  0.909090936
  50186,   22.9752064,   31.4401913,  0.909090936
  50187,   21.9834709,   31.4401913,  0.909090936
  50188,   20.9917355,   31.4401913,  0.909090936
  50189,   29.1900826,   30.6411476,  0.909090936
  50190,   28.3801651,   30.6411476,  0.909090936
  50191,   27.5702477,   30.6411476,  0.909090936
  50192,   26.7603302,   30.6411476,  0.909090936
  50193,   25.9504128,   30.6411476,  0.909090936
  50194,   24.9586773,   30.6411476,  0.909090936
  50195,   23.9669418,   30.6411476,  0.909090936
  50196,   22.9752064,   30.6411476,  0.909090936
  50197,   21.9834709,   30.6411476,  0.909090936
  50198,   20.9917355,   30.6411476,  0.909090936
  50199,   29.1900826,   29.8421059,  0.909090936
  50200,   28.3801651,   29.8421059,  0.909090936
  50201,   27.5702477,   29.8421059,  0.909090936
  50202,   26.7603302,   29.8421059,  0.909090936
  50203,   25.9504128,   29.8421059,  0.909090936
  50204,   24.9586773,   29.8421059,  0.909090936
  50205,   23.9669418,   29.8421059,  0.909090936
  50206,   22.9752064,   29.8421059,  0.909090936
  50207,   21.9834709,   29.8421059,  0.909090936
  50208,   20.9917355,   29.8421059,  0.909090936
  50209,   29.1900826,   29.0430622,  0.909090936
  50210,   28.3801651,   29.0430622,  0.909090936
  50211,   27.5702477,   29.0430622,  0.909090936
  50212,   26.7603302,   29.0430622,  0.909090936
  50213,   25.9504128,   29.0430622,  0.909090936
  50214,   24.9586773,   29.0430622,  0.909090936
  50215,   23.9669418,   29.0430622,  0.909090936
  50216,   22.9752064,   29.0430622,  0.909090936
  50217,   21.9834709,   29.0430622,  0.909090936
  50218,   20.9917355,   29.0430622,  0.909090936
  50219,   29.1900826,   28.2440186,  0.909090936
  50220,   28.3801651,   28.2440186,  0.909090936
  50221,   27.5702477,   28.2440186,  0.909090936
  50222,   26.7603302,   28.2440186,  0.909090936
  50223,   25.9504128,   28.2440186,  0.909090936
  50224,   24.9586773,   28.2440186,  0.909090936
  50225,   23.9669418,   28.2440186,  0.909090936
  50226,   22.9752064,   28.2440186,  0.909090936
  50227,   21.9834709,   28.2440186,  0.909090936
  50228,   20.9917355,   28.2440186,  0.909090936
  50229,   29.1900826,   27.4449768,  0.909090936
  50230,   28.3801651,   27.4449768,  0.909090936
  50231,   27.5702477,   27.4449768,  0.909090936
  50232,   26.7603302,   27.4449768,  0.909090936
  50233,   25.9504128,   27.4449768,  0.909090936
  50234,   24.9586773,   27.4449768,  0.909090936
  50235,   23.9669418,   27.4449768,  0.909090936
  50236,   22.9752064,   27.4449768,  0.909090936
  50237,   21.9834709,   27.4449768,  0.909090936
  50238,   20.9917355,   27.4449768,  0.909090936
  50239,   29.1900826,   26.6459332,  0.909090936
  50240,   28.3801651,   26.6459332,  0.909090936
  50241,   27.5702477,   26.6459332,  0.909090936
  50242,   26.7603302,   26.6459332,  0.909090936
  50243,   25.9504128,   26.6459332,  0.909090936
  50244,   24.9586773,   26.6459332,  0.909090936
  50245,   23.9669418,   26.6459332,  0.909090936
  50246,   22.9752064,   26.6459332,  0.909090936
  50247,   21.9834709,   26.6459332,  0.909090936
  50248,   20.9917355,   26.6459332,  0.909090936
  50249,   29.1900826,   25.8468895,  0.909090936
  50250,   28.3801651,   25.8468895,  0.909090936
  50251,   27.5702477,   25.8468895,  0.909090936
  50252,   26.7603302,   25.8468895,  0.909090936
  50253,   25.9504128,   25.8468895,  0.909090936
  50254,   24.9586773,   25.8468895,  0.909090936
  50255,   23.9669418,   25.8468895,  0.909090936
  50256,   22.9752064,   25.8468895,  0.909090936
  50257,   21.9834709,   25.8468895,  0.909090936
  50258,   20.9917355,   25.8468895,  0.909090936
  50259,   29.1900826,   25.0478477,  0.909090936
  50260,   28.3801651,   25.0478477,  0.909090936
  50261,   27.5702477,   25.0478477,  0.909090936
  50262,   26.7603302,   25.0478477,  0.909090936
  50263,   25.9504128,   25.0478477,  0.909090936
  50264,   24.9586773,   25.0478477,  0.909090936
  50265,   23.9669418,   25.0478477,  0.909090936
  50266,   22.9752064,   25.0478477,  0.909090936
  50267,   21.9834709,   25.0478477,  0.909090936
  50268,   20.9917355,   25.0478477,  0.909090936
  50269,   29.1759148,    24.326725,  0.909090936
  50270,   28.3518295,    24.326725,  0.909090936
  50271,   27.5277462,    24.326725,  0.909090936
  50272,    26.703661,    24.326725,  0.909090936
  50273,   25.8795738,    24.326725,  0.909090936
  50274,   24.8996449,    24.326725,  0.909090936
  50275,   23.9197159,    24.326725,  0.909090936
  50276,   22.9397869,    24.326725,  0.909090936
  50277,   21.9598579,    24.326725,  0.909090936
  50278,    20.979929,    24.326725,  0.909090936
  50279,    29.161747,   23.6056042,  0.909090936
  50280,    28.323494,   23.6056042,  0.909090936
  50281,   27.4852409,   23.6056042,  0.909090936
  50282,   26.6469898,   23.6056042,  0.909090936
  50283,   25.8087368,   23.6056042,  0.909090936
  50284,   24.8406143,   23.6056042,  0.909090936
  50285,   23.8724918,   23.6056042,  0.909090936
  50286,   22.9043674,   23.6056042,  0.909090936
  50287,    21.936245,   23.6056042,  0.909090936
  50288,   20.9681225,   23.6056042,  0.909090936
  50289,   29.1475792,   22.8844833,  0.909090936
  50290,   28.2951603,   22.8844833,  0.909090936
  50291,   27.4427395,   22.8844833,  0.909090936
  50292,   26.5903187,   22.8844833,  0.909090936
  50293,   25.7378979,   22.8844833,  0.909090936
  50294,   24.7815819,   22.8844833,  0.909090936
  50295,   23.8252659,   22.8844833,  0.909090936
  50296,   22.8689499,   22.8844833,  0.909090936
  50297,    21.912632,   22.8844833,  0.909090936
  50298,    20.956316,   22.8844833,  0.909090936
  50299,   29.1334133,   22.1633625,  0.909090936
  50300,   28.2668228,   22.1633625,  0.909090936
  50301,   27.4002361,   22.1633625,  0.909090936
  50302,   26.5336475,   22.1633625,  0.909090936
  50303,   25.6670609,   22.1633625,  0.909090936
  50304,   24.7225494,   22.1633625,  0.909090936
  50305,   23.7780399,   22.1633625,  0.909090936
  50306,   22.8335304,   22.1633625,  0.909090936
  50307,   21.8890209,   22.1633625,  0.909090936
  50308,   20.9445095,   22.1633625,  0.909090936
  50309,   29.1192436,   21.4422417,  0.909090936
  50310,   28.2384892,   21.4422417,  0.909090936
  50311,   27.3577328,   21.4422417,  0.909090936
  50312,   26.4769783,   21.4422417,  0.909090936
  50313,   25.5962219,   21.4422417,  0.909090936
  50314,   24.6635189,   21.4422417,  0.909090936
  50315,    23.730814,   21.4422417,  0.909090936
  50316,    22.798111,   21.4422417,  0.909090936
  50317,   21.8654079,   21.4422417,  0.909090936
  50318,    20.932703,   21.4422417,  0.909090936
  50319,   29.1050758,   20.7211208,  0.909090936
  50320,   28.2101536,   20.7211208,  0.909090936
  50321,   27.3152313,   20.7211208,  0.909090936
  50322,   26.4203072,   20.7211208,  0.909090936
  50323,    25.525383,   20.7211208,  0.909090936
  50324,   24.6044865,   20.7211208,  0.909090936
  50325,   23.6835899,   20.7211208,  0.909090936
  50326,   22.7626915,   20.7211208,  0.909090936
  50327,    21.841795,   20.7211208,  0.909090936
  50328,   20.9208965,   20.7211208,  0.909090936
  50329,   22.3009567,   15.7470732,   9.53482533
  50330,   22.9007435,   15.7470732,   9.53482533
  50331,   23.5005322,   15.7470732,   9.53482533
  50332,   24.1003189,   15.7470732,   9.53482533
  50333,   24.7001057,   15.7470732,   9.53482533
  50334,   25.2998943,   15.7470732,   9.53482533
  50335,   25.8996811,   15.7470732,   9.53482533
  50336,   26.4994678,   15.7470732,   9.53482533
  50337,   27.0992565,   15.7470732,   9.53482533
  50338,   27.6990433,   15.7470732,   9.53482533
  50339,    22.290226,   15.7798605,    9.0696516
  50340,   22.8923988,   15.7798605,    9.0696516
  50341,   23.4945698,   15.7798605,    9.0696516
  50342,   24.0967426,   15.7798605,    9.0696516
  50343,   24.6989136,   15.7798605,    9.0696516
  50344,   25.3010864,   15.7798605,    9.0696516
  50345,   25.9032593,   15.7798605,    9.0696516
  50346,   26.5054302,   15.7798605,    9.0696516
  50347,   27.1076012,   15.7798605,    9.0696516
  50348,    27.709774,   15.7798605,    9.0696516
  50349,   22.2794971,   15.8126478,   8.60447693
  50350,   22.8840523,   15.8126478,   8.60447693
  50351,   23.4886093,   15.8126478,   8.60447693
  50352,   24.0931644,   15.8126478,   8.60447693
  50353,   24.6977215,   15.8126478,   8.60447693
  50354,   25.3022785,   15.8126478,   8.60447693
  50355,   25.9068356,   15.8126478,   8.60447693
  50356,   26.5113907,   15.8126478,   8.60447693
  50357,   27.1159477,   15.8126478,   8.60447693
  50358,   27.7205029,   15.8126478,   8.60447693
  50359,   22.2687664,   15.8454351,   8.13930225
  50360,   22.8757057,   15.8454351,   8.13930225
  50361,   23.4826469,   15.8454351,   8.13930225
  50362,   24.0895882,   15.8454351,   8.13930225
  50363,   24.6965294,   15.8454351,   8.13930225
  50364,   25.3034706,   15.8454351,   8.13930225
  50365,   25.9104118,   15.8454351,   8.13930225
  50366,   26.5173531,   15.8454351,   8.13930225
  50367,   27.1242943,   15.8454351,   8.13930225
  50368,   27.7312336,   15.8454351,   8.13930225
  50369,   22.2580357,   15.8782225,   7.67412806
  50370,   22.8673611,   15.8782225,   7.67412806
  50371,   23.4766865,   15.8782225,   7.67412806
  50372,   24.0860119,   15.8782225,   7.67412806
  50373,   24.6953373,   15.8782225,   7.67412806
  50374,   25.3046627,   15.8782225,   7.67412806
  50375,   25.9139881,   15.8782225,   7.67412806
  50376,   26.5233135,   15.8782225,   7.67412806
  50377,   27.1326389,   15.8782225,   7.67412806
  50378,   27.7419643,   15.8782225,   7.67412806
  50379,   22.2473049,   15.9110098,   7.20895386
  50380,   22.8590145,   15.9110098,   7.20895386
  50381,   23.4707241,   15.9110098,   7.20895386
  50382,   24.0824356,   15.9110098,   7.20895386
  50383,   24.6941452,   15.9110098,   7.20895386
  50384,   25.3058567,   15.9110098,   7.20895386
  50385,   25.9175663,   15.9110098,   7.20895386
  50386,   26.5292759,   15.9110098,   7.20895386
  50387,   27.1409855,   15.9110098,   7.20895386
  50388,   27.7526951,   15.9110098,   7.20895386
  50389,   22.2365742,   15.9437971,   6.74377966
  50390,   22.8506699,   15.9437971,   6.74377966
  50391,   23.4647636,   15.9437971,   6.74377966
  50392,   24.0788593,   15.9437971,   6.74377966
  50393,   24.6929531,   15.9437971,   6.74377966
  50394,   25.3070488,   15.9437971,   6.74377918
  50395,   25.9211426,   15.9437971,   6.74377918
  50396,   26.5352364,   15.9437971,   6.74377918
  50397,   27.1493301,   15.9437971,   6.74377918
  50398,   27.7634258,   15.9437971,   6.74377918
  50399,   22.2258434,   15.9765844,   6.27860498
  50400,   22.8423233,   15.9765844,   6.27860498
  50401,   23.4588013,   15.9765844,   6.27860498
  50402,   24.0752831,   15.9765844,   6.27860498
  50403,    24.691761,   15.9765844,   6.27860498
  50404,   25.3082409,   15.9765854,   6.27860498
  50405,   25.9247189,   15.9765854,   6.27860498
  50406,   26.5411987,   15.9765854,   6.27860498
  50407,   27.1576767,   15.9765854,   6.27860498
  50408,   27.7741566,   15.9765854,   6.27860498
  50409,   22.2151146,   16.0093727,   5.81343079
  50410,   22.8339767,   16.0093727,   5.81343079
  50411,   23.4528408,   16.0093727,   5.81343079
  50412,   24.0717049,   16.0093727,   5.81343079
  50413,   24.6905689,   16.0093727,   5.81343079
  50414,    25.309433,   16.0093727,   5.81343079
  50415,   25.9282951,   16.0093727,   5.81343079
  50416,   26.5471592,   16.0093727,   5.81343079
  50417,   27.1660233,   16.0093727,   5.81343079
  50418,   27.7848854,   16.0093727,   5.81343079
  50419,   22.2043839,     16.04216,   5.34825659
  50420,   22.8256321,     16.04216,   5.34825659
  50421,   23.4468784,     16.04216,   5.34825659
  50422,   24.0681286,     16.04216,   5.34825659
  50423,   24.6893768,     16.04216,   5.34825659
  50424,   25.3106251,     16.04216,   5.34825611
  50425,   25.9318733,     16.04216,   5.34825611
  50426,   26.5531216,     16.04216,   5.34825611
  50427,   27.1743679,     16.04216,   5.34825611
  50428,   27.7956161,     16.04216,   5.34825611
  50429,   22.0577736,   16.4901371,   9.50317574
  50430,   22.7116013,   16.4901371,   9.50317574
  50431,   23.3654289,   16.4901371,   9.50317574
  50432,   24.0192585,   16.4901371,   9.50317574
  50433,   24.6730862,   16.4901371,   9.50317574
  50434,   25.3269138,   16.4901371,   9.50317574
  50435,   25.9807415,   16.4901371,   9.50317574
  50436,   26.6345711,   16.4901371,   9.50317574
  50437,   27.2883987,   16.4901371,   9.50317574
  50438,   27.9422264,   16.4901371,   9.50317574
  50439,   22.0376244,   16.5517025,   9.00635147
  50440,   22.6959286,   16.5517025,   9.00635147
  50441,   23.3542347,   16.5517025,   9.00635147
  50442,   24.0125408,   16.5517025,   9.00635147
  50443,   24.6708469,   16.5517025,   9.00635147
  50444,   25.3291531,   16.5517025,   9.00635147
  50445,   25.9874592,   16.5517044,   9.00635147
  50446,   26.6457653,   16.5517044,   9.00635147
  50447,   27.3040714,   16.5517044,   9.00635147
  50448,   27.9623756,   16.5517044,   9.00635147
  50449,    22.017477,   16.6132698,   8.50952721
  50450,   22.6802578,   16.6132698,   8.50952721
  50451,   23.3430424,   16.6132698,   8.50952721
  50452,    24.005825,   16.6132698,   8.50952721
  50453,   24.6686096,   16.6132698,   8.50952721
  50454,   25.3313904,   16.6132698,   8.50952721
  50455,    25.994175,   16.6132698,   8.50952721
  50456,   26.6569576,   16.6132698,   8.50952721
  50457,   27.3197422,   16.6132698,   8.50952721
  50458,    27.982523,   16.6132698,   8.50952721
  50459,   21.9973278,   16.6748352,   8.01270294
  50460,    22.664587,   16.6748352,   8.01270294
  50461,   23.3318481,   16.6748352,   8.01270294
  50462,   23.9991093,   16.6748352,   8.01270294
  50463,   24.6663704,   16.6748352,   8.01270294
  50464,   25.3336296,   16.6748352,   8.01270294
  50465,   26.0008907,   16.6748352,   8.01270294
  50466,   26.6681519,   16.6748352,   8.01270294
  50467,    27.335413,   16.6748352,   8.01270294
  50468,   28.0026722,   16.6748352,   8.01270294
  50469,   21.9771786,   16.7364006,   7.51587868
  50470,   22.6489162,   16.7364006,   7.51587868
  50471,   23.3206539,   16.7364006,   7.51587868
  50472,   23.9923935,   16.7364006,   7.51587868
  50473,   24.6641312,   16.7364006,   7.51587868
  50474,   25.3358688,   16.7364006,   7.51587868
  50475,   26.0076065,   16.7364006,   7.51587868
  50476,   26.6793461,   16.7364006,   7.51587868
  50477,   27.3510838,   16.7364025,   7.51587868
  50478,   28.0228214,   16.7364025,   7.51587868
  50479,   21.9570293,   16.7979679,   7.01905441
  50480,   22.6332436,   16.7979679,   7.01905441
  50481,   23.3094616,   16.7979679,   7.01905441
  50482,   23.9856758,   16.7979679,   7.01905441
  50483,   24.6618919,   16.7979679,   7.01905441
  50484,   25.3381081,   16.7979679,   7.01905441
  50485,   26.0143242,   16.7979679,   7.01905441
  50486,   26.6905403,   16.7979679,   7.01905441
  50487,   27.3667564,   16.7979679,   7.01905441
  50488,   28.0429707,   16.7979679,   7.01905441
  50489,    21.936882,   16.8595333,   6.52223015
  50490,   22.6175728,   16.8595333,   6.52223015
  50491,   23.2982674,   16.8595333,   6.52223015
  50492,     23.97896,   16.8595333,   6.52223015
  50493,   24.6596527,   16.8595333,   6.52223015
  50494,   25.3403473,   16.8595333,   6.52223015
  50495,     26.02104,   16.8595333,   6.52223015
  50496,   26.7017326,   16.8595333,   6.52223015
  50497,   27.3824272,   16.8595333,   6.52223015
  50498,    28.063118,   16.8595333,   6.52223015
  50499,   21.9167309,   16.9210987,   6.02540588
  50500,    22.601902,   16.9210987,   6.02540588
  50501,   23.2870731,   16.9210987,   6.02540588
  50502,   23.9722443,   16.9210987,   6.02540588
  50503,   24.6574135,   16.9210987,   6.02540588
  50504,   25.3425865,   16.9210987,   6.02540588
  50505,   26.0277557,   16.9210987,   6.02540588
  50506,   26.7129288,   16.9210987,   6.02540588
  50507,    27.398098,   16.9211006,   6.02540541
  50508,   28.0832691,   16.9211006,   6.02540541
  50509,   21.8965836,    16.982666,   5.52858162
  50510,   22.5862312,    16.982666,   5.52858162
  50511,   23.2758808,    16.982666,   5.52858162
  50512,   23.9655285,    16.982666,   5.52858162
  50513,   24.6551762,    16.982666,   5.52858162
  50514,   25.3448238,    16.982666,   5.52858162
  50515,   26.0344715,   16.9826641,   5.52858162
  50516,   26.7241211,   16.9826641,   5.52858162
  50517,   27.4137688,    16.982666,   5.52858114
  50518,   28.1034164,    16.982666,   5.52858114
  50519,   21.8764343,   17.0442314,   5.03175735
  50520,   22.5705605,   17.0442314,   5.03175735
  50521,   23.2646866,   17.0442314,   5.03175735
  50522,   23.9588108,   17.0442314,   5.03175735
  50523,   24.6529369,   17.0442314,   5.03175735
  50524,   25.3470631,   17.0442314,   5.03175735
  50525,   26.0411892,   17.0442295,   5.03175735
  50526,   26.7353153,   17.0442295,   5.03175735
  50527,   27.4294395,   17.0442314,   5.03175688
  50528,   28.1235657,   17.0442314,   5.03175688
  50529,   21.8172531,   17.2250614,   9.45129395
  50530,   22.5245304,   17.2250614,   9.45129395
  50531,   23.2318077,   17.2250614,   9.45129395
  50532,    23.939085,   17.2250614,   9.45129395
  50533,   24.6463623,   17.2250614,   9.45129395
  50534,   25.3536377,   17.2250614,   9.45129395
  50535,    26.060915,   17.2250614,   9.45129395
  50536,   26.7681923,   17.2250614,   9.45129395
  50537,   27.4754696,   17.2250614,   9.45129395
  50538,   28.1827469,   17.2250614,   9.45129395
  50539,     21.79035,   17.3072662,   8.90258694
  50540,   22.5036049,   17.3072662,   8.90258694
  50541,   23.2168617,   17.3072662,   8.90258694
  50542,   23.9301167,   17.3072662,   8.90258694
  50543,   24.6433716,   17.3072662,   8.90258694
  50544,   25.3566284,   17.3072662,   8.90258789
  50545,   26.0698833,   17.3072662,   8.90258789
  50546,   26.7831383,   17.3072662,   8.90258789
  50547,   27.4963951,   17.3072662,   8.90258789
  50548,     28.20965,   17.3072662,   8.90258789
  50549,   21.7634468,   17.3894711,   8.35388088
  50550,   22.4826794,   17.3894711,   8.35388088
  50551,   23.2019157,   17.3894711,   8.35388088
  50552,   23.9211483,   17.3894711,   8.35388088
  50553,   24.6403828,   17.3894711,   8.35388088
  50554,   25.3596172,   17.3894711,   8.35388088
  50555,   26.0788517,   17.3894711,   8.35388088
  50556,   26.7980843,   17.3894711,   8.35388088
  50557,   27.5173206,   17.3894711,   8.35388088
  50558,   28.2365532,   17.3894711,   8.35388088
  50559,   21.7365437,   17.4716759,   7.80517483
  50560,   22.4617558,   17.4716759,   7.80517483
  50561,   23.1869678,   17.4716759,   7.80517483
  50562,   23.9121819,   17.4716759,   7.80517483
  50563,    24.637394,   17.4716759,   7.80517483
  50564,    25.362606,   17.4716759,   7.80517483
  50565,   26.0878181,   17.4716759,   7.80517483
  50566,   26.8130322,   17.4716759,   7.80517483
  50567,   27.5382442,   17.4716759,   7.80517483
  50568,   28.2634563,   17.4716759,   7.80517483
  50569,   21.7096386,   17.5538807,    7.2564683
  50570,   22.4408302,   17.5538807,    7.2564683
  50571,   23.1720219,   17.5538807,    7.2564683
  50572,   23.9032135,   17.5538807,    7.2564683
  50573,   24.6344051,   17.5538807,    7.2564683
  50574,   25.3655949,   17.5538807,    7.2564683
  50575,   26.0967865,   17.5538807,    7.2564683
  50576,   26.8279781,   17.5538807,    7.2564683
  50577,   27.5591698,   17.5538807,   7.25646877
  50578,   28.2903614,   17.5538807,   7.25646877
  50579,   21.6827374,   17.6360855,   6.70776224
  50580,   22.4199047,   17.6360855,   6.70776224
  50581,   23.1570759,   17.6360855,   6.70776224
  50582,   23.8942451,   17.6360855,   6.70776224
  50583,   24.6314144,   17.6360855,   6.70776224
  50584,   25.3685856,   17.6360855,   6.70776224
  50585,   26.1057549,   17.6360855,   6.70776224
  50586,   26.8429241,   17.6360855,   6.70776224
  50587,   27.5800953,   17.6360855,   6.70776224
  50588,   28.3172626,   17.6360855,   6.70776224
  50589,   21.6558323,   17.7182903,   6.15905571
  50590,   22.3989792,   17.7182903,   6.15905571
  50591,   23.1421299,   17.7182903,   6.15905571
  50592,   23.8852768,   17.7182903,   6.15905571
  50593,   24.6284256,   17.7182903,   6.15905571
  50594,   25.3715744,   17.7182903,   6.15905571
  50595,   26.1147232,   17.7182903,   6.15905571
  50596,   26.8578701,   17.7182903,   6.15905571
  50597,   27.6010208,   17.7182903,   6.15905619
  50598,   28.3441677,   17.7182903,   6.15905619
  50599,    21.628931,   17.8004951,   5.61034966
  50600,   22.3780556,   17.8004951,   5.61034966
  50601,   23.1271839,   17.8004951,   5.61034966
  50602,   23.8763103,   17.8004951,   5.61034966
  50603,   24.6254368,   17.8004951,   5.61034966
  50604,   25.3745632,   17.8004951,   5.61034966
  50605,   26.1236897,   17.8004951,   5.61034966
  50606,   26.8728161,   17.8004951,   5.61034966
  50607,   27.6219444,   17.8004951,   5.61034966
  50608,    28.371069,   17.8004951,   5.61034966
  50609,    21.602026,      17.8827,   5.06164312
  50610,   22.3571301,      17.8827,   5.06164312
  50611,    23.112236,      17.8827,   5.06164312
  50612,    23.867342,      17.8827,   5.06164312
  50613,    24.622448,      17.8827,   5.06164312
  50614,    25.377552,      17.8827,   5.06164312
  50615,    26.132658,      17.8827,   5.06164312
  50616,    26.887764,      17.8827,   5.06164312
  50617,   27.6428699,      17.8827,   5.06164312
  50618,    28.397974,      17.8827,   5.06164312
  50619,   21.5751228,   17.9649048,   4.51293707
  50620,   22.3362045,   17.9649048,   4.51293707
  50621,     23.09729,   17.9649048,   4.51293707
  50622,   23.8583736,   17.9649048,   4.51293707
  50623,   24.6194572,   17.9649048,   4.51293707
  50624,   25.3805428,   17.9649048,   4.51293707
  50625,   26.1416264,   17.9649048,   4.51293707
  50626,     26.90271,   17.9649048,   4.51293707
  50627,   27.6637955,   17.9649048,   4.51293707
  50628,   28.4248772,   17.9649048,   4.51293707
  50629,   21.5807991,   17.9475536,    9.3807478
  50630,   22.3406219,   17.9475536,    9.3807478
  50631,   23.1004429,   17.9475536,    9.3807478
  50632,   23.8602676,   17.9475536,    9.3807478
  50633,   24.6200886,   17.9475536,    9.3807478
  50634,   25.3799114,   17.9475536,    9.3807478
  50635,   26.1397324,   17.9475536,    9.3807478
  50636,   26.8995571,   17.9475536,    9.3807478
  50637,   27.6593781,   17.9475536,    9.3807478
  50638,   28.4192009,   17.9475536,    9.3807478
  50639,   21.5512123,    18.037962,   8.76149559
  50640,   22.3176098,    18.037962,   8.76149559
  50641,   23.0840054,    18.037962,   8.76149559
  50642,   23.8504047,    18.037962,   8.76149559
  50643,   24.6168022,    18.037962,   8.76149559
  50644,   25.3831978,    18.037962,   8.76149559
  50645,   26.1495953,    18.037962,   8.76149559
  50646,   26.9159946,    18.037962,   8.76149559
  50647,   27.6823902,    18.037962,   8.76149559
  50648,   28.4487877,    18.037962,   8.76149559
  50649,   21.5216236,   18.1283722,   8.14224243
  50650,   22.2945957,   18.1283722,   8.14224243
  50651,   23.0675678,   18.1283722,   8.14224243
  50652,   23.8405418,   18.1283722,   8.14224243
  50653,   24.6135139,   18.1283722,   8.14224339
  50654,   25.3864861,   18.1283722,   8.14224339
  50655,   26.1594582,   18.1283722,   8.14224339
  50656,   26.9324322,   18.1283722,   8.14224339
  50657,   27.7054043,   18.1283722,   8.14224339
  50658,   28.4783764,   18.1283722,   8.14224339
  50659,   21.4920349,   18.2187824,    7.5229907
  50660,   22.2715816,   18.2187824,    7.5229907
  50661,   23.0511303,   18.2187824,    7.5229907
  50662,   23.8306789,   18.2187824,    7.5229907
  50663,   24.6102257,   18.2187824,    7.5229907
  50664,   25.3897743,   18.2187824,    7.5229907
  50665,   26.1693211,   18.2187824,    7.5229907
  50666,   26.9488697,   18.2187824,    7.5229907
  50667,   27.7284184,   18.2187824,    7.5229907
  50668,   28.5079651,   18.2187824,    7.5229907
  50669,   21.4624462,   18.3091927,   6.90373802
  50670,   22.2485695,   18.3091927,    6.9037385
  50671,   23.0346928,   18.3091927,    6.9037385
  50672,    23.820816,   18.3091927,    6.9037385
  50673,   24.6069374,   18.3091927,    6.9037385
  50674,   25.3930607,   18.3091927,    6.9037385
  50675,    26.179184,   18.3091927,    6.9037385
  50676,   26.9653072,   18.3091927,    6.9037385
  50677,   27.7514305,   18.3091927,    6.9037385
  50678,   28.5375538,   18.3091927,    6.9037385
  50679,   21.4328575,   18.3996029,   6.28448582
  50680,   22.2255554,   18.3996029,   6.28448582
  50681,   23.0182533,   18.3996029,   6.28448582
  50682,   23.8109531,   18.3996029,   6.28448582
  50683,    24.603651,   18.3996029,   6.28448582
  50684,    25.396349,   18.3996029,   6.28448582
  50685,   26.1890469,   18.3996029,   6.28448582
  50686,   26.9817467,   18.3996029,   6.28448582
  50687,   27.7744446,   18.3996029,   6.28448582
  50688,   28.5671425,   18.3996029,   6.28448582
  50689,   21.4032688,   18.4900131,   5.66523361
  50690,   22.2025414,   18.4900131,   5.66523409
  50691,   23.0018158,   18.4900131,   5.66523361
  50692,   23.8010902,   18.4900131,   5.66523361
  50693,   24.6003628,   18.4900131,   5.66523361
  50694,   25.3996353,   18.4900131,   5.66523361
  50695,   26.1989098,   18.4900131,   5.66523361
  50696,   26.9981842,   18.4900131,   5.66523361
  50697,   27.7974586,   18.4900131,   5.66523361
  50698,   28.5967312,   18.4900131,   5.66523361
  50699,   21.3736801,   18.5804234,   5.04598093
  50700,   22.1795292,   18.5804234,   5.04598141
  50701,   22.9853783,   18.5804234,   5.04598141
  50702,   23.7912273,   18.5804234,   5.04598141
  50703,   24.5970745,   18.5804234,   5.04598141
  50704,   25.4029236,   18.5804234,   5.04598141
  50705,   26.2087727,   18.5804234,   5.04598141
  50706,   27.0146217,   18.5804234,   5.04598141
  50707,   27.8204708,   18.5804234,   5.04598141
  50708,   28.6263199,   18.5804234,   5.04598141
  50709,   21.3440895,   18.6708336,   4.42672873
  50710,   22.1565151,   18.6708336,    4.4267292
  50711,   22.9689388,   18.6708336,    4.4267292
  50712,   23.7813625,   18.6708336,    4.4267292
  50713,   24.5937862,   18.6708336,    4.4267292
  50714,   25.4062099,   18.6708317,    4.4267292
  50715,   26.2186356,   18.6708317,    4.4267292
  50716,   27.0310593,   18.6708317,    4.4267292
  50717,    27.843483,   18.6708317,    4.4267292
  50718,   28.6559086,   18.6708317,    4.4267292
  50719,   21.3145027,   18.7612419,   3.80747652
  50720,   22.1335011,   18.7612419,   3.80747676
  50721,   22.9525013,   18.7612419,   3.80747676
  50722,   23.7715015,   18.7612419,   3.80747676
  50723,   24.5904999,   18.7612419,   3.80747676
  50724,   25.4094982,   18.7612419,   3.80747676
  50725,   26.2284985,   18.7612419,   3.80747676
  50726,   27.0474987,   18.7612419,   3.80747676
  50727,   27.8664989,   18.7612419,   3.80747676
  50728,   28.6854973,   18.7612419,   3.80747676
  50729,   21.3498306,   18.6532974,   9.29421329
  50730,   22.1609783,   18.6532974,   9.29421329
  50731,   22.9721279,   18.6532974,   9.29421329
  50732,   23.7832775,   18.6532974,   9.29421329
  50733,   24.5944252,   18.6532974,   9.29421329
  50734,   25.4055748,   18.6532974,   9.29421329
  50735,   26.2167225,   18.6532974,   9.29421329
  50736,   27.0278721,   18.6532974,   9.29421329
  50737,   27.8390217,   18.6532974,   9.29421329
  50738,   28.6501694,   18.6532974,   9.29421329
  50739,   21.3230343,   18.7351685,   8.58842754
  50740,   22.1401386,   18.7351685,   8.58842754
  50741,   22.9572411,   18.7351685,   8.58842754
  50742,   23.7743454,   18.7351685,   8.58842754
  50743,   24.5914478,   18.7351685,   8.58842754
  50744,   25.4085522,   18.7351685,   8.58842754
  50745,   26.2256546,   18.7351685,   8.58842754
  50746,   27.0427589,   18.7351685,   8.58842754
  50747,   27.8598614,   18.7351685,   8.58842754
  50748,   28.6769657,   18.7351685,   8.58842754
  50749,   21.2962418,   18.8170376,   7.88264084
  50750,   22.1192989,   18.8170376,   7.88264084
  50751,   22.9423561,   18.8170376,   7.88264084
  50752,   23.7654133,   18.8170376,   7.88264084
  50753,   24.5884724,   18.8170376,   7.88264084
  50754,   25.4115276,   18.8170376,   7.88264084
  50755,   26.2345867,   18.8170376,   7.88264084
  50756,   27.0576439,   18.8170376,   7.88264084
  50757,   27.8807011,   18.8170376,   7.88264084
  50758,   28.7037582,   18.8170376,   7.88264084
  50759,   21.2694492,   18.8989067,   7.17685413
  50760,   22.0984592,   18.8989067,   7.17685413
  50761,   22.9274712,   18.8989067,   7.17685461
  50762,   23.7564831,   18.8989067,   7.17685461
  50763,    24.585495,   18.8989067,   7.17685461
  50764,    25.414505,   18.8989067,   7.17685461
  50765,   26.2435169,   18.8989067,   7.17685461
  50766,   27.0725288,   18.8989067,   7.17685461
  50767,   27.9015408,   18.8989067,   7.17685461
  50768,   28.7305508,   18.8989067,   7.17685461
  50769,   21.2426529,   18.9807777,   6.47106791
  50770,   22.0776196,   18.9807777,   6.47106791
  50771,   22.9125843,   18.9807777,   6.47106838
  50772,    23.747551,   18.9807777,   6.47106838
  50773,   24.5825176,   18.9807777,   6.47106838
  50774,   25.4174824,   18.9807777,   6.47106838
  50775,    26.252449,   18.9807777,   6.47106838
  50776,   27.0874138,   18.9807777,   6.47106838
  50777,   27.9223804,   18.9807777,   6.47106838
  50778,   28.7573471,   18.9807777,   6.47106838
  50779,   21.2158604,   19.0626469,    5.7652812
  50780,   22.0567799,   19.0626469,    5.7652812
  50781,   22.8976994,   19.0626469,   5.76528168
  50782,   23.7386208,   19.0626469,   5.76528168
  50783,   24.5795403,   19.0626469,   5.76528168
  50784,   25.4204597,   19.0626469,   5.76528168
  50785,   26.2613792,   19.0626469,   5.76528168
  50786,   27.1022987,   19.0626469,   5.76528168
  50787,   27.9432201,   19.0626469,   5.76528168
  50788,   28.7841396,   19.0626469,   5.76528168
  50789,   21.1890659,    19.144516,   5.05949497
  50790,   22.0359421,    19.144516,   5.05949497
  50791,   22.8828144,    19.144516,   5.05949545
  50792,   23.7296886,    19.144516,   5.05949545
  50793,   24.5765629,    19.144516,   5.05949545
  50794,   25.4234371,    19.144516,   5.05949545
  50795,   26.2703114,    19.144516,   5.05949545
  50796,   27.1171837,    19.144516,   5.05949545
  50797,   27.9640579,    19.144516,   5.05949545
  50798,   28.8109341,    19.144516,   5.05949545
  50799,   21.1622715,    19.226387,   4.35370874
  50800,   22.0151005,    19.226387,   4.35370874
  50801,   22.8679276,    19.226387,   4.35370922
  50802,   23.7207565,    19.226387,   4.35370922
  50803,   24.5735855,    19.226387,   4.35370922
  50804,   25.4264126,   19.2263851,   4.35370922
  50805,   26.2792416,   19.2263851,   4.35370922
  50806,   27.1320686,   19.2263851,   4.35370922
  50807,   27.9848976,   19.2263851,   4.35370922
  50808,   28.8377266,   19.2263851,   4.35370922
  50809,    21.135479,   19.3082561,   3.64792228
  50810,   21.9942608,   19.3082561,   3.64792228
  50811,   22.8530426,   19.3082561,   3.64792252
  50812,   23.7118263,   19.3082561,   3.64792252
  50813,     24.57061,   19.3082561,   3.64792252
  50814,     25.42939,   19.3082561,   3.64792252
  50815,   26.2881737,   19.3082561,   3.64792275
  50816,   27.1469555,   19.3082561,   3.64792275
  50817,   28.0057392,   19.3082561,   3.64792299
  50818,    28.864521,   19.3082561,   3.64792299
  50819,   21.1086845,   19.3901253,   2.94213605
  50820,    21.973423,   19.3901253,   2.94213605
  50821,   22.8381577,   19.3901253,   2.94213629
  50822,   23.7028942,   19.3901253,   2.94213629
  50823,   24.5676327,   19.3901253,   2.94213629
  50824,   25.4323673,   19.3901253,   2.94213629
  50825,   26.2971058,   19.3901253,   2.94213653
  50826,   27.1618404,   19.3901253,   2.94213653
  50827,    28.026577,   19.3901253,   2.94213653
  50828,   28.8913155,   19.3901253,   2.94213653
  50829,    21.125618,   19.3383884,   9.19576931
  50830,   21.9865913,   19.3383884,   9.19576931
  50831,   22.8475666,   19.3383884,   9.19576931
  50832,   23.7085381,   19.3383884,   9.19576931
  50833,   24.5695133,   19.3383884,   9.19576931
  50834,   25.4304867,   19.3383884,   9.19576931
  50835,   26.2914619,   19.3383884,   9.19576931
  50836,   27.1524334,   19.3383884,   9.19576931
  50837,   28.0134087,   19.3383884,   9.19576931
  50838,    28.874382,   19.3383884,   9.19576931
  50839,   21.1083775,   19.3910637,   8.39153957
  50840,   21.9731827,   19.3910637,   8.39153957
  50841,   22.8379879,   19.3910637,   8.39153957
  50842,   23.7027931,   19.3910637,   8.39153957
  50843,   24.5675964,   19.3910637,   8.39153957
  50844,   25.4324017,   19.3910637,   8.39153957
  50845,   26.2972069,   19.3910637,   8.39153957
  50846,   27.1620121,   19.3910637,   8.39153957
  50847,   28.0268173,   19.3910637,   8.39153957
  50848,   28.8916225,   19.3910637,   8.39153957
  50849,   21.0911407,    19.443737,   7.58730888
  50850,   21.9597759,    19.443737,   7.58730888
  50851,   22.8284111,    19.443737,   7.58730888
  50852,   23.6970463,    19.443737,   7.58730888
  50853,   24.5656815,    19.443737,   7.58730888
  50854,   25.4343185,    19.443737,   7.58730888
  50855,   26.3029537,    19.443737,   7.58730936
  50856,   27.1715889,    19.443737,   7.58730936
  50857,   28.0402241,    19.443737,   7.58730936
  50858,   28.9088593,    19.443737,   7.58730936
  50859,   21.0739002,   19.4964123,   6.78307867
  50860,   21.9463673,   19.4964123,   6.78307867
  50861,   22.8188343,   19.4964123,   6.78307867
  50862,   23.6912994,   19.4964123,   6.78307867
  50863,   24.5637665,   19.4964123,   6.78307867
  50864,   25.4362335,   19.4964123,   6.78307867
  50865,   26.3087006,   19.4964123,   6.78307867
  50866,   27.1811657,   19.4964123,   6.78307867
  50867,   28.0536327,   19.4964123,   6.78307915
  50868,   28.9260998,   19.4964123,   6.78307915
  50869,   21.0566635,   19.5490856,   5.97884846
  50870,   21.9329605,   19.5490856,   5.97884846
  50871,   22.8092575,   19.5490856,   5.97884846
  50872,   23.6855545,   19.5490856,   5.97884846
  50873,   24.5618515,   19.5490856,   5.97884846
  50874,   25.4381485,   19.5490856,   5.97884846
  50875,   26.3144455,   19.5490856,   5.97884846
  50876,   27.1907425,   19.5490856,   5.97884846
  50877,   28.0670395,   19.5490856,   5.97884893
  50878,   28.9433365,   19.5490856,   5.97884893
  50879,    21.039423,   19.6017609,   5.17461777
  50880,   21.9195518,   19.6017609,   5.17461777
  50881,   22.7996807,   19.6017609,   5.17461777
  50882,   23.6798077,   19.6017609,   5.17461824
  50883,   24.5599346,   19.6017609,   5.17461824
  50884,   25.4400635,   19.6017609,   5.17461824
  50885,   26.3201923,   19.6017609,   5.17461824
  50886,   27.2003193,   19.6017609,   5.17461824
  50887,   28.0804482,   19.6017609,   5.17461824
  50888,    28.960577,   19.6017609,   5.17461872
  50889,   21.0221844,   19.6544342,   4.37038755
  50890,   21.9061432,   19.6544342,   4.37038755
  50891,    22.790102,   19.6544342,   4.37038755
  50892,   23.6740608,   19.6544342,   4.37038755
  50893,   24.5580196,   19.6544342,   4.37038755
  50894,   25.4419785,   19.6544342,   4.37038755
  50895,   26.3259392,   19.6544342,   4.37038755
  50896,    27.209898,   19.6544342,   4.37038755
  50897,   28.0938568,   19.6544342,   4.37038755
  50898,   28.9778156,   19.6544342,   4.37038803
  50899,   21.0049458,   19.7071095,   3.56615734
  50900,   21.8927364,   19.7071095,   3.56615734
  50901,   22.7805271,   19.7071095,   3.56615734
  50902,   23.6683159,   19.7071095,   3.56615758
  50903,   24.5561047,   19.7071095,   3.56615758
  50904,   25.4438934,   19.7071095,   3.56615758
  50905,   26.3316841,   19.7071095,   3.56615758
  50906,   27.2194729,   19.7071095,   3.56615758
  50907,   28.1072636,   19.7071095,   3.56615782
  50908,   28.9950542,   19.7071095,   3.56615782
  50909,   20.9877071,   19.7597847,   2.76192689
  50910,   21.8793278,   19.7597847,   2.76192689
  50911,   22.7709484,   19.7597847,   2.76192689
  50912,    23.662569,   19.7597847,   2.76192713
  50913,   24.5541897,   19.7597847,   2.76192713
  50914,   25.4458103,   19.7597828,   2.76192737
  50915,    26.337431,   19.7597828,   2.76192737
  50916,   27.2290516,   19.7597828,   2.76192737
  50917,   28.1206722,   19.7597828,   2.76192737
  50918,   29.0122929,   19.7597828,    2.7619276
  50919,   20.9704685,    19.812458,   1.95769656
  50920,   21.8659191,    19.812458,   1.95769668
  50921,   22.7613716,    19.812458,   1.95769668
  50922,   23.6568222,    19.812458,    1.9576968
  50923,   24.5522728,    19.812458,   1.95769691
  50924,   25.4477253,    19.812458,   1.95769703
  50925,   26.3431778,    19.812458,   1.95769703
  50926,   27.2386284,    19.812458,   1.95769703
  50927,   28.1340809,    19.812458,   1.95769703
  50928,   29.0295315,    19.812458,   1.95769715
  50929,  -29.0791035,   20.7211208,  0.909090936
  50930,   -28.158205,   20.7211208,  0.909090936
  50931,  -27.2373085,   20.7211208,  0.909090936
  50932,  -26.3164101,   20.7211208,  0.909090936
  50933,  -25.4140663,   20.7211208,  0.909090936
  50934,  -24.5117226,   20.7211208,  0.909090936
  50935,  -23.6093788,   20.7211208,  0.909090936
  50936,  -22.7070332,   20.7211208,  0.909090936
  50937,  -21.8046875,   20.7211208,  0.909090936
  50938,  -20.9023457,   20.7211208,  0.909090936
  50939,   -29.067297,   21.4422417,  0.909090936
  50940,  -28.1345921,   21.4422417,  0.909090936
  50941,   -27.201889,   21.4422417,  0.909090936
  50942,   -26.269186,   21.4422417,  0.909090936
  50943,  -25.3735886,   21.4422417,  0.909090936
  50944,  -24.4779892,   21.4422417,  0.909090936
  50945,  -23.5823917,   21.4422417,  0.909090936
  50946,  -22.6867924,   21.4422417,  0.909090936
  50947,  -21.7911968,   21.4422417,  0.909090936
  50948,  -20.8955975,   21.4422417,  0.909090936
  50949,  -29.0554905,   22.1633625,  0.909090936
  50950,  -28.1109791,   22.1633625,  0.909090936
  50951,  -27.1664696,   22.1633625,  0.909090936
  50952,  -26.2219601,   22.1633625,  0.909090936
  50953,  -25.3331089,   22.1633625,  0.909090936
  50954,  -24.4442577,   22.1633625,  0.909090936
  50955,  -23.5554066,   22.1633625,  0.909090936
  50956,  -22.6665535,   22.1633625,  0.909090936
  50957,  -21.7777023,   22.1633625,  0.909090936
  50958,  -20.8888512,   22.1633625,  0.909090936
  50959,   -29.043684,   22.8844833,  0.909090936
  50960,   -28.087368,   22.8844833,  0.909090936
  50961,  -27.1310501,   22.8844833,  0.909090936
  50962,  -26.1747341,   22.8844833,  0.909090936
  50963,  -25.2926292,   22.8844833,  0.909090936
  50964,  -24.4105244,   22.8844833,  0.909090936
  50965,  -23.5284195,   22.8844833,  0.909090936
  50966,  -22.6463146,   22.8844833,  0.909090936
  50967,  -21.7642097,   22.8844833,  0.909090936
  50968,  -20.8821049,   22.8844833,  0.909090936
  50969,  -29.0318775,   23.6056042,  0.909090936
  50970,   -28.063755,   23.6056042,  0.909090936
  50971,  -27.0956326,   23.6056042,  0.909090936
  50972,  -26.1275082,   23.6056042,  0.909090936
  50973,  -25.2521496,   23.6056042,  0.909090936
  50974,  -24.3767929,   23.6056042,  0.909090936
  50975,  -23.5014324,   23.6056042,  0.909090936
  50976,  -22.6260757,   23.6056042,  0.909090936
  50977,  -21.7507172,   23.6056042,  0.909090936
  50978,  -20.8753586,   23.6056042,  0.909090936
  50979,   -29.020071,    24.326725,  0.909090936
  50980,  -28.0401421,    24.326725,  0.909090936
  50981,  -27.0602131,    24.326725,  0.909090936
  50982,  -26.0802841,    24.326725,  0.909090936
  50983,  -25.2116718,    24.326725,  0.909090936
  50984,  -24.3430595,    24.326725,  0.909090936
  50985,  -23.4744473,    24.326725,  0.909090936
  50986,  -22.6058369,    24.326725,  0.909090936
  50987,  -21.7372246,    24.326725,  0.909090936
  50988,  -20.8686123,    24.326725,  0.909090936
  50989,  -29.0082645,   25.0478477,  0.909090936
  50990,  -28.0165291,   25.0478477,  0.909090936
  50991,  -27.0247936,   25.0478477,  0.909090936
  50992,  -26.0330582,   25.0478477,  0.909090936
  50993,  -25.1711922,   25.0478477,  0.909090936
  50994,  -24.3093281,   25.0478477,  0.909090936
  50995,  -23.4474621,   25.0478477,  0.909090936
  50996,  -22.5855961,   25.0478477,  0.909090936
  50997,  -21.7237301,   25.0478477,  0.909090936
  50998,   -20.861866,   25.0478477,  0.909090936
  50999,  -29.0082645,   25.8468895,  0.909090936
  51000,  -28.0165291,   25.8468895,  0.909090936
  51001,  -27.0247936,   25.8468895,  0.909090936
  51002,  -26.0330582,   25.8468895,  0.909090936
  51003,  -25.1711922,   25.8468895,  0.909090936
  51004,  -24.3093281,   25.8468895,  0.909090936
  51005,  -23.4474621,   25.8468895,  0.909090936
  51006,  -22.5855961,   25.8468895,  0.909090936
  51007,  -21.7237301,   25.8468895,  0.909090936
  51008,   -20.861866,   25.8468895,  0.909090936
  51009,  -29.0082645,   26.6459332,  0.909090936
  51010,  -28.0165291,   26.6459332,  0.909090936
  51011,  -27.0247936,   26.6459332,  0.909090936
  51012,  -26.0330582,   26.6459332,  0.909090936
  51013,  -25.1711922,   26.6459332,  0.909090936
  51014,  -24.3093281,   26.6459332,  0.909090936
  51015,  -23.4474621,   26.6459332,  0.909090936
  51016,  -22.5855961,   26.6459332,  0.909090936
  51017,  -21.7237301,   26.6459332,  0.909090936
  51018,   -20.861866,   26.6459332,  0.909090936
  51019,  -29.0082645,   27.4449768,  0.909090936
  51020,  -28.0165291,   27.4449768,  0.909090936
  51021,  -27.0247936,   27.4449768,  0.909090936
  51022,  -26.0330582,   27.4449768,  0.909090936
  51023,  -25.1711922,   27.4449768,  0.909090936
  51024,  -24.3093281,   27.4449768,  0.909090936
  51025,  -23.4474621,   27.4449768,  0.909090936
  51026,  -22.5855961,   27.4449768,  0.909090936
  51027,  -21.7237301,   27.4449768,  0.909090936
  51028,   -20.861866,   27.4449768,  0.909090936
  51029,  -29.0082645,   28.2440186,  0.909090936
  51030,  -28.0165291,   28.2440186,  0.909090936
  51031,  -27.0247936,   28.2440186,  0.909090936
  51032,  -26.0330582,   28.2440186,  0.909090936
  51033,  -25.1711922,   28.2440186,  0.909090936
  51034,  -24.3093281,   28.2440186,  0.909090936
  51035,  -23.4474621,   28.2440186,  0.909090936
  51036,  -22.5855961,   28.2440186,  0.909090936
  51037,  -21.7237301,   28.2440186,  0.909090936
  51038,   -20.861866,   28.2440186,  0.909090936
  51039,  -29.0082645,   29.0430622,  0.909090936
  51040,  -28.0165291,   29.0430622,  0.909090936
  51041,  -27.0247936,   29.0430622,  0.909090936
  51042,  -26.0330582,   29.0430622,  0.909090936
  51043,  -25.1711922,   29.0430622,  0.909090936
  51044,  -24.3093281,   29.0430622,  0.909090936
  51045,  -23.4474621,   29.0430622,  0.909090936
  51046,  -22.5855961,   29.0430622,  0.909090936
  51047,  -21.7237301,   29.0430622,  0.909090936
  51048,   -20.861866,   29.0430622,  0.909090936
  51049,  -29.0082645,   29.8421059,  0.909090936
  51050,  -28.0165291,   29.8421059,  0.909090936
  51051,  -27.0247936,   29.8421059,  0.909090936
  51052,  -26.0330582,   29.8421059,  0.909090936
  51053,  -25.1711922,   29.8421059,  0.909090936
  51054,  -24.3093281,   29.8421059,  0.909090936
  51055,  -23.4474621,   29.8421059,  0.909090936
  51056,  -22.5855961,   29.8421059,  0.909090936
  51057,  -21.7237301,   29.8421059,  0.909090936
  51058,   -20.861866,   29.8421059,  0.909090936
  51059,  -29.0082645,   30.6411476,  0.909090936
  51060,  -28.0165291,   30.6411476,  0.909090936
  51061,  -27.0247936,   30.6411476,  0.909090936
  51062,  -26.0330582,   30.6411476,  0.909090936
  51063,  -25.1711922,   30.6411476,  0.909090936
  51064,  -24.3093281,   30.6411476,  0.909090936
  51065,  -23.4474621,   30.6411476,  0.909090936
  51066,  -22.5855961,   30.6411476,  0.909090936
  51067,  -21.7237301,   30.6411476,  0.909090936
  51068,   -20.861866,   30.6411476,  0.909090936
  51069,  -29.0082645,   31.4401913,  0.909090936
  51070,  -28.0165291,   31.4401913,  0.909090936
  51071,  -27.0247936,   31.4401913,  0.909090936
  51072,  -26.0330582,   31.4401913,  0.909090936
  51073,  -25.1711922,   31.4401913,  0.909090936
  51074,  -24.3093281,   31.4401913,  0.909090936
  51075,  -23.4474621,   31.4401913,  0.909090936
  51076,  -22.5855961,   31.4401913,  0.909090936
  51077,  -21.7237301,   31.4401913,  0.909090936
  51078,   -20.861866,   31.4401913,  0.909090936
  51079,  -29.0082645,   32.2392349,  0.909090936
  51080,  -28.0165291,   32.2392349,  0.909090936
  51081,  -27.0247936,   32.2392349,  0.909090936
  51082,  -26.0330582,   32.2392349,  0.909090936
  51083,  -25.1711922,   32.2392349,  0.909090936
  51084,  -24.3093281,   32.2392349,  0.909090936
  51085,  -23.4474621,   32.2392349,  0.909090936
  51086,  -22.5855961,   32.2392349,  0.909090936
  51087,  -21.7237301,   32.2392349,  0.909090936
  51088,   -20.861866,   32.2392349,  0.909090936
  51089,  -29.0082645,   33.0382767,  0.909090936
  51090,  -28.0165291,   33.0382767,  0.909090936
  51091,  -27.0247936,   33.0382767,  0.909090936
  51092,  -26.0330582,   33.0382767,  0.909090936
  51093,  -25.1711922,   33.0382767,  0.909090936
  51094,  -24.3093281,   33.0382767,  0.909090936
  51095,  -23.4474621,   33.0382767,  0.909090936
  51096,  -22.5855961,   33.0382767,  0.909090936
  51097,  -21.7237301,   33.0382767,  0.909090936
  51098,   -20.861866,   33.0382767,  0.909090936
  51099,  -29.0082645,   33.8373222,  0.909090936
  51100,  -28.0165291,   33.8373222,  0.909090936
  51101,  -27.0247936,   33.8373222,  0.909090936
  51102,  -26.0330582,   33.8373222,  0.909090936
  51103,  -25.1711922,   33.8373222,  0.909090936
  51104,  -24.3093281,   33.8373222,  0.909090936
  51105,  -23.4474621,   33.8373222,  0.909090936
  51106,  -22.5855961,   33.8373222,  0.909090936
  51107,  -21.7237301,   33.8373222,  0.909090936
  51108,   -20.861866,   33.8373222,  0.909090936
  51109,  -29.0082645,    34.636364,  0.909090936
  51110,  -28.0165291,    34.636364,  0.909090936
  51111,  -27.0247936,    34.636364,  0.909090936
  51112,  -26.0330582,    34.636364,  0.909090936
  51113,  -25.1711922,    34.636364,  0.909090936
  51114,  -24.3093281,    34.636364,  0.909090936
  51115,  -23.4474621,    34.636364,  0.909090936
  51116,  -22.5855961,    34.636364,  0.909090936
  51117,  -21.7237301,    34.636364,  0.909090936
  51118,   -20.861866,    34.636364,  0.909090936
  51119,  -29.0082645,   35.4354057,  0.909090936
  51120,  -28.0165291,   35.4354057,  0.909090936
  51121,  -27.0247936,   35.4354057,  0.909090936
  51122,  -26.0330582,   35.4354057,  0.909090936
  51123,  -25.1711922,   35.4354057,  0.909090936
  51124,  -24.3093281,   35.4354057,  0.909090936
  51125,  -23.4474621,   35.4354057,  0.909090936
  51126,  -22.5855961,   35.4354057,  0.909090936
  51127,  -21.7237301,   35.4354057,  0.909090936
  51128,   -20.861866,   35.4354057,  0.909090936
  51129,  -29.0082645,   36.2344513,  0.909090936
  51130,  -28.0165291,   36.2344513,  0.909090936
  51131,  -27.0247936,   36.2344513,  0.909090936
  51132,  -26.0330582,   36.2344513,  0.909090936
  51133,  -25.1711922,   36.2344513,  0.909090936
  51134,  -24.3093281,   36.2344513,  0.909090936
  51135,  -23.4474621,   36.2344513,  0.909090936
  51136,  -22.5855961,   36.2344513,  0.909090936
  51137,  -21.7237301,   36.2344513,  0.909090936
  51138,   -20.861866,   36.2344513,  0.909090936
  51139,  -29.0082645,    37.033493,  0.909090936
  51140,  -28.0165291,    37.033493,  0.909090936
  51141,  -27.0247936,    37.033493,  0.909090936
  51142,  -26.0330582,    37.033493,  0.909090936
  51143,  -25.1711922,    37.033493,  0.909090936
  51144,  -24.3093281,    37.033493,  0.909090936
  51145,  -23.4474621,    37.033493,  0.909090936
  51146,  -22.5855961,    37.033493,  0.909090936
  51147,  -21.7237301,    37.033493,  0.909090936
  51148,   -20.861866,    37.033493,  0.909090936
  51149,  -29.0082645,   37.8325348,  0.909090936
  51150,  -28.0165291,   37.8325348,  0.909090936
  51151,  -27.0247936,   37.8325348,  0.909090936
  51152,  -26.0330582,   37.8325348,  0.909090936
  51153,  -25.1711922,   37.8325348,  0.909090936
  51154,  -24.3093281,   37.8325348,  0.909090936
  51155,  -23.4474621,   37.8325348,  0.909090936
  51156,  -22.5855961,   37.8325348,  0.909090936
  51157,  -21.7237301,   37.8325348,  0.909090936
  51158,   -20.861866,   37.8325348,  0.909090936
  51159,  -29.0082645,   38.6315804,  0.909090936
  51160,  -28.0165291,   38.6315804,  0.909090936
  51161,  -27.0247936,   38.6315804,  0.909090936
  51162,  -26.0330582,   38.6315804,  0.909090936
  51163,  -25.1711922,   38.6315804,  0.909090936
  51164,  -24.3093281,   38.6315804,  0.909090936
  51165,  -23.4474621,   38.6315804,  0.909090936
  51166,  -22.5855961,   38.6315804,  0.909090936
  51167,  -21.7237301,   38.6315804,  0.909090936
  51168,   -20.861866,   38.6315804,  0.909090936
  51169,  -29.0082645,   39.4306221,  0.909090936
  51170,  -28.0165291,   39.4306221,  0.909090936
  51171,  -27.0247936,   39.4306221,  0.909090936
  51172,  -26.0330582,   39.4306221,  0.909090936
  51173,  -25.1711922,   39.4306221,  0.909090936
  51174,  -24.3093281,   39.4306221,  0.909090936
  51175,  -23.4474621,   39.4306221,  0.909090936
  51176,  -22.5855961,   39.4306221,  0.909090936
  51177,  -21.7237301,   39.4306221,  0.909090936
  51178,   -20.861866,   39.4306221,  0.909090936
  51179,  -29.0082645,   40.2296638,  0.909090936
  51180,  -28.0165291,   40.2296638,  0.909090936
  51181,  -27.0247936,   40.2296638,  0.909090936
  51182,  -26.0330582,   40.2296638,  0.909090936
  51183,  -25.1711922,   40.2296638,  0.909090936
  51184,  -24.3093281,   40.2296638,  0.909090936
  51185,  -23.4474621,   40.2296638,  0.909090936
  51186,  -22.5855961,   40.2296638,  0.909090936
  51187,  -21.7237301,   40.2296638,  0.909090936
  51188,   -20.861866,   40.2296638,  0.909090936
  51189,  -29.0082645,   41.0287094,  0.909090936
  51190,  -28.0165291,   41.0287094,  0.909090936
  51191,  -27.0247936,   41.0287094,  0.909090936
  51192,  -26.0330582,   41.0287094,  0.909090936
  51193,  -25.1711922,   41.0287094,  0.909090936
  51194,  -24.3093281,   41.0287094,  0.909090936
  51195,  -23.4474621,   41.0287094,  0.909090936
  51196,  -22.5855961,   41.0287094,  0.909090936
  51197,  -21.7237301,   41.0287094,  0.909090936
  51198,   -20.861866,   41.0287094,  0.909090936
  51199,  -29.0082645,   41.8277512,  0.909090936
  51200,  -28.0165291,   41.8277512,  0.909090936
  51201,  -27.0247936,   41.8277512,  0.909090936
  51202,  -26.0330582,   41.8277512,  0.909090936
  51203,  -25.1711922,   41.8277512,  0.909090936
  51204,  -24.3093281,   41.8277512,  0.909090936
  51205,  -23.4474621,   41.8277512,  0.909090936
  51206,  -22.5855961,   41.8277512,  0.909090936
  51207,  -21.7237301,   41.8277512,  0.909090936
  51208,   -20.861866,   41.8277512,  0.909090936
  51209,  -29.0082645,   42.6267929,  0.909090936
  51210,  -28.0165291,   42.6267929,  0.909090936
  51211,  -27.0247936,   42.6267929,  0.909090936
  51212,  -26.0330582,   42.6267929,  0.909090936
  51213,  -25.1711922,   42.6267929,  0.909090936
  51214,  -24.3093281,   42.6267929,  0.909090936
  51215,  -23.4474621,   42.6267929,  0.909090936
  51216,  -22.5855961,   42.6267929,  0.909090936
  51217,  -21.7237301,   42.6267929,  0.909090936
  51218,   -20.861866,   42.6267929,  0.909090936
  51219,  -29.0082645,   43.4258385,  0.909090936
  51220,  -28.0165291,   43.4258385,  0.909090936
  51221,  -27.0247936,   43.4258385,  0.909090936
  51222,  -26.0330582,   43.4258385,  0.909090936
  51223,  -25.1711922,   43.4258385,  0.909090936
  51224,  -24.3093281,   43.4258385,  0.909090936
  51225,  -23.4474621,   43.4258385,  0.909090936
  51226,  -22.5855961,   43.4258385,  0.909090936
  51227,  -21.7237301,   43.4258385,  0.909090936
  51228,   -20.861866,   43.4258385,  0.909090936
  51229,  -29.0082645,   44.2248802,  0.909090936
  51230,  -28.0165291,   44.2248802,  0.909090936
  51231,  -27.0247936,   44.2248802,  0.909090936
  51232,  -26.0330582,   44.2248802,  0.909090936
  51233,  -25.1711922,   44.2248802,  0.909090936
  51234,  -24.3093281,   44.2248802,  0.909090936
  51235,  -23.4474621,   44.2248802,  0.909090936
  51236,  -22.5855961,   44.2248802,  0.909090936
  51237,  -21.7237301,   44.2248802,  0.909090936
  51238,   -20.861866,   44.2248802,  0.909090936
  51239,  -29.0082645,    45.023922,  0.909090936
  51240,  -28.0165291,    45.023922,  0.909090936
  51241,  -27.0247936,    45.023922,  0.909090936
  51242,  -26.0330582,    45.023922,  0.909090936
  51243,  -25.1711922,    45.023922,  0.909090936
  51244,  -24.3093281,    45.023922,  0.909090936
  51245,  -23.4474621,    45.023922,  0.909090936
  51246,  -22.5855961,    45.023922,  0.909090936
  51247,  -21.7237301,    45.023922,  0.909090936
  51248,   -20.861866,    45.023922,  0.909090936
  51249,  -29.0220394,   45.8532677,  0.909090936
  51250,  -28.0440788,   45.8532677,  0.909090936
  51251,  -27.0661144,   45.8532677,  0.909090936
  51252,  -26.0881538,   45.8532677,  0.909090936
  51253,  -25.2184181,   45.8532677,  0.909090936
  51254,  -24.3486824,   45.8532677,  0.909090936
  51255,  -23.4789448,   45.8532677,  0.909090936
  51256,  -22.6092091,   45.8532677,  0.909090936
  51257,  -21.7394733,   45.8532677,  0.909090936
  51258,  -20.8697357,   45.8532677,  0.909090936
  51259,  -29.0358143,   46.6826172,  0.909090936
  51260,  -28.0716248,   46.6826172,  0.909090936
  51261,   -27.107439,   46.6826172,  0.909090936
  51262,  -26.1432514,   46.6826172,  0.909090936
  51263,  -25.2656441,   46.6826172,  0.909090936
  51264,  -24.3880348,   46.6826172,  0.909090936
  51265,  -23.5104294,   46.6826172,  0.909090936
  51266,   -22.632822,   46.6826172,  0.909090936
  51267,  -21.7552147,   46.6826172,  0.909090936
  51268,  -20.8776073,   46.6826172,  0.909090936
  51269,  -29.0495872,   47.5119629,  0.909090936
  51270,  -28.0991745,   47.5119629,  0.909090936
  51271,  -27.1487598,   47.5119629,  0.909090936
  51272,  -26.1983471,   47.5119629,  0.909090936
  51273,    -25.31287,   47.5119629,  0.909090936
  51274,  -24.4273911,   47.5119629,  0.909090936
  51275,  -23.5419121,   47.5119629,  0.909090936
  51276,   -22.656435,   47.5119629,  0.909090936
  51277,   -21.770956,   47.5119629,  0.909090936
  51278,   -20.885479,   47.5119629,  0.909090936
  51279,  -29.0633602,   48.3413086,  0.909090936
  51280,  -28.1267223,   48.3413086,  0.909090936
  51281,  -27.1900826,   48.3413086,  0.909090936
  51282,  -26.2534428,   48.3413086,  0.909090936
  51283,  -25.3600941,   48.3413086,  0.909090936
  51284,  -24.4667454,   48.3413086,  0.909090936
  51285,  -23.5733948,   48.3413086,  0.909090936
  51286,   -22.680048,   48.3413086,  0.909090936
  51287,  -21.7866993,   48.3413086,  0.909090936
  51288,  -20.8933487,   48.3413086,  0.909090936
  51289,  -29.0771351,   49.1706543,  0.909090936
  51290,  -28.1542702,   49.1706543,  0.909090936
  51291,  -27.2314053,   49.1706543,  0.909090936
  51292,  -26.3085403,   49.1706543,  0.909090936
  51293,    -25.40732,   49.1706543,  0.909090936
  51294,  -24.5060997,   49.1706543,  0.909090936
  51295,  -23.6048813,   49.1706543,  0.909090936
  51296,  -22.7036591,   49.1706543,  0.909090936
  51297,  -21.8024387,   49.1706543,  0.909090936
  51298,  -20.9012203,   49.1706543,  0.909090936
  51299,  -29.0802841,   20.7279568,   1.81818187
  51300,  -28.1605663,   20.7279568,   1.81818187
  51301,  -27.2408504,   20.7279568,   1.81818187
  51302,  -26.3211327,   20.7279568,   1.81818187
  51303,  -25.4181156,   20.7279568,   1.81818187
  51304,  -24.5150948,   20.7279568,   1.81818187
  51305,  -23.6120777,   20.7279568,   1.81818187
  51306,  -22.7090569,   20.7279568,   1.81818187
  51307,  -21.8060379,   20.7279568,   1.81818187
  51308,   -20.903019,   20.7279568,   1.81818187
  51309,  -29.0696583,   21.4559116,   1.81818187
  51310,  -28.1393147,   21.4559116,   1.81818187
  51311,  -27.2089729,   21.4559116,   1.81818187
  51312,  -26.2786312,   21.4559116,   1.81818187
  51313,  -25.3816833,   21.4559116,   1.81818187
  51314,  -24.4847355,   21.4559116,   1.81818187
  51315,  -23.5877876,   21.4559116,   1.81818187
  51316,  -22.6908417,   21.4559116,   1.81818187
  51317,  -21.7938957,   21.4559116,   1.81818187
  51318,  -20.8969479,   21.4559116,   1.81818187
  51319,  -29.0590324,   22.1838684,   1.81818187
  51320,   -28.118063,   22.1838684,   1.81818187
  51321,  -27.1770954,   22.1838684,   1.81818187
  51322,  -26.2361279,   22.1838684,   1.81818187
  51323,   -25.345253,   22.1838684,   1.81818187
  51324,  -24.4543762,   22.1838684,   1.81818187
  51325,  -23.5635014,   22.1838684,   1.81818187
  51326,  -22.6726265,   22.1838684,   1.81818187
  51327,  -21.7817516,   22.1838684,   1.81818187
  51328,  -20.8908749,   22.1838684,   1.81818187
  51329,  -29.0484066,   22.9118252,   1.81818187
  51330,  -28.0968132,   22.9118252,   1.81818187
  51331,  -27.1452179,   22.9118252,   1.81818187
  51332,  -26.1936245,   22.9118252,   1.81818187
  51333,  -25.3088207,   22.9118252,   1.81818187
  51334,   -24.424017,   22.9118252,   1.81818187
  51335,  -23.5392151,   22.9118252,   1.81818187
  51336,  -22.6544113,   22.9118252,   1.81818187
  51337,  -21.7696056,   22.9118252,   1.81818187
  51338,  -20.8848038,   22.9118252,   1.81818187
  51339,  -29.0377808,    23.639782,   1.81818187
  51340,  -28.0755615,    23.639782,   1.81818187
  51341,  -27.1133423,    23.639782,   1.81818187
  51342,  -26.1511211,    23.639782,   1.81818187
  51343,  -25.2723904,    23.639782,   1.81818187
  51344,  -24.3936577,    23.639782,   1.81818187
  51345,  -23.5149269,    23.639782,   1.81818187
  51346,  -22.6361942,    23.639782,   1.81818187
  51347,  -21.7574635,    23.639782,   1.81818187
  51348,  -20.8787308,    23.639782,   1.81818187
  51349,  -29.0271549,   24.3677368,   1.81818187
  51350,  -28.0543098,   24.3677368,   1.81818187
  51351,  -27.0814648,   24.3677368,   1.81818187
  51352,  -26.1086197,   24.3677368,   1.81818187
  51353,  -25.2359581,   24.3677368,   1.81818187
  51354,  -24.3633003,   24.3677368,   1.81818187
  51355,  -23.4906387,   24.3677368,   1.81818187
  51356,   -22.617979,   24.3677368,   1.81818187
  51357,  -21.7453194,   24.3677368,   1.81818187
  51358,  -20.8726597,   24.3677368,   1.81818187
  51359,  -29.0165291,   25.0956936,   1.81818187
  51360,  -28.0330582,   25.0956936,   1.81818187
  51361,  -27.0495872,   25.0956936,   1.81818187
  51362,  -26.0661163,   25.0956936,   1.81818187
  51363,  -25.1995277,   25.0956936,   1.81818187
  51364,  -24.3329411,   25.0956936,   1.81818187
  51365,  -23.4663525,   25.0956936,   1.81818187
  51366,  -22.5997639,   25.0956936,   1.81818187
  51367,  -21.7331753,   25.0956936,   1.81818187
  51368,  -20.8665886,   25.0956936,   1.81818187
  51369,  -29.0165291,   25.8937798,   1.81818187
  51370,  -28.0330582,   25.8937798,   1.81818187
  51371,  -27.0495872,   25.8937798,   1.81818187
  51372,  -26.0661163,   25.8937798,   1.81818187
  51373,  -25.1995277,   25.8937798,   1.81818187
  51374,  -24.3329411,   25.8937798,   1.81818187
  51375,  -23.4663525,   25.8937798,   1.81818187
  51376,  -22.5997639,   25.8937798,   1.81818187
  51377,  -21.7331753,   25.8937798,   1.81818187
  51378,  -20.8665886,   25.8937798,   1.81818187
  51379,  -29.0165291,   26.6918659,   1.81818187
  51380,  -28.0330582,   26.6918659,   1.81818187
  51381,  -27.0495872,   26.6918659,   1.81818187
  51382,  -26.0661163,   26.6918659,   1.81818187
  51383,  -25.1995277,   26.6918659,   1.81818187
  51384,  -24.3329411,   26.6918659,   1.81818187
  51385,  -23.4663525,   26.6918659,   1.81818187
  51386,  -22.5997639,   26.6918659,   1.81818187
  51387,  -21.7331753,   26.6918659,   1.81818187
  51388,  -20.8665886,   26.6918659,   1.81818187
  51389,  -29.0165291,   27.4899521,   1.81818187
  51390,  -28.0330582,   27.4899521,   1.81818187
  51391,  -27.0495872,   27.4899521,   1.81818187
  51392,  -26.0661163,   27.4899521,   1.81818187
  51393,  -25.1995277,   27.4899521,   1.81818187
  51394,  -24.3329411,   27.4899521,   1.81818187
  51395,  -23.4663525,   27.4899521,   1.81818187
  51396,  -22.5997639,   27.4899521,   1.81818187
  51397,  -21.7331753,   27.4899521,   1.81818187
  51398,  -20.8665886,   27.4899521,   1.81818187
  51399,  -29.0165291,   28.2880383,   1.81818187
  51400,  -28.0330582,   28.2880383,   1.81818187
  51401,  -27.0495872,   28.2880383,   1.81818187
  51402,  -26.0661163,   28.2880383,   1.81818187
  51403,  -25.1995277,   28.2880383,   1.81818187
  51404,  -24.3329411,   28.2880383,   1.81818187
  51405,  -23.4663525,   28.2880383,   1.81818187
  51406,  -22.5997639,   28.2880383,   1.81818187
  51407,  -21.7331753,   28.2880383,   1.81818187
  51408,  -20.8665886,   28.2880383,   1.81818187
  51409,  -29.0165291,   29.0861244,   1.81818187
  51410,  -28.0330582,   29.0861244,   1.81818187
  51411,  -27.0495872,   29.0861244,   1.81818187
  51412,  -26.0661163,   29.0861244,   1.81818187
  51413,  -25.1995277,   29.0861244,   1.81818187
  51414,  -24.3329411,   29.0861244,   1.81818187
  51415,  -23.4663525,   29.0861244,   1.81818187
  51416,  -22.5997639,   29.0861244,   1.81818187
  51417,  -21.7331753,   29.0861244,   1.81818187
  51418,  -20.8665886,   29.0861244,   1.81818187
  51419,  -29.0165291,   29.8842106,   1.81818187
  51420,  -28.0330582,   29.8842106,   1.81818187
  51421,  -27.0495872,   29.8842106,   1.81818187
  51422,  -26.0661163,   29.8842106,   1.81818187
  51423,  -25.1995277,   29.8842106,   1.81818187
  51424,  -24.3329411,   29.8842106,   1.81818187
  51425,  -23.4663525,   29.8842106,   1.81818187
  51426,  -22.5997639,   29.8842106,   1.81818187
  51427,  -21.7331753,   29.8842106,   1.81818187
  51428,  -20.8665886,   29.8842106,   1.81818187
  51429,  -29.0165291,   30.6822968,   1.81818187
  51430,  -28.0330582,   30.6822968,   1.81818187
  51431,  -27.0495872,   30.6822968,   1.81818187
  51432,  -26.0661163,   30.6822968,   1.81818187
  51433,  -25.1995277,   30.6822968,   1.81818187
  51434,  -24.3329411,   30.6822968,   1.81818187
  51435,  -23.4663525,   30.6822968,   1.81818187
  51436,  -22.5997639,   30.6822968,   1.81818187
  51437,  -21.7331753,   30.6822968,   1.81818187
  51438,  -20.8665886,   30.6822968,   1.81818187
  51439,  -29.0165291,   31.4803829,   1.81818187
  51440,  -28.0330582,   31.4803829,   1.81818187
  51441,  -27.0495872,   31.4803829,   1.81818187
  51442,  -26.0661163,   31.4803829,   1.81818187
  51443,  -25.1995277,   31.4803829,   1.81818187
  51444,  -24.3329411,   31.4803829,   1.81818187
  51445,  -23.4663525,   31.4803829,   1.81818187
  51446,  -22.5997639,   31.4803829,   1.81818187
  51447,  -21.7331753,   31.4803829,   1.81818187
  51448,  -20.8665886,   31.4803829,   1.81818187
  51449,  -29.0165291,   32.2784691,   1.81818187
  51450,  -28.0330582,   32.2784691,   1.81818187
  51451,  -27.0495872,   32.2784691,   1.81818187
  51452,  -26.0661163,   32.2784691,   1.81818187
  51453,  -25.1995277,   32.2784691,   1.81818187
  51454,  -24.3329411,   32.2784691,   1.81818187
  51455,  -23.4663525,   32.2784691,   1.81818187
  51456,  -22.5997639,   32.2784691,   1.81818187
  51457,  -21.7331753,   32.2784691,   1.81818187
  51458,  -20.8665886,   32.2784691,   1.81818187
  51459,  -29.0165291,   33.0765533,   1.81818187
  51460,  -28.0330582,   33.0765533,   1.81818187
  51461,  -27.0495872,   33.0765533,   1.81818187
  51462,  -26.0661163,   33.0765533,   1.81818187
  51463,  -25.1995277,   33.0765533,   1.81818187
  51464,  -24.3329411,   33.0765533,   1.81818187
  51465,  -23.4663525,   33.0765533,   1.81818187
  51466,  -22.5997639,   33.0765533,   1.81818187
  51467,  -21.7331753,   33.0765533,   1.81818187
  51468,  -20.8665886,   33.0765533,   1.81818187
  51469,  -29.0165291,   33.8746414,   1.81818187
  51470,  -28.0330582,   33.8746414,   1.81818187
  51471,  -27.0495872,   33.8746414,   1.81818187
  51472,  -26.0661163,   33.8746414,   1.81818187
  51473,  -25.1995277,   33.8746414,   1.81818187
  51474,  -24.3329411,   33.8746414,   1.81818187
  51475,  -23.4663525,   33.8746414,   1.81818187
  51476,  -22.5997639,   33.8746414,   1.81818187
  51477,  -21.7331753,   33.8746414,   1.81818187
  51478,  -20.8665886,   33.8746414,   1.81818187
  51479,  -29.0165291,   34.6727257,   1.81818187
  51480,  -28.0330582,   34.6727257,   1.81818187
  51481,  -27.0495872,   34.6727257,   1.81818187
  51482,  -26.0661163,   34.6727257,   1.81818187
  51483,  -25.1995277,   34.6727257,   1.81818187
  51484,  -24.3329411,   34.6727257,   1.81818187
  51485,  -23.4663525,   34.6727257,   1.81818187
  51486,  -22.5997639,   34.6727257,   1.81818187
  51487,  -21.7331753,   34.6727257,   1.81818187
  51488,  -20.8665886,   34.6727257,   1.81818187
  51489,  -29.0165291,   35.4708138,   1.81818187
  51490,  -28.0330582,   35.4708138,   1.81818187
  51491,  -27.0495872,   35.4708138,   1.81818187
  51492,  -26.0661163,   35.4708138,   1.81818187
  51493,  -25.1995277,   35.4708138,   1.81818187
  51494,  -24.3329411,   35.4708138,   1.81818187
  51495,  -23.4663525,   35.4708138,   1.81818187
  51496,  -22.5997639,   35.4708138,   1.81818187
  51497,  -21.7331753,   35.4708138,   1.81818187
  51498,  -20.8665886,   35.4708138,   1.81818187
  51499,  -29.0165291,    36.268898,   1.81818187
  51500,  -28.0330582,    36.268898,   1.81818187
  51501,  -27.0495872,    36.268898,   1.81818187
  51502,  -26.0661163,    36.268898,   1.81818187
  51503,  -25.1995277,    36.268898,   1.81818187
  51504,  -24.3329411,    36.268898,   1.81818187
  51505,  -23.4663525,    36.268898,   1.81818187
  51506,  -22.5997639,    36.268898,   1.81818187
  51507,  -21.7331753,    36.268898,   1.81818187
  51508,  -20.8665886,    36.268898,   1.81818187
  51509,  -29.0165291,   37.0669861,   1.81818187
  51510,  -28.0330582,   37.0669861,   1.81818187
  51511,  -27.0495872,   37.0669861,   1.81818187
  51512,  -26.0661163,   37.0669861,   1.81818187
  51513,  -25.1995277,   37.0669861,   1.81818187
  51514,  -24.3329411,   37.0669861,   1.81818187
  51515,  -23.4663525,   37.0669861,   1.81818187
  51516,  -22.5997639,   37.0669861,   1.81818187
  51517,  -21.7331753,   37.0669861,   1.81818187
  51518,  -20.8665886,   37.0669861,   1.81818187
  51519,  -29.0165291,   37.8650703,   1.81818187
  51520,  -28.0330582,   37.8650703,   1.81818187
  51521,  -27.0495872,   37.8650703,   1.81818187
  51522,  -26.0661163,   37.8650703,   1.81818187
  51523,  -25.1995277,   37.8650703,   1.81818187
  51524,  -24.3329411,   37.8650703,   1.81818187
  51525,  -23.4663525,   37.8650703,   1.81818187
  51526,  -22.5997639,   37.8650703,   1.81818187
  51527,  -21.7331753,   37.8650703,   1.81818187
  51528,  -20.8665886,   37.8650703,   1.81818187
  51529,  -29.0165291,   38.6631584,   1.81818187
  51530,  -28.0330582,   38.6631584,   1.81818187
  51531,  -27.0495872,   38.6631584,   1.81818187
  51532,  -26.0661163,   38.6631584,   1.81818187
  51533,  -25.1995277,   38.6631584,   1.81818187
  51534,  -24.3329411,   38.6631584,   1.81818187
  51535,  -23.4663525,   38.6631584,   1.81818187
  51536,  -22.5997639,   38.6631584,   1.81818187
  51537,  -21.7331753,   38.6631584,   1.81818187
  51538,  -20.8665886,   38.6631584,   1.81818187
  51539,  -29.0165291,   39.4612427,   1.81818187
  51540,  -28.0330582,   39.4612427,   1.81818187
  51541,  -27.0495872,   39.4612427,   1.81818187
  51542,  -26.0661163,   39.4612427,   1.81818187
  51543,  -25.1995277,   39.4612427,   1.81818187
  51544,  -24.3329411,   39.4612427,   1.81818187
  51545,  -23.4663525,   39.4612427,   1.81818187
  51546,  -22.5997639,   39.4612427,   1.81818187
  51547,  -21.7331753,   39.4612427,   1.81818187
  51548,  -20.8665886,   39.4612427,   1.81818187
  51549,  -29.0165291,   40.2593307,   1.81818187
  51550,  -28.0330582,   40.2593307,   1.81818187
  51551,  -27.0495872,   40.2593307,   1.81818187
  51552,  -26.0661163,   40.2593307,   1.81818187
  51553,  -25.1995277,   40.2593307,   1.81818187
  51554,  -24.3329411,   40.2593307,   1.81818187
  51555,  -23.4663525,   40.2593307,   1.81818187
  51556,  -22.5997639,   40.2593307,   1.81818187
  51557,  -21.7331753,   40.2593307,   1.81818187
  51558,  -20.8665886,   40.2593307,   1.81818187
  51559,  -29.0165291,    41.057415,   1.81818187
  51560,  -28.0330582,    41.057415,   1.81818187
  51561,  -27.0495872,    41.057415,   1.81818187
  51562,  -26.0661163,    41.057415,   1.81818187
  51563,  -25.1995277,    41.057415,   1.81818187
  51564,  -24.3329411,    41.057415,   1.81818187
  51565,  -23.4663525,    41.057415,   1.81818187
  51566,  -22.5997639,    41.057415,   1.81818187
  51567,  -21.7331753,    41.057415,   1.81818187
  51568,  -20.8665886,    41.057415,   1.81818187
  51569,  -29.0165291,   41.8555031,   1.81818187
  51570,  -28.0330582,   41.8555031,   1.81818187
  51571,  -27.0495872,   41.8555031,   1.81818187
  51572,  -26.0661163,   41.8555031,   1.81818187
  51573,  -25.1995277,   41.8555031,   1.81818187
  51574,  -24.3329411,   41.8555031,   1.81818187
  51575,  -23.4663525,   41.8555031,   1.81818187
  51576,  -22.5997639,   41.8555031,   1.81818187
  51577,  -21.7331753,   41.8555031,   1.81818187
  51578,  -20.8665886,   41.8555031,   1.81818187
  51579,  -29.0165291,   42.6535873,   1.81818187
  51580,  -28.0330582,   42.6535873,   1.81818187
  51581,  -27.0495872,   42.6535873,   1.81818187
  51582,  -26.0661163,   42.6535873,   1.81818187
  51583,  -25.1995277,   42.6535873,   1.81818187
  51584,  -24.3329411,   42.6535873,   1.81818187
  51585,  -23.4663525,   42.6535873,   1.81818187
  51586,  -22.5997639,   42.6535873,   1.81818187
  51587,  -21.7331753,   42.6535873,   1.81818187
  51588,  -20.8665886,   42.6535873,   1.81818187
  51589,  -29.0165291,   43.4516754,   1.81818187
  51590,  -28.0330582,   43.4516754,   1.81818187
  51591,  -27.0495872,   43.4516754,   1.81818187
  51592,  -26.0661163,   43.4516754,   1.81818187
  51593,  -25.1995277,   43.4516754,   1.81818187
  51594,  -24.3329411,   43.4516754,   1.81818187
  51595,  -23.4663525,   43.4516754,   1.81818187
  51596,  -22.5997639,   43.4516754,   1.81818187
  51597,  -21.7331753,   43.4516754,   1.81818187
  51598,  -20.8665886,   43.4516754,   1.81818187
  51599,  -29.0165291,   44.2497597,   1.81818187
  51600,  -28.0330582,   44.2497597,   1.81818187
  51601,  -27.0495872,   44.2497597,   1.81818187
  51602,  -26.0661163,   44.2497597,   1.81818187
  51603,  -25.1995277,   44.2497597,   1.81818187
  51604,  -24.3329411,   44.2497597,   1.81818187
  51605,  -23.4663525,   44.2497597,   1.81818187
  51606,  -22.5997639,   44.2497597,   1.81818187
  51607,  -21.7331753,   44.2497597,   1.81818187
  51608,  -20.8665886,   44.2497597,   1.81818187
  51609,  -29.0165291,   45.0478477,   1.81818187
  51610,  -28.0330582,   45.0478477,   1.81818187
  51611,  -27.0495872,   45.0478477,   1.81818187
  51612,  -26.0661163,   45.0478477,   1.81818187
  51613,  -25.1995277,   45.0478477,   1.81818187
  51614,  -24.3329411,   45.0478477,   1.81818187
  51615,  -23.4663525,   45.0478477,   1.81818187
  51616,  -22.5997639,   45.0478477,   1.81818187
  51617,  -21.7331753,   45.0478477,   1.81818187
  51618,  -20.8665886,   45.0478477,   1.81818187
  51619,  -29.0289268,   45.8732071,   1.81818187
  51620,  -28.0578518,   45.8732071,   1.81818187
  51621,  -27.0867767,   45.8732071,   1.81818187
  51622,  -26.1157017,   45.8732071,   1.81818187
  51623,  -25.2420311,   45.8732071,   1.81818187
  51624,  -24.3683586,   45.8732071,   1.81818187
  51625,   -23.494688,   45.8732071,   1.81818187
  51626,  -22.6210155,   45.8732071,   1.81818187
  51627,  -21.7473431,   45.8732071,   1.81818187
  51628,  -20.8736725,   45.8732071,   1.81818187
  51629,  -29.0413227,   46.6985664,   1.81818187
  51630,  -28.0826454,   46.6985664,   1.81818187
  51631,  -27.1239681,   46.6985664,   1.81818187
  51632,  -26.1652889,   46.6985664,   1.81818187
  51633,  -25.2845345,   46.6985664,   1.81818187
  51634,  -24.4037781,   46.6985664,   1.81818187
  51635,  -23.5230217,   46.6985664,   1.81818187
  51636,  -22.6422672,   46.6985664,   1.81818187
  51637,  -21.7615128,   46.6985664,   1.81818187
  51638,  -20.8807545,   46.6985664,   1.81818187
  51639,  -29.0537186,    47.523922,   1.81818187
  51640,   -28.107439,    47.523922,   1.81818187
  51641,  -27.1611576,    47.523922,   1.81818187
  51642,  -26.2148762,    47.523922,   1.81818187
  51643,  -25.3270378,    47.523922,   1.81818187
  51644,  -24.4391975,    47.523922,   1.81818187
  51645,  -23.5513573,    47.523922,   1.81818187
  51646,  -22.6635189,    47.523922,   1.81818187
  51647,  -21.7756786,    47.523922,   1.81818187
  51648,  -20.8878403,    47.523922,   1.81818187
  51649,  -29.0661163,   48.3492813,   1.81818187
  51650,  -28.1322308,   48.3492813,   1.81818187
  51651,  -27.1983471,   48.3492813,   1.81818187
  51652,  -26.2644634,   48.3492813,   1.81818187
  51653,  -25.3695393,   48.3492813,   1.81818187
  51654,  -24.4746151,   48.3492813,   1.81818187
  51655,  -23.5796928,   48.3492813,   1.81818187
  51656,  -22.6847706,   48.3492813,   1.81818187
  51657,  -21.7898464,   48.3492813,   1.81818187
  51658,  -20.8949242,   48.3492813,   1.81818187
  51659,  -29.0785122,   49.1746407,   1.81818187
  51660,  -28.1570263,   49.1746407,   1.81818187
  51661,  -27.2355366,   49.1746407,   1.81818187
  51662,  -26.3140488,   49.1746407,   1.81818187
  51663,  -25.4120426,   49.1746407,   1.81818187
  51664,  -24.5100365,   49.1746407,   1.81818187
  51665,  -23.6080284,   49.1746407,   1.81818187
  51666,  -22.7060204,   49.1746407,   1.81818187
  51667,  -21.8040142,   49.1746407,   1.81818187
  51668,  -20.9020061,   49.1746407,   1.81818187
  51669,  -29.0814648,   20.7347908,   2.72727275
  51670,  -28.1629276,   20.7347908,   2.72727275
  51671,  -27.2443924,   20.7347908,   2.72727275
  51672,  -26.3258553,   20.7347908,   2.72727275
  51673,   -25.422163,   20.7347908,   2.72727275
  51674,  -24.5184689,   20.7347908,   2.72727275
  51675,  -23.6147747,   20.7347908,   2.72727275
  51676,  -22.7110806,   20.7347908,   2.72727275
  51677,  -21.8073864,   20.7347908,   2.72727275
  51678,  -20.9036942,   20.7347908,   2.72727275
  51679,  -29.0720196,   21.4695835,   2.72727275
  51680,  -28.1440372,   21.4695835,   2.72727275
  51681,  -27.2160568,   21.4695835,   2.72727275
  51682,  -26.2880764,   21.4695835,   2.72727275
  51683,    -25.38978,   21.4695835,   2.72727275
  51684,  -24.4914818,   21.4695835,   2.72727275
  51685,  -23.5931854,   21.4695835,   2.72727275
  51686,  -22.6948891,   21.4695835,   2.72727275
  51687,  -21.7965927,   21.4695835,   2.72727275
  51688,  -20.8982964,   21.4695835,   2.72727275
  51689,  -29.0625744,   22.2043743,   2.72727275
  51690,  -28.1251469,   22.2043743,   2.72727275
  51691,  -27.1877213,   22.2043743,   2.72727275
  51692,  -26.2502956,   22.2043743,   2.72727275
  51693,  -25.3573952,   22.2043743,   2.72727275
  51694,  -24.4644966,   22.2043743,   2.72727275
  51695,  -23.5715981,   22.2043743,   2.72727275
  51696,  -22.6786976,   22.2043743,   2.72727275
  51697,   -21.785799,   22.2043743,   2.72727275
  51698,  -20.8928986,   22.2043743,   2.72727275
  51699,  -29.0531292,    22.939167,   2.72727275
  51700,  -28.1062584,    22.939167,   2.72727275
  51701,  -27.1593857,    22.939167,   2.72727275
  51702,  -26.2125149,    22.939167,   2.72727275
  51703,  -25.3250122,    22.939167,   2.72727275
  51704,  -24.4375114,    22.939167,   2.72727275
  51705,  -23.5500088,    22.939167,   2.72727275
  51706,  -22.6625061,    22.939167,   2.72727275
  51707,  -21.7750034,    22.939167,   2.72727275
  51708,  -20.8875008,    22.939167,   2.72727275
  51709,   -29.043684,   23.6739578,   2.72727275
  51710,   -28.087368,   23.6739578,   2.72727275
  51711,   -27.131052,   23.6739578,   2.72727275
  51712,  -26.1747341,   23.6739578,   2.72727275
  51713,  -25.2926292,   23.6739578,   2.72727275
  51714,  -24.4105244,   23.6739578,   2.72727275
  51715,  -23.5284195,   23.6739578,   2.72727275
  51716,  -22.6463146,   23.6739578,   2.72727275
  51717,  -21.7642097,   23.6739578,   2.72727275
  51718,  -20.8821049,   23.6739578,   2.72727275
  51719,  -29.0342388,   24.4087486,   2.72727275
  51720,  -28.0684776,   24.4087486,   2.72727275
  51721,  -27.1027164,   24.4087486,   2.72727275
  51722,  -26.1369534,   24.4087486,   2.72727275
  51723,  -25.2602463,   24.4087486,   2.72727275
  51724,  -24.3835392,   24.4087486,   2.72727275
  51725,  -23.5068302,   24.4087486,   2.72727275
  51726,  -22.6301231,   24.4087486,   2.72727275
  51727,  -21.7534161,   24.4087486,   2.72727275
  51728,   -20.876709,   24.4087486,   2.72727275
  51729,  -29.0247936,   25.1435413,   2.72727275
  51730,  -28.0495872,   25.1435413,   2.72727275
  51731,  -27.0743809,   25.1435413,   2.72727275
  51732,  -26.0991726,   25.1435413,   2.72727275
  51733,  -25.2278633,   25.1435413,   2.72727275
  51734,  -24.3565521,   25.1435413,   2.72727275
  51735,  -23.4852428,   25.1435413,   2.72727275
  51736,  -22.6139317,   25.1435413,   2.72727275
  51737,  -21.7426205,   25.1435413,   2.72727275
  51738,  -20.8713112,   25.1435413,   2.72727275
  51739,  -29.0247936,     25.94067,   2.72727275
  51740,  -28.0495872,     25.94067,   2.72727275
  51741,  -27.0743809,     25.94067,   2.72727275
  51742,  -26.0991726,     25.94067,   2.72727275
  51743,  -25.2278633,     25.94067,   2.72727275
  51744,  -24.3565521,     25.94067,   2.72727275
  51745,  -23.4852428,     25.94067,   2.72727275
  51746,  -22.6139317,     25.94067,   2.72727275
  51747,  -21.7426205,     25.94067,   2.72727275
  51748,  -20.8713112,     25.94067,   2.72727275
  51749,  -29.0247936,   26.7377987,   2.72727275
  51750,  -28.0495872,   26.7377987,   2.72727275
  51751,  -27.0743809,   26.7377987,   2.72727275
  51752,  -26.0991726,   26.7377987,   2.72727275
  51753,  -25.2278633,   26.7377987,   2.72727275
  51754,  -24.3565521,   26.7377987,   2.72727275
  51755,  -23.4852428,   26.7377987,   2.72727275
  51756,  -22.6139317,   26.7377987,   2.72727275
  51757,  -21.7426205,   26.7377987,   2.72727275
  51758,  -20.8713112,   26.7377987,   2.72727275
  51759,  -29.0247936,   27.5349274,   2.72727275
  51760,  -28.0495872,   27.5349274,   2.72727275
  51761,  -27.0743809,   27.5349274,   2.72727275
  51762,  -26.0991726,   27.5349274,   2.72727275
  51763,  -25.2278633,   27.5349274,   2.72727275
  51764,  -24.3565521,   27.5349274,   2.72727275
  51765,  -23.4852428,   27.5349274,   2.72727275
  51766,  -22.6139317,   27.5349274,   2.72727275
  51767,  -21.7426205,   27.5349274,   2.72727275
  51768,  -20.8713112,   27.5349274,   2.72727275
  51769,  -29.0247936,    28.332058,   2.72727275
  51770,  -28.0495872,    28.332058,   2.72727275
  51771,  -27.0743809,    28.332058,   2.72727275
  51772,  -26.0991726,    28.332058,   2.72727275
  51773,  -25.2278633,    28.332058,   2.72727275
  51774,  -24.3565521,    28.332058,   2.72727275
  51775,  -23.4852428,    28.332058,   2.72727275
  51776,  -22.6139317,    28.332058,   2.72727275
  51777,  -21.7426205,    28.332058,   2.72727275
  51778,  -20.8713112,    28.332058,   2.72727275
  51779,  -29.0247936,   29.1291866,   2.72727275
  51780,  -28.0495872,   29.1291866,   2.72727275
  51781,  -27.0743809,   29.1291866,   2.72727275
  51782,  -26.0991726,   29.1291866,   2.72727275
  51783,  -25.2278633,   29.1291866,   2.72727275
  51784,  -24.3565521,   29.1291866,   2.72727275
  51785,  -23.4852428,   29.1291866,   2.72727275
  51786,  -22.6139317,   29.1291866,   2.72727275
  51787,  -21.7426205,   29.1291866,   2.72727275
  51788,  -20.8713112,   29.1291866,   2.72727275
  51789,  -29.0247936,   29.9263153,   2.72727275
  51790,  -28.0495872,   29.9263153,   2.72727275
  51791,  -27.0743809,   29.9263153,   2.72727275
  51792,  -26.0991726,   29.9263153,   2.72727275
  51793,  -25.2278633,   29.9263153,   2.72727275
  51794,  -24.3565521,   29.9263153,   2.72727275
  51795,  -23.4852428,   29.9263153,   2.72727275
  51796,  -22.6139317,   29.9263153,   2.72727275
  51797,  -21.7426205,   29.9263153,   2.72727275
  51798,  -20.8713112,   29.9263153,   2.72727275
  51799,  -29.0247936,   30.7234459,   2.72727275
  51800,  -28.0495872,   30.7234459,   2.72727275
  51801,  -27.0743809,   30.7234459,   2.72727275
  51802,  -26.0991726,   30.7234459,   2.72727275
  51803,  -25.2278633,   30.7234459,   2.72727275
  51804,  -24.3565521,   30.7234459,   2.72727275
  51805,  -23.4852428,   30.7234459,   2.72727275
  51806,  -22.6139317,   30.7234459,   2.72727275
  51807,  -21.7426205,   30.7234459,   2.72727275
  51808,  -20.8713112,   30.7234459,   2.72727275
  51809,  -29.0247936,   31.5205746,   2.72727275
  51810,  -28.0495872,   31.5205746,   2.72727275
  51811,  -27.0743809,   31.5205746,   2.72727275
  51812,  -26.0991726,   31.5205746,   2.72727275
  51813,  -25.2278633,   31.5205746,   2.72727275
  51814,  -24.3565521,   31.5205746,   2.72727275
  51815,  -23.4852428,   31.5205746,   2.72727275
  51816,  -22.6139317,   31.5205746,   2.72727275
  51817,  -21.7426205,   31.5205746,   2.72727275
  51818,  -20.8713112,   31.5205746,   2.72727275
  51819,  -29.0247936,   32.3177032,   2.72727275
  51820,  -28.0495872,   32.3177032,   2.72727275
  51821,  -27.0743809,   32.3177032,   2.72727275
  51822,  -26.0991726,   32.3177032,   2.72727275
  51823,  -25.2278633,   32.3177032,   2.72727275
  51824,  -24.3565521,   32.3177032,   2.72727275
  51825,  -23.4852428,   32.3177032,   2.72727275
  51826,  -22.6139317,   32.3177032,   2.72727275
  51827,  -21.7426205,   32.3177032,   2.72727275
  51828,  -20.8713112,   32.3177032,   2.72727275
  51829,  -29.0247936,   33.1148338,   2.72727275
  51830,  -28.0495872,   33.1148338,   2.72727275
  51831,  -27.0743809,   33.1148338,   2.72727275
  51832,  -26.0991726,   33.1148338,   2.72727275
  51833,  -25.2278633,   33.1148338,   2.72727275
  51834,  -24.3565521,   33.1148338,   2.72727275
  51835,  -23.4852428,   33.1148338,   2.72727275
  51836,  -22.6139317,   33.1148338,   2.72727275
  51837,  -21.7426205,   33.1148338,   2.72727275
  51838,  -20.8713112,   33.1148338,   2.72727275
  51839,  -29.0247936,   33.9119606,   2.72727275
  51840,  -28.0495872,   33.9119606,   2.72727275
  51841,  -27.0743809,   33.9119606,   2.72727275
  51842,  -26.0991726,   33.9119606,   2.72727275
  51843,  -25.2278633,   33.9119606,   2.72727275
  51844,  -24.3565521,   33.9119606,   2.72727275
  51845,  -23.4852428,   33.9119606,   2.72727275
  51846,  -22.6139317,   33.9119606,   2.72727275
  51847,  -21.7426205,   33.9119606,   2.72727275
  51848,  -20.8713112,   33.9119606,   2.72727275
  51849,  -29.0247936,   34.7090912,   2.72727275
  51850,  -28.0495872,   34.7090912,   2.72727275
  51851,  -27.0743809,   34.7090912,   2.72727275
  51852,  -26.0991726,   34.7090912,   2.72727275
  51853,  -25.2278633,   34.7090912,   2.72727275
  51854,  -24.3565521,   34.7090912,   2.72727275
  51855,  -23.4852428,   34.7090912,   2.72727275
  51856,  -22.6139317,   34.7090912,   2.72727275
  51857,  -21.7426205,   34.7090912,   2.72727275
  51858,  -20.8713112,   34.7090912,   2.72727275
  51859,  -29.0247936,   35.5062218,   2.72727275
  51860,  -28.0495872,   35.5062218,   2.72727275
  51861,  -27.0743809,   35.5062218,   2.72727275
  51862,  -26.0991726,   35.5062218,   2.72727275
  51863,  -25.2278633,   35.5062218,   2.72727275
  51864,  -24.3565521,   35.5062218,   2.72727275
  51865,  -23.4852428,   35.5062218,   2.72727275
  51866,  -22.6139317,   35.5062218,   2.72727275
  51867,  -21.7426205,   35.5062218,   2.72727275
  51868,  -20.8713112,   35.5062218,   2.72727275
  51869,  -29.0247936,   36.3033485,   2.72727275
  51870,  -28.0495872,   36.3033485,   2.72727275
  51871,  -27.0743809,   36.3033485,   2.72727275
  51872,  -26.0991726,   36.3033485,   2.72727275
  51873,  -25.2278633,   36.3033485,   2.72727275
  51874,  -24.3565521,   36.3033485,   2.72727275
  51875,  -23.4852428,   36.3033485,   2.72727275
  51876,  -22.6139317,   36.3033485,   2.72727275
  51877,  -21.7426205,   36.3033485,   2.72727275
  51878,  -20.8713112,   36.3033485,   2.72727275
  51879,  -29.0247936,   37.1004791,   2.72727275
  51880,  -28.0495872,   37.1004791,   2.72727275
  51881,  -27.0743809,   37.1004791,   2.72727275
  51882,  -26.0991726,   37.1004791,   2.72727275
  51883,  -25.2278633,   37.1004791,   2.72727275
  51884,  -24.3565521,   37.1004791,   2.72727275
  51885,  -23.4852428,   37.1004791,   2.72727275
  51886,  -22.6139317,   37.1004791,   2.72727275
  51887,  -21.7426205,   37.1004791,   2.72727275
  51888,  -20.8713112,   37.1004791,   2.72727275
  51889,  -29.0247936,   37.8976059,   2.72727275
  51890,  -28.0495872,   37.8976059,   2.72727275
  51891,  -27.0743809,   37.8976059,   2.72727275
  51892,  -26.0991726,   37.8976059,   2.72727275
  51893,  -25.2278633,   37.8976059,   2.72727275
  51894,  -24.3565521,   37.8976059,   2.72727275
  51895,  -23.4852428,   37.8976059,   2.72727275
  51896,  -22.6139317,   37.8976059,   2.72727275
  51897,  -21.7426205,   37.8976059,   2.72727275
  51898,  -20.8713112,   37.8976059,   2.72727275
  51899,  -29.0247936,   38.6947365,   2.72727275
  51900,  -28.0495872,   38.6947365,   2.72727275
  51901,  -27.0743809,   38.6947365,   2.72727275
  51902,  -26.0991726,   38.6947365,   2.72727275
  51903,  -25.2278633,   38.6947365,   2.72727275
  51904,  -24.3565521,   38.6947365,   2.72727275
  51905,  -23.4852428,   38.6947365,   2.72727275
  51906,  -22.6139317,   38.6947365,   2.72727275
  51907,  -21.7426205,   38.6947365,   2.72727275
  51908,  -20.8713112,   38.6947365,   2.72727275
  51909,  -29.0247936,   39.4918671,   2.72727275
  51910,  -28.0495872,   39.4918671,   2.72727275
  51911,  -27.0743809,   39.4918671,   2.72727275
  51912,  -26.0991726,   39.4918671,   2.72727275
  51913,  -25.2278633,   39.4918671,   2.72727275
  51914,  -24.3565521,   39.4918671,   2.72727275
  51915,  -23.4852428,   39.4918671,   2.72727275
  51916,  -22.6139317,   39.4918671,   2.72727275
  51917,  -21.7426205,   39.4918671,   2.72727275
  51918,  -20.8713112,   39.4918671,   2.72727275
  51919,  -29.0247936,   40.2889938,   2.72727275
  51920,  -28.0495872,   40.2889938,   2.72727275
  51921,  -27.0743809,   40.2889938,   2.72727275
  51922,  -26.0991726,   40.2889938,   2.72727275
  51923,  -25.2278633,   40.2889938,   2.72727275
  51924,  -24.3565521,   40.2889938,   2.72727275
  51925,  -23.4852428,   40.2889938,   2.72727275
  51926,  -22.6139317,   40.2889938,   2.72727275
  51927,  -21.7426205,   40.2889938,   2.72727275
  51928,  -20.8713112,   40.2889938,   2.72727275
  51929,  -29.0247936,   41.0861244,   2.72727275
  51930,  -28.0495872,   41.0861244,   2.72727275
  51931,  -27.0743809,   41.0861244,   2.72727275
  51932,  -26.0991726,   41.0861244,   2.72727275
  51933,  -25.2278633,   41.0861244,   2.72727275
  51934,  -24.3565521,   41.0861244,   2.72727275
  51935,  -23.4852428,   41.0861244,   2.72727275
  51936,  -22.6139317,   41.0861244,   2.72727275
  51937,  -21.7426205,   41.0861244,   2.72727275
  51938,  -20.8713112,   41.0861244,   2.72727275
  51939,  -29.0247936,    41.883255,   2.72727275
  51940,  -28.0495872,    41.883255,   2.72727275
  51941,  -27.0743809,    41.883255,   2.72727275
  51942,  -26.0991726,    41.883255,   2.72727275
  51943,  -25.2278633,    41.883255,   2.72727275
  51944,  -24.3565521,    41.883255,   2.72727275
  51945,  -23.4852428,    41.883255,   2.72727275
  51946,  -22.6139317,    41.883255,   2.72727275
  51947,  -21.7426205,    41.883255,   2.72727275
  51948,  -20.8713112,    41.883255,   2.72727275
  51949,  -29.0247936,   42.6803818,   2.72727275
  51950,  -28.0495872,   42.6803818,   2.72727275
  51951,  -27.0743809,   42.6803818,   2.72727275
  51952,  -26.0991726,   42.6803818,   2.72727275
  51953,  -25.2278633,   42.6803818,   2.72727275
  51954,  -24.3565521,   42.6803818,   2.72727275
  51955,  -23.4852428,   42.6803818,   2.72727275
  51956,  -22.6139317,   42.6803818,   2.72727275
  51957,  -21.7426205,   42.6803818,   2.72727275
  51958,  -20.8713112,   42.6803818,   2.72727275
  51959,  -29.0247936,   43.4775124,   2.72727275
  51960,  -28.0495872,   43.4775124,   2.72727275
  51961,  -27.0743809,   43.4775124,   2.72727275
  51962,  -26.0991726,   43.4775124,   2.72727275
  51963,  -25.2278633,   43.4775124,   2.72727275
  51964,  -24.3565521,   43.4775124,   2.72727275
  51965,  -23.4852428,   43.4775124,   2.72727275
  51966,  -22.6139317,   43.4775124,   2.72727275
  51967,  -21.7426205,   43.4775124,   2.72727275
  51968,  -20.8713112,   43.4775124,   2.72727275
  51969,  -29.0247936,   44.2746429,   2.72727275
  51970,  -28.0495872,   44.2746429,   2.72727275
  51971,  -27.0743809,   44.2746429,   2.72727275
  51972,  -26.0991726,   44.2746429,   2.72727275
  51973,  -25.2278633,   44.2746429,   2.72727275
  51974,  -24.3565521,   44.2746429,   2.72727275
  51975,  -23.4852428,   44.2746429,   2.72727275
  51976,  -22.6139317,   44.2746429,   2.72727275
  51977,  -21.7426205,   44.2746429,   2.72727275
  51978,  -20.8713112,   44.2746429,   2.72727275
  51979,  -29.0247936,   45.0717697,   2.72727275
  51980,  -28.0495872,   45.0717697,   2.72727275
  51981,  -27.0743809,   45.0717697,   2.72727275
  51982,  -26.0991726,   45.0717697,   2.72727275
  51983,  -25.2278633,   45.0717697,   2.72727275
  51984,  -24.3565521,   45.0717697,   2.72727275
  51985,  -23.4852428,   45.0717697,   2.72727275
  51986,  -22.6139317,   45.0717697,   2.72727275
  51987,  -21.7426205,   45.0717697,   2.72727275
  51988,  -20.8713112,   45.0717697,   2.72727275
  51989,  -29.0358124,   45.8931427,   2.72727275
  51990,  -28.0716267,   45.8931427,   2.72727275
  51991,  -27.1074371,   45.8931427,   2.72727275
  51992,  -26.1432514,   45.8931427,   2.72727275
  51993,  -25.2656441,   45.8931427,   2.72727275
  51994,  -24.3880367,   45.8931427,   2.72727275
