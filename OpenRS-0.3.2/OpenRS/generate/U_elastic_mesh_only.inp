   9995,   26.5979786,   63.8761482,   6.36363649
   9996,   26.1395607,   64.7215271,   6.36363649
   9997,   25.6542816,   65.5517807,   6.36363649
   9998,   25.1426411,   66.3660507,   6.36363649
   9999,   24.6051693,   67.1634979,   6.36363649
  10000,   24.0424099,   67.9433136,   6.36363649
  10001,   23.4549427,   68.7046967,   6.36363649
  10002,   22.8433781,   69.4468536,   6.36363649
  10003,   22.2083378,   70.1690292,   6.36363649
  10004,   21.5504799,   70.8704758,   6.36363649
  10005,   20.8704739,   71.5504837,   6.36363649
  10006,   20.1690254,   72.2083435,   6.36363649
  10007,   19.4468536,   72.8433762,   6.36363649
  10008,   18.7046967,   73.4549408,   6.36363649
  10009,   17.9433136,   74.0424118,   6.36363649
  10010,   17.1634979,   74.6051712,   6.36363649
  10011,    16.366045,   75.1426468,   6.36363649
  10012,   15.5517778,   75.6542816,   6.36363649
  10013,   14.7215252,   76.1395645,   6.36363649
  10014,   13.8761501,   76.5979767,   6.36363649
  10015,    13.016511,    77.029068,   6.36363649
  10016,   12.1434994,   77.4323807,   6.36363649
  10017,   11.2580099,   77.8075027,   6.36363649
  10018,   10.3609514,   78.1540527,   6.36363649
  10019,   9.45324612,   78.4716721,   6.36363649
  10020,   8.53582859,   78.7600327,   6.36363649
  10021,   7.60963821,   79.0188446,   6.36363649
  10022,   6.67562723,   79.2478409,   6.36363649
  10023,   5.73475838,   79.4467773,   6.36363649
  10024,   4.78799629,   79.6154556,   6.36363649
  10025,   3.83631492,   79.7537003,   6.36363649
  10026,   2.88069081,   79.8613739,   6.36363649
  10027,   1.92210662,   79.9383621,   6.36363649
  10028,  0.961547256,   79.9845886,   6.36363649
  10029,           0.,          80.,   6.36363649
  10030, -0.961547256,   79.9845886,   6.36363649
  10031,  -1.92210662,   79.9383621,   6.36363649
  10032,  -2.88069081,   79.8613739,   6.36363649
  10033,  -3.83631492,   79.7537003,   6.36363649
  10034,  -4.78799629,   79.6154556,   6.36363649
  10035,  -5.73475838,   79.4467773,   6.36363649
  10036,  -6.67562723,   79.2478409,   6.36363649
  10037,  -7.60963821,   79.0188446,   6.36363649
  10038,  -8.53582859,   78.7600327,   6.36363649
  10039,  -9.45324612,   78.4716721,   6.36363649
  10040,  -10.3609514,   78.1540527,   6.36363649
  10041,  -11.2580099,   77.8075027,   6.36363649
  10042,  -12.1434994,   77.4323807,   6.36363649
  10043,   -13.016511,    77.029068,   6.36363649
  10044,  -13.8761501,   76.5979767,   6.36363649
  10045,  -14.7215252,   76.1395645,   6.36363649
  10046,  -15.5517778,   75.6542816,   6.36363649
  10047,   -16.366045,   75.1426468,   6.36363649
  10048,  -17.1634979,   74.6051712,   6.36363649
  10049,  -17.9433136,   74.0424118,   6.36363649
  10050,  -18.7046967,   73.4549408,   6.36363649
  10051,  -19.4468536,   72.8433762,   6.36363649
  10052,  -20.1690254,   72.2083435,   6.36363649
  10053,  -20.8704739,   71.5504837,   6.36363649
  10054,  -21.5504799,   70.8704758,   6.36363649
  10055,  -22.2083378,   70.1690292,   6.36363649
  10056,  -22.8433781,   69.4468536,   6.36363649
  10057,  -23.4549427,   68.7046967,   6.36363649
  10058,  -24.0424099,   67.9433136,   6.36363649
  10059,  -24.6051693,   67.1634979,   6.36363649
  10060,  -25.1426411,   66.3660507,   6.36363649
  10061,  -25.6542816,   65.5517807,   6.36363649
  10062,  -26.1395607,   64.7215271,   6.36363649
  10063,  -26.5979786,   63.8761482,   6.36363649
  10064,  -27.0290661,   63.0165138,   6.36363649
  10065,  -27.4323788,   62.1435013,   6.36363649
  10066,  -27.8075027,   61.2580109,   6.36363649
  10067,  -28.1540527,   60.3609505,   6.36363649
  10068,  -28.4716721,   59.4532471,   6.36363649
  10069,  -28.7600365,   58.5358276,   6.36363649
  10070,  -29.0188465,   57.6096382,   6.36363649
  10071,  -29.2478371,   56.6756287,   6.36363649
  10072,  -29.4467735,   55.7347603,   6.36363649
  10073,  -29.6154537,   54.7879982,   6.36363649
  10074,  -29.7537003,   53.8363152,   6.36363649
  10075,  -29.8613739,   52.8806915,   6.36363649
  10076,  -29.9383621,   51.9221077,   6.36363649
  10077,  -29.9845867,   50.9615479,   6.36363649
  10078,   29.9845867,   50.9615479,   7.27272749
  10079,   29.9383621,   51.9221077,   7.27272749
  10080,   29.8613739,   52.8806915,   7.27272749
  10081,   29.7537003,   53.8363152,   7.27272749
  10082,   29.6154537,   54.7879982,   7.27272749
  10083,   29.4467735,   55.7347603,   7.27272749
  10084,   29.2478371,   56.6756287,   7.27272749
  10085,   29.0188465,   57.6096382,   7.27272749
  10086,   28.7600365,   58.5358276,   7.27272749
  10087,   28.4716721,   59.4532471,   7.27272749
  10088,   28.1540527,   60.3609505,   7.27272749
  10089,   27.8075027,   61.2580109,   7.27272749
  10090,   27.4323788,   62.1435013,   7.27272749
  10091,   27.0290661,   63.0165138,   7.27272749
  10092,   26.5979786,   63.8761482,   7.27272749
  10093,   26.1395607,   64.7215271,   7.27272749
  10094,   25.6542816,   65.5517807,   7.27272749
  10095,   25.1426411,   66.3660507,   7.27272749
  10096,   24.6051693,   67.1634979,   7.27272749
  10097,   24.0424099,   67.9433136,   7.27272749
  10098,   23.4549427,   68.7046967,   7.27272749
  10099,   22.8433781,   69.4468536,   7.27272749
  10100,   22.2083378,   70.1690292,   7.27272749
  10101,   21.5504799,   70.8704758,   7.27272749
  10102,   20.8704739,   71.5504837,   7.27272749
  10103,   20.1690254,   72.2083435,   7.27272749
  10104,   19.4468536,   72.8433762,   7.27272749
  10105,   18.7046967,   73.4549408,   7.27272749
  10106,   17.9433136,   74.0424118,   7.27272749
  10107,   17.1634979,   74.6051712,   7.27272749
  10108,    16.366045,   75.1426468,   7.27272749
  10109,   15.5517778,   75.6542816,   7.27272749
  10110,   14.7215252,   76.1395645,   7.27272749
  10111,   13.8761501,   76.5979767,   7.27272749
  10112,    13.016511,    77.029068,   7.27272749
  10113,   12.1434994,   77.4323807,   7.27272749
  10114,   11.2580099,   77.8075027,   7.27272749
  10115,   10.3609514,   78.1540527,   7.27272749
  10116,   9.45324612,   78.4716721,   7.27272749
  10117,   8.53582859,   78.7600327,   7.27272749
  10118,   7.60963821,   79.0188446,   7.27272749
  10119,   6.67562723,   79.2478409,   7.27272749
  10120,   5.73475838,   79.4467773,   7.27272749
  10121,   4.78799629,   79.6154556,   7.27272749
  10122,   3.83631492,   79.7537003,   7.27272749
  10123,   2.88069081,   79.8613739,   7.27272749
  10124,   1.92210662,   79.9383621,   7.27272749
  10125,  0.961547256,   79.9845886,   7.27272749
  10126,           0.,          80.,   7.27272749
  10127, -0.961547256,   79.9845886,   7.27272749
  10128,  -1.92210662,   79.9383621,   7.27272749
  10129,  -2.88069081,   79.8613739,   7.27272749
  10130,  -3.83631492,   79.7537003,   7.27272749
  10131,  -4.78799629,   79.6154556,   7.27272749
  10132,  -5.73475838,   79.4467773,   7.27272749
  10133,  -6.67562723,   79.2478409,   7.27272749
  10134,  -7.60963821,   79.0188446,   7.27272749
  10135,  -8.53582859,   78.7600327,   7.27272749
  10136,  -9.45324612,   78.4716721,   7.27272749
  10137,  -10.3609514,   78.1540527,   7.27272749
  10138,  -11.2580099,   77.8075027,   7.27272749
  10139,  -12.1434994,   77.4323807,   7.27272749
  10140,   -13.016511,    77.029068,   7.27272749
  10141,  -13.8761501,   76.5979767,   7.27272749
  10142,  -14.7215252,   76.1395645,   7.27272749
  10143,  -15.5517778,   75.6542816,   7.27272749
  10144,   -16.366045,   75.1426468,   7.27272749
  10145,  -17.1634979,   74.6051712,   7.27272749
  10146,  -17.9433136,   74.0424118,   7.27272749
  10147,  -18.7046967,   73.4549408,   7.27272749
  10148,  -19.4468536,   72.8433762,   7.27272749
  10149,  -20.1690254,   72.2083435,   7.27272749
  10150,  -20.8704739,   71.5504837,   7.27272749
  10151,  -21.5504799,   70.8704758,   7.27272749
  10152,  -22.2083378,   70.1690292,   7.27272749
  10153,  -22.8433781,   69.4468536,   7.27272749
  10154,  -23.4549427,   68.7046967,   7.27272749
  10155,  -24.0424099,   67.9433136,   7.27272749
  10156,  -24.6051693,   67.1634979,   7.27272749
  10157,  -25.1426411,   66.3660507,   7.27272749
  10158,  -25.6542816,   65.5517807,   7.27272749
  10159,  -26.1395607,   64.7215271,   7.27272749
  10160,  -26.5979786,   63.8761482,   7.27272749
  10161,  -27.0290661,   63.0165138,   7.27272749
  10162,  -27.4323788,   62.1435013,   7.27272749
  10163,  -27.8075027,   61.2580109,   7.27272749
  10164,  -28.1540527,   60.3609505,   7.27272749
  10165,  -28.4716721,   59.4532471,   7.27272749
  10166,  -28.7600365,   58.5358276,   7.27272749
  10167,  -29.0188465,   57.6096382,   7.27272749
  10168,  -29.2478371,   56.6756287,   7.27272749
  10169,  -29.4467735,   55.7347603,   7.27272749
  10170,  -29.6154537,   54.7879982,   7.27272749
  10171,  -29.7537003,   53.8363152,   7.27272749
  10172,  -29.8613739,   52.8806915,   7.27272749
  10173,  -29.9383621,   51.9221077,   7.27272749
  10174,  -29.9845867,   50.9615479,   7.27272749
  10175,   29.9845867,   50.9615479,   8.18181801
  10176,   29.9383621,   51.9221077,   8.18181801
  10177,   29.8613739,   52.8806915,   8.18181801
  10178,   29.7537003,   53.8363152,   8.18181801
  10179,   29.6154537,   54.7879982,   8.18181801
  10180,   29.4467735,   55.7347603,   8.18181801
  10181,   29.2478371,   56.6756287,   8.18181801
  10182,   29.0188465,   57.6096382,   8.18181801
  10183,   28.7600365,   58.5358276,   8.18181801
  10184,   28.4716721,   59.4532471,   8.18181801
  10185,   28.1540527,   60.3609505,   8.18181801
  10186,   27.8075027,   61.2580109,   8.18181801
  10187,   27.4323788,   62.1435013,   8.18181801
  10188,   27.0290661,   63.0165138,   8.18181801
  10189,   26.5979786,   63.8761482,   8.18181801
  10190,   26.1395607,   64.7215271,   8.18181801
  10191,   25.6542816,   65.5517807,   8.18181801
  10192,   25.1426411,   66.3660507,   8.18181801
  10193,   24.6051693,   67.1634979,   8.18181801
  10194,   24.0424099,   67.9433136,   8.18181801
  10195,   23.4549427,   68.7046967,   8.18181801
  10196,   22.8433781,   69.4468536,   8.18181801
  10197,   22.2083378,   70.1690292,   8.18181801
  10198,   21.5504799,   70.8704758,   8.18181801
  10199,   20.8704739,   71.5504837,   8.18181801
  10200,   20.1690254,   72.2083435,   8.18181801
  10201,   19.4468536,   72.8433762,   8.18181801
  10202,   18.7046967,   73.4549408,   8.18181801
  10203,   17.9433136,   74.0424118,   8.18181801
  10204,   17.1634979,   74.6051712,   8.18181801
  10205,    16.366045,   75.1426468,   8.18181801
  10206,   15.5517778,   75.6542816,   8.18181801
  10207,   14.7215252,   76.1395645,   8.18181801
  10208,   13.8761501,   76.5979767,   8.18181801
  10209,    13.016511,    77.029068,   8.18181801
  10210,   12.1434994,   77.4323807,   8.18181801
  10211,   11.2580099,   77.8075027,   8.18181801
  10212,   10.3609514,   78.1540527,   8.18181801
  10213,   9.45324612,   78.4716721,   8.18181801
  10214,   8.53582859,   78.7600327,   8.18181801
  10215,   7.60963821,   79.0188446,   8.18181801
  10216,   6.67562723,   79.2478409,   8.18181801
  10217,   5.73475838,   79.4467773,   8.18181801
  10218,   4.78799629,   79.6154556,   8.18181801
  10219,   3.83631492,   79.7537003,   8.18181801
  10220,   2.88069081,   79.8613739,   8.18181801
  10221,   1.92210662,   79.9383621,   8.18181801
  10222,  0.961547256,   79.9845886,   8.18181801
  10223,           0.,          80.,   8.18181801
  10224, -0.961547256,   79.9845886,   8.18181801
  10225,  -1.92210662,   79.9383621,   8.18181801
  10226,  -2.88069081,   79.8613739,   8.18181801
  10227,  -3.83631492,   79.7537003,   8.18181801
  10228,  -4.78799629,   79.6154556,   8.18181801
  10229,  -5.73475838,   79.4467773,   8.18181801
  10230,  -6.67562723,   79.2478409,   8.18181801
  10231,  -7.60963821,   79.0188446,   8.18181801
  10232,  -8.53582859,   78.7600327,   8.18181801
  10233,  -9.45324612,   78.4716721,   8.18181801
  10234,  -10.3609514,   78.1540527,   8.18181801
  10235,  -11.2580099,   77.8075027,   8.18181801
  10236,  -12.1434994,   77.4323807,   8.18181801
  10237,   -13.016511,    77.029068,   8.18181801
  10238,  -13.8761501,   76.5979767,   8.18181801
  10239,  -14.7215252,   76.1395645,   8.18181801
  10240,  -15.5517778,   75.6542816,   8.18181801
  10241,   -16.366045,   75.1426468,   8.18181801
  10242,  -17.1634979,   74.6051712,   8.18181801
  10243,  -17.9433136,   74.0424118,   8.18181801
  10244,  -18.7046967,   73.4549408,   8.18181801
  10245,  -19.4468536,   72.8433762,   8.18181801
  10246,  -20.1690254,   72.2083435,   8.18181801
  10247,  -20.8704739,   71.5504837,   8.18181801
  10248,  -21.5504799,   70.8704758,   8.18181801
  10249,  -22.2083378,   70.1690292,   8.18181801
  10250,  -22.8433781,   69.4468536,   8.18181801
  10251,  -23.4549427,   68.7046967,   8.18181801
  10252,  -24.0424099,   67.9433136,   8.18181801
  10253,  -24.6051693,   67.1634979,   8.18181801
  10254,  -25.1426411,   66.3660507,   8.18181801
  10255,  -25.6542816,   65.5517807,   8.18181801
  10256,  -26.1395607,   64.7215271,   8.18181801
  10257,  -26.5979786,   63.8761482,   8.18181801
  10258,  -27.0290661,   63.0165138,   8.18181801
  10259,  -27.4323788,   62.1435013,   8.18181801
  10260,  -27.8075027,   61.2580109,   8.18181801
  10261,  -28.1540527,   60.3609505,   8.18181801
  10262,  -28.4716721,   59.4532471,   8.18181801
  10263,  -28.7600365,   58.5358276,   8.18181801
  10264,  -29.0188465,   57.6096382,   8.18181801
  10265,  -29.2478371,   56.6756287,   8.18181801
  10266,  -29.4467735,   55.7347603,   8.18181801
  10267,  -29.6154537,   54.7879982,   8.18181801
  10268,  -29.7537003,   53.8363152,   8.18181801
  10269,  -29.8613739,   52.8806915,   8.18181801
  10270,  -29.9383621,   51.9221077,   8.18181801
  10271,  -29.9845867,   50.9615479,   8.18181801
  10272,   29.9845867,   50.9615479,     9.090909
  10273,   29.9383621,   51.9221077,     9.090909
  10274,   29.8613739,   52.8806915,     9.090909
  10275,   29.7537003,   53.8363152,     9.090909
  10276,   29.6154537,   54.7879982,     9.090909
  10277,   29.4467735,   55.7347603,     9.090909
  10278,   29.2478371,   56.6756287,     9.090909
  10279,   29.0188465,   57.6096382,     9.090909
  10280,   28.7600365,   58.5358276,     9.090909
  10281,   28.4716721,   59.4532471,     9.090909
  10282,   28.1540527,   60.3609505,     9.090909
  10283,   27.8075027,   61.2580109,     9.090909
  10284,   27.4323788,   62.1435013,     9.090909
  10285,   27.0290661,   63.0165138,     9.090909
  10286,   26.5979786,   63.8761482,     9.090909
  10287,   26.1395607,   64.7215271,     9.090909
  10288,   25.6542816,   65.5517807,     9.090909
  10289,   25.1426411,   66.3660507,     9.090909
  10290,   24.6051693,   67.1634979,     9.090909
  10291,   24.0424099,   67.9433136,     9.090909
  10292,   23.4549427,   68.7046967,     9.090909
  10293,   22.8433781,   69.4468536,     9.090909
  10294,   22.2083378,   70.1690292,     9.090909
  10295,   21.5504799,   70.8704758,     9.090909
  10296,   20.8704739,   71.5504837,     9.090909
  10297,   20.1690254,   72.2083435,     9.090909
  10298,   19.4468536,   72.8433762,     9.090909
  10299,   18.7046967,   73.4549408,     9.090909
  10300,   17.9433136,   74.0424118,     9.090909
  10301,   17.1634979,   74.6051712,     9.090909
  10302,    16.366045,   75.1426468,     9.090909
  10303,   15.5517778,   75.6542816,     9.090909
  10304,   14.7215252,   76.1395645,     9.090909
  10305,   13.8761501,   76.5979767,     9.090909
  10306,    13.016511,    77.029068,     9.090909
  10307,   12.1434994,   77.4323807,     9.090909
  10308,   11.2580099,   77.8075027,     9.090909
  10309,   10.3609514,   78.1540527,     9.090909
  10310,   9.45324612,   78.4716721,     9.090909
  10311,   8.53582859,   78.7600327,     9.090909
  10312,   7.60963821,   79.0188446,     9.090909
  10313,   6.67562723,   79.2478409,     9.090909
  10314,   5.73475838,   79.4467773,     9.090909
  10315,   4.78799629,   79.6154556,     9.090909
  10316,   3.83631492,   79.7537003,     9.090909
  10317,   2.88069081,   79.8613739,     9.090909
  10318,   1.92210662,   79.9383621,     9.090909
  10319,  0.961547256,   79.9845886,     9.090909
  10320,           0.,          80.,     9.090909
  10321, -0.961547256,   79.9845886,     9.090909
  10322,  -1.92210662,   79.9383621,     9.090909
  10323,  -2.88069081,   79.8613739,     9.090909
  10324,  -3.83631492,   79.7537003,     9.090909
  10325,  -4.78799629,   79.6154556,     9.090909
  10326,  -5.73475838,   79.4467773,     9.090909
  10327,  -6.67562723,   79.2478409,     9.090909
  10328,  -7.60963821,   79.0188446,     9.090909
  10329,  -8.53582859,   78.7600327,     9.090909
  10330,  -9.45324612,   78.4716721,     9.090909
  10331,  -10.3609514,   78.1540527,     9.090909
  10332,  -11.2580099,   77.8075027,     9.090909
  10333,  -12.1434994,   77.4323807,     9.090909
  10334,   -13.016511,    77.029068,     9.090909
  10335,  -13.8761501,   76.5979767,     9.090909
  10336,  -14.7215252,   76.1395645,     9.090909
  10337,  -15.5517778,   75.6542816,     9.090909
  10338,   -16.366045,   75.1426468,     9.090909
  10339,  -17.1634979,   74.6051712,     9.090909
  10340,  -17.9433136,   74.0424118,     9.090909
  10341,  -18.7046967,   73.4549408,     9.090909
  10342,  -19.4468536,   72.8433762,     9.090909
  10343,  -20.1690254,   72.2083435,     9.090909
  10344,  -20.8704739,   71.5504837,     9.090909
  10345,  -21.5504799,   70.8704758,     9.090909
  10346,  -22.2083378,   70.1690292,     9.090909
  10347,  -22.8433781,   69.4468536,     9.090909
  10348,  -23.4549427,   68.7046967,     9.090909
  10349,  -24.0424099,   67.9433136,     9.090909
  10350,  -24.6051693,   67.1634979,     9.090909
  10351,  -25.1426411,   66.3660507,     9.090909
  10352,  -25.6542816,   65.5517807,     9.090909
  10353,  -26.1395607,   64.7215271,     9.090909
  10354,  -26.5979786,   63.8761482,     9.090909
  10355,  -27.0290661,   63.0165138,     9.090909
  10356,  -27.4323788,   62.1435013,     9.090909
  10357,  -27.8075027,   61.2580109,     9.090909
  10358,  -28.1540527,   60.3609505,     9.090909
  10359,  -28.4716721,   59.4532471,     9.090909
  10360,  -28.7600365,   58.5358276,     9.090909
  10361,  -29.0188465,   57.6096382,     9.090909
  10362,  -29.2478371,   56.6756287,     9.090909
  10363,  -29.4467735,   55.7347603,     9.090909
  10364,  -29.6154537,   54.7879982,     9.090909
  10365,  -29.7537003,   53.8363152,     9.090909
  10366,  -29.8613739,   52.8806915,     9.090909
  10367,  -29.9383621,   51.9221077,     9.090909
  10368,  -29.9845867,   50.9615479,     9.090909
  10369,   19.9897251,   50.6410332,  0.909090936
  10370,   19.9589081,   51.2814026,  0.909090936
  10371,   19.9075832,   51.9204597,  0.909090936
  10372,   19.8358002,   52.5575447,  0.909090936
  10373,   19.7436352,   53.1919975,  0.909090936
  10374,   19.6311836,   53.8231735,  0.909090936
  10375,    19.498558,   54.4504204,  0.909090936
  10376,   19.3458977,   55.0730934,  0.909090936
  10377,    19.173357,   55.6905518,  0.909090936
  10378,   18.9811153,    56.302166,  0.909090936
  10379,   18.7693672,   56.9073029,  0.909090936
  10380,   18.5383358,   57.5053406,  0.909090936
  10381,   18.2882538,    58.095665,  0.909090936
  10382,   18.0193787,   58.6776733,  0.909090936
  10383,   17.7319851,   59.2507668,  0.909090936
  10384,   17.4263744,   59.8143501,  0.909090936
  10385,   17.1028557,   60.3678513,  0.909090936
  10386,   16.7617626,   60.9106979,  0.909090936
  10387,   16.4034443,   61.4423332,  0.909090936
  10388,   16.0282726,   61.9622116,  0.909090936
  10389,   15.6366301,   62.4697952,  0.909090936
  10390,   15.2289181,   62.9645691,  0.909090936
  10391,   14.8055601,   63.4460182,  0.909090936
  10392,   14.3669872,   63.9136505,  0.909090936
  10393,   13.9136505,   64.3669891,  0.909090936
  10394,   13.4460192,   64.8055573,  0.909090936
  10395,   12.9645672,     65.22892,  0.909090936
  10396,   12.4697971,   65.6366272,  0.909090936
  10397,   11.9622097,   66.0282745,  0.909090936
  10398,   11.4423342,   66.4034424,  0.909090936
  10399,    10.910697,   66.7617645,  0.909090936
  10400,   10.3678532,   67.1028519,  0.909090936
  10401,   9.81435013,   67.4263763,  0.909090936
  10402,    9.2507658,    67.731987,  0.909090936
  10403,   8.67767429,   68.0193787,  0.909090936
  10404,   8.09566593,   68.2882538,  0.909090936
  10405,   7.50533915,   68.5383377,  0.909090936
  10406,       6.9073,    68.769371,  0.909090936
  10407,   6.30216408,   68.9811172,  0.909090936
  10408,   5.69055223,   69.1733551,  0.909090936
  10409,   5.07309246,   69.3458939,  0.909090936
  10410,   4.45041847,    69.498558,  0.909090936
  10411,   3.82317328,   69.6311798,  0.909090936
  10412,   3.19199777,   69.7436371,  0.909090936
  10413,   2.55754328,   69.8358002,  0.909090936
  10414,   1.92046022,   69.9075851,  0.909090936
  10415,   1.28140438,   69.9589081,  0.909090936
  10416,  0.641031623,   69.9897232,  0.909090936
  10417,           0.,          70.,  0.909090936
  10418, -0.641031623,   69.9897232,  0.909090936
  10419,  -1.28140438,   69.9589081,  0.909090936
  10420,  -1.92046022,   69.9075851,  0.909090936
  10421,  -2.55754328,   69.8358002,  0.909090936
  10422,  -3.19199777,   69.7436371,  0.909090936
  10423,  -3.82317328,   69.6311798,  0.909090936
  10424,  -4.45041847,    69.498558,  0.909090936
  10425,  -5.07309246,   69.3458939,  0.909090936
  10426,  -5.69055223,   69.1733551,  0.909090936
  10427,  -6.30216408,   68.9811172,  0.909090936
  10428,      -6.9073,    68.769371,  0.909090936
  10429,  -7.50533915,   68.5383377,  0.909090936
  10430,  -8.09566593,   68.2882538,  0.909090936
  10431,  -8.67767429,   68.0193787,  0.909090936
  10432,   -9.2507658,    67.731987,  0.909090936
  10433,  -9.81435013,   67.4263763,  0.909090936
  10434,  -10.3678532,   67.1028519,  0.909090936
  10435,   -10.910697,   66.7617645,  0.909090936
  10436,  -11.4423342,   66.4034424,  0.909090936
  10437,  -11.9622097,   66.0282745,  0.909090936
  10438,  -12.4697971,   65.6366272,  0.909090936
  10439,  -12.9645672,     65.22892,  0.909090936
  10440,  -13.4460192,   64.8055573,  0.909090936
  10441,  -13.9136505,   64.3669891,  0.909090936
  10442,  -14.3669872,   63.9136505,  0.909090936
  10443,  -14.8055601,   63.4460182,  0.909090936
  10444,  -15.2289181,   62.9645691,  0.909090936
  10445,  -15.6366301,   62.4697952,  0.909090936
  10446,  -16.0282726,   61.9622116,  0.909090936
  10447,  -16.4034443,   61.4423332,  0.909090936
  10448,  -16.7617626,   60.9106979,  0.909090936
  10449,  -17.1028557,   60.3678513,  0.909090936
  10450,  -17.4263744,   59.8143501,  0.909090936
  10451,  -17.7319851,   59.2507668,  0.909090936
  10452,  -18.0193787,   58.6776733,  0.909090936
  10453,  -18.2882538,    58.095665,  0.909090936
  10454,  -18.5383358,   57.5053406,  0.909090936
  10455,  -18.7693672,   56.9073029,  0.909090936
  10456,  -18.9811153,    56.302166,  0.909090936
  10457,   -19.173357,   55.6905518,  0.909090936
  10458,  -19.3458977,   55.0730934,  0.909090936
  10459,   -19.498558,   54.4504204,  0.909090936
  10460,  -19.6311836,   53.8231735,  0.909090936
  10461,  -19.7436352,   53.1919975,  0.909090936
  10462,  -19.8358002,   52.5575447,  0.909090936
  10463,  -19.9075832,   51.9204597,  0.909090936
  10464,  -19.9589081,   51.2814026,  0.909090936
  10465,  -19.9897251,   50.6410332,  0.909090936
  10466,   19.9897251,   50.6410332,   1.81818187
  10467,   19.9589081,   51.2814026,   1.81818187
  10468,   19.9075832,   51.9204597,   1.81818187
  10469,   19.8358002,   52.5575447,   1.81818187
  10470,   19.7436352,   53.1919975,   1.81818187
  10471,   19.6311836,   53.8231735,   1.81818187
  10472,    19.498558,   54.4504204,   1.81818187
  10473,   19.3458977,   55.0730934,   1.81818187
  10474,    19.173357,   55.6905518,   1.81818187
  10475,   18.9811153,    56.302166,   1.81818187
  10476,   18.7693672,   56.9073029,   1.81818187
  10477,   18.5383358,   57.5053406,   1.81818187
  10478,   18.2882538,    58.095665,   1.81818187
  10479,   18.0193787,   58.6776733,   1.81818187
  10480,   17.7319851,   59.2507668,   1.81818187
  10481,   17.4263744,   59.8143501,   1.81818187
  10482,   17.1028557,   60.3678513,   1.81818187
  10483,   16.7617626,   60.9106979,   1.81818187
  10484,   16.4034443,   61.4423332,   1.81818187
  10485,   16.0282726,   61.9622116,   1.81818187
  10486,   15.6366301,   62.4697952,   1.81818187
  10487,   15.2289181,   62.9645691,   1.81818187
  10488,   14.8055601,   63.4460182,   1.81818187
  10489,   14.3669872,   63.9136505,   1.81818187
  10490,   13.9136505,   64.3669891,   1.81818187
  10491,   13.4460192,   64.8055573,   1.81818187
  10492,   12.9645672,     65.22892,   1.81818187
  10493,   12.4697971,   65.6366272,   1.81818187
  10494,   11.9622097,   66.0282745,   1.81818187
  10495,   11.4423342,   66.4034424,   1.81818187
  10496,    10.910697,   66.7617645,   1.81818187
  10497,   10.3678532,   67.1028519,   1.81818187
  10498,   9.81435013,   67.4263763,   1.81818187
  10499,    9.2507658,    67.731987,   1.81818187
  10500,   8.67767429,   68.0193787,   1.81818187
  10501,   8.09566593,   68.2882538,   1.81818187
  10502,   7.50533915,   68.5383377,   1.81818187
  10503,       6.9073,    68.769371,   1.81818187
  10504,   6.30216408,   68.9811172,   1.81818187
  10505,   5.69055223,   69.1733551,   1.81818187
  10506,   5.07309246,   69.3458939,   1.81818187
  10507,   4.45041847,    69.498558,   1.81818187
  10508,   3.82317328,   69.6311798,   1.81818187
  10509,   3.19199777,   69.7436371,   1.81818187
  10510,   2.55754328,   69.8358002,   1.81818187
  10511,   1.92046022,   69.9075851,   1.81818187
  10512,   1.28140438,   69.9589081,   1.81818187
  10513,  0.641031623,   69.9897232,   1.81818187
  10514,           0.,          70.,   1.81818187
  10515, -0.641031623,   69.9897232,   1.81818187
  10516,  -1.28140438,   69.9589081,   1.81818187
  10517,  -1.92046022,   69.9075851,   1.81818187
  10518,  -2.55754328,   69.8358002,   1.81818187
  10519,  -3.19199777,   69.7436371,   1.81818187
  10520,  -3.82317328,   69.6311798,   1.81818187
  10521,  -4.45041847,    69.498558,   1.81818187
  10522,  -5.07309246,   69.3458939,   1.81818187
  10523,  -5.69055223,   69.1733551,   1.81818187
  10524,  -6.30216408,   68.9811172,   1.81818187
  10525,      -6.9073,    68.769371,   1.81818187
  10526,  -7.50533915,   68.5383377,   1.81818187
  10527,  -8.09566593,   68.2882538,   1.81818187
  10528,  -8.67767429,   68.0193787,   1.81818187
  10529,   -9.2507658,    67.731987,   1.81818187
  10530,  -9.81435013,   67.4263763,   1.81818187
  10531,  -10.3678532,   67.1028519,   1.81818187
  10532,   -10.910697,   66.7617645,   1.81818187
  10533,  -11.4423342,   66.4034424,   1.81818187
  10534,  -11.9622097,   66.0282745,   1.81818187
  10535,  -12.4697971,   65.6366272,   1.81818187
  10536,  -12.9645672,     65.22892,   1.81818187
  10537,  -13.4460192,   64.8055573,   1.81818187
  10538,  -13.9136505,   64.3669891,   1.81818187
  10539,  -14.3669872,   63.9136505,   1.81818187
  10540,  -14.8055601,   63.4460182,   1.81818187
  10541,  -15.2289181,   62.9645691,   1.81818187
  10542,  -15.6366301,   62.4697952,   1.81818187
  10543,  -16.0282726,   61.9622116,   1.81818187
  10544,  -16.4034443,   61.4423332,   1.81818187
  10545,  -16.7617626,   60.9106979,   1.81818187
  10546,  -17.1028557,   60.3678513,   1.81818187
  10547,  -17.4263744,   59.8143501,   1.81818187
  10548,  -17.7319851,   59.2507668,   1.81818187
  10549,  -18.0193787,   58.6776733,   1.81818187
  10550,  -18.2882538,    58.095665,   1.81818187
  10551,  -18.5383358,   57.5053406,   1.81818187
  10552,  -18.7693672,   56.9073029,   1.81818187
  10553,  -18.9811153,    56.302166,   1.81818187
  10554,   -19.173357,   55.6905518,   1.81818187
  10555,  -19.3458977,   55.0730934,   1.81818187
  10556,   -19.498558,   54.4504204,   1.81818187
  10557,  -19.6311836,   53.8231735,   1.81818187
  10558,  -19.7436352,   53.1919975,   1.81818187
  10559,  -19.8358002,   52.5575447,   1.81818187
  10560,  -19.9075832,   51.9204597,   1.81818187
  10561,  -19.9589081,   51.2814026,   1.81818187
  10562,  -19.9897251,   50.6410332,   1.81818187
  10563,   19.9897251,   50.6410332,   2.72727275
  10564,   19.9589081,   51.2814026,   2.72727275
  10565,   19.9075832,   51.9204597,   2.72727275
  10566,   19.8358002,   52.5575447,   2.72727275
  10567,   19.7436352,   53.1919975,   2.72727275
  10568,   19.6311836,   53.8231735,   2.72727275
  10569,    19.498558,   54.4504204,   2.72727275
  10570,   19.3458977,   55.0730934,   2.72727275
  10571,    19.173357,   55.6905518,   2.72727275
  10572,   18.9811153,    56.302166,   2.72727275
  10573,   18.7693672,   56.9073029,   2.72727275
  10574,   18.5383358,   57.5053406,   2.72727275
  10575,   18.2882538,    58.095665,   2.72727275
  10576,   18.0193787,   58.6776733,   2.72727275
  10577,   17.7319851,   59.2507668,   2.72727275
  10578,   17.4263744,   59.8143501,   2.72727275
  10579,   17.1028557,   60.3678513,   2.72727275
  10580,   16.7617626,   60.9106979,   2.72727275
  10581,   16.4034443,   61.4423332,   2.72727275
  10582,   16.0282726,   61.9622116,   2.72727275
  10583,   15.6366301,   62.4697952,   2.72727275
  10584,   15.2289181,   62.9645691,   2.72727275
  10585,   14.8055601,   63.4460182,   2.72727275
  10586,   14.3669872,   63.9136505,   2.72727275
  10587,   13.9136505,   64.3669891,   2.72727275
  10588,   13.4460192,   64.8055573,   2.72727275
  10589,   12.9645672,     65.22892,   2.72727275
  10590,   12.4697971,   65.6366272,   2.72727275
  10591,   11.9622097,   66.0282745,   2.72727275
  10592,   11.4423342,   66.4034424,   2.72727275
  10593,    10.910697,   66.7617645,   2.72727275
  10594,   10.3678532,   67.1028519,   2.72727275
  10595,   9.81435013,   67.4263763,   2.72727275
  10596,    9.2507658,    67.731987,   2.72727275
  10597,   8.67767429,   68.0193787,   2.72727275
  10598,   8.09566593,   68.2882538,   2.72727275
  10599,   7.50533915,   68.5383377,   2.72727275
  10600,       6.9073,    68.769371,   2.72727275
  10601,   6.30216408,   68.9811172,   2.72727275
  10602,   5.69055223,   69.1733551,   2.72727275
  10603,   5.07309246,   69.3458939,   2.72727275
  10604,   4.45041847,    69.498558,   2.72727275
  10605,   3.82317328,   69.6311798,   2.72727275
  10606,   3.19199777,   69.7436371,   2.72727275
  10607,   2.55754328,   69.8358002,   2.72727275
  10608,   1.92046022,   69.9075851,   2.72727275
  10609,   1.28140438,   69.9589081,   2.72727275
  10610,  0.641031623,   69.9897232,   2.72727275
  10611,           0.,          70.,   2.72727275
  10612, -0.641031623,   69.9897232,   2.72727275
  10613,  -1.28140438,   69.9589081,   2.72727275
  10614,  -1.92046022,   69.9075851,   2.72727275
  10615,  -2.55754328,   69.8358002,   2.72727275
  10616,  -3.19199777,   69.7436371,   2.72727275
  10617,  -3.82317328,   69.6311798,   2.72727275
  10618,  -4.45041847,    69.498558,   2.72727275
  10619,  -5.07309246,   69.3458939,   2.72727275
  10620,  -5.69055223,   69.1733551,   2.72727275
  10621,  -6.30216408,   68.9811172,   2.72727275
  10622,      -6.9073,    68.769371,   2.72727275
  10623,  -7.50533915,   68.5383377,   2.72727275
  10624,  -8.09566593,   68.2882538,   2.72727275
  10625,  -8.67767429,   68.0193787,   2.72727275
  10626,   -9.2507658,    67.731987,   2.72727275
  10627,  -9.81435013,   67.4263763,   2.72727275
  10628,  -10.3678532,   67.1028519,   2.72727275
  10629,   -10.910697,   66.7617645,   2.72727275
  10630,  -11.4423342,   66.4034424,   2.72727275
  10631,  -11.9622097,   66.0282745,   2.72727275
  10632,  -12.4697971,   65.6366272,   2.72727275
  10633,  -12.9645672,     65.22892,   2.72727275
  10634,  -13.4460192,   64.8055573,   2.72727275
  10635,  -13.9136505,   64.3669891,   2.72727275
  10636,  -14.3669872,   63.9136505,   2.72727275
  10637,  -14.8055601,   63.4460182,   2.72727275
  10638,  -15.2289181,   62.9645691,   2.72727275
  10639,  -15.6366301,   62.4697952,   2.72727275
  10640,  -16.0282726,   61.9622116,   2.72727275
  10641,  -16.4034443,   61.4423332,   2.72727275
  10642,  -16.7617626,   60.9106979,   2.72727275
  10643,  -17.1028557,   60.3678513,   2.72727275
  10644,  -17.4263744,   59.8143501,   2.72727275
  10645,  -17.7319851,   59.2507668,   2.72727275
  10646,  -18.0193787,   58.6776733,   2.72727275
  10647,  -18.2882538,    58.095665,   2.72727275
  10648,  -18.5383358,   57.5053406,   2.72727275
  10649,  -18.7693672,   56.9073029,   2.72727275
  10650,  -18.9811153,    56.302166,   2.72727275
  10651,   -19.173357,   55.6905518,   2.72727275
  10652,  -19.3458977,   55.0730934,   2.72727275
  10653,   -19.498558,   54.4504204,   2.72727275
  10654,  -19.6311836,   53.8231735,   2.72727275
  10655,  -19.7436352,   53.1919975,   2.72727275
  10656,  -19.8358002,   52.5575447,   2.72727275
  10657,  -19.9075832,   51.9204597,   2.72727275
  10658,  -19.9589081,   51.2814026,   2.72727275
  10659,  -19.9897251,   50.6410332,   2.72727275
  10660,   19.9897251,   50.6410332,   3.63636374
  10661,   19.9589081,   51.2814026,   3.63636374
  10662,   19.9075832,   51.9204597,   3.63636374
  10663,   19.8358002,   52.5575447,   3.63636374
  10664,   19.7436352,   53.1919975,   3.63636374
  10665,   19.6311836,   53.8231735,   3.63636374
  10666,    19.498558,   54.4504204,   3.63636374
  10667,   19.3458977,   55.0730934,   3.63636374
  10668,    19.173357,   55.6905518,   3.63636374
  10669,   18.9811153,    56.302166,   3.63636374
  10670,   18.7693672,   56.9073029,   3.63636374
  10671,   18.5383358,   57.5053406,   3.63636374
  10672,   18.2882538,    58.095665,   3.63636374
  10673,   18.0193787,   58.6776733,   3.63636374
  10674,   17.7319851,   59.2507668,   3.63636374
  10675,   17.4263744,   59.8143501,   3.63636374
  10676,   17.1028557,   60.3678513,   3.63636374
  10677,   16.7617626,   60.9106979,   3.63636374
  10678,   16.4034443,   61.4423332,   3.63636374
  10679,   16.0282726,   61.9622116,   3.63636374
  10680,   15.6366301,   62.4697952,   3.63636374
  10681,   15.2289181,   62.9645691,   3.63636374
  10682,   14.8055601,   63.4460182,   3.63636374
  10683,   14.3669872,   63.9136505,   3.63636374
  10684,   13.9136505,   64.3669891,   3.63636374
  10685,   13.4460192,   64.8055573,   3.63636374
  10686,   12.9645672,     65.22892,   3.63636374
  10687,   12.4697971,   65.6366272,   3.63636374
  10688,   11.9622097,   66.0282745,   3.63636374
  10689,   11.4423342,   66.4034424,   3.63636374
  10690,    10.910697,   66.7617645,   3.63636374
  10691,   10.3678532,   67.1028519,   3.63636374
  10692,   9.81435013,   67.4263763,   3.63636374
  10693,    9.2507658,    67.731987,   3.63636374
  10694,   8.67767429,   68.0193787,   3.63636374
  10695,   8.09566593,   68.2882538,   3.63636374
  10696,   7.50533915,   68.5383377,   3.63636374
  10697,       6.9073,    68.769371,   3.63636374
  10698,   6.30216408,   68.9811172,   3.63636374
  10699,   5.69055223,   69.1733551,   3.63636374
  10700,   5.07309246,   69.3458939,   3.63636374
  10701,   4.45041847,    69.498558,   3.63636374
  10702,   3.82317328,   69.6311798,   3.63636374
  10703,   3.19199777,   69.7436371,   3.63636374
  10704,   2.55754328,   69.8358002,   3.63636374
  10705,   1.92046022,   69.9075851,   3.63636374
  10706,   1.28140438,   69.9589081,   3.63636374
  10707,  0.641031623,   69.9897232,   3.63636374
  10708,           0.,          70.,   3.63636374
  10709, -0.641031623,   69.9897232,   3.63636374
  10710,  -1.28140438,   69.9589081,   3.63636374
  10711,  -1.92046022,   69.9075851,   3.63636374
  10712,  -2.55754328,   69.8358002,   3.63636374
  10713,  -3.19199777,   69.7436371,   3.63636374
  10714,  -3.82317328,   69.6311798,   3.63636374
  10715,  -4.45041847,    69.498558,   3.63636374
  10716,  -5.07309246,   69.3458939,   3.63636374
  10717,  -5.69055223,   69.1733551,   3.63636374
  10718,  -6.30216408,   68.9811172,   3.63636374
  10719,      -6.9073,    68.769371,   3.63636374
  10720,  -7.50533915,   68.5383377,   3.63636374
  10721,  -8.09566593,   68.2882538,   3.63636374
  10722,  -8.67767429,   68.0193787,   3.63636374
  10723,   -9.2507658,    67.731987,   3.63636374
  10724,  -9.81435013,   67.4263763,   3.63636374
  10725,  -10.3678532,   67.1028519,   3.63636374
  10726,   -10.910697,   66.7617645,   3.63636374
  10727,  -11.4423342,   66.4034424,   3.63636374
  10728,  -11.9622097,   66.0282745,   3.63636374
  10729,  -12.4697971,   65.6366272,   3.63636374
  10730,  -12.9645672,     65.22892,   3.63636374
  10731,  -13.4460192,   64.8055573,   3.63636374
  10732,  -13.9136505,   64.3669891,   3.63636374
  10733,  -14.3669872,   63.9136505,   3.63636374
  10734,  -14.8055601,   63.4460182,   3.63636374
  10735,  -15.2289181,   62.9645691,   3.63636374
  10736,  -15.6366301,   62.4697952,   3.63636374
  10737,  -16.0282726,   61.9622116,   3.63636374
  10738,  -16.4034443,   61.4423332,   3.63636374
  10739,  -16.7617626,   60.9106979,   3.63636374
  10740,  -17.1028557,   60.3678513,   3.63636374
  10741,  -17.4263744,   59.8143501,   3.63636374
  10742,  -17.7319851,   59.2507668,   3.63636374
  10743,  -18.0193787,   58.6776733,   3.63636374
  10744,  -18.2882538,    58.095665,   3.63636374
  10745,  -18.5383358,   57.5053406,   3.63636374
  10746,  -18.7693672,   56.9073029,   3.63636374
  10747,  -18.9811153,    56.302166,   3.63636374
  10748,   -19.173357,   55.6905518,   3.63636374
  10749,  -19.3458977,   55.0730934,   3.63636374
  10750,   -19.498558,   54.4504204,   3.63636374
  10751,  -19.6311836,   53.8231735,   3.63636374
  10752,  -19.7436352,   53.1919975,   3.63636374
  10753,  -19.8358002,   52.5575447,   3.63636374
  10754,  -19.9075832,   51.9204597,   3.63636374
  10755,  -19.9589081,   51.2814026,   3.63636374
  10756,  -19.9897251,   50.6410332,   3.63636374
  10757,   19.9897251,   50.6410332,    4.5454545
  10758,   19.9589081,   51.2814026,    4.5454545
  10759,   19.9075832,   51.9204597,    4.5454545
  10760,   19.8358002,   52.5575447,    4.5454545
  10761,   19.7436352,   53.1919975,    4.5454545
  10762,   19.6311836,   53.8231735,    4.5454545
  10763,    19.498558,   54.4504204,    4.5454545
  10764,   19.3458977,   55.0730934,    4.5454545
  10765,    19.173357,   55.6905518,    4.5454545
  10766,   18.9811153,    56.302166,    4.5454545
  10767,   18.7693672,   56.9073029,    4.5454545
  10768,   18.5383358,   57.5053406,    4.5454545
  10769,   18.2882538,    58.095665,    4.5454545
  10770,   18.0193787,   58.6776733,    4.5454545
  10771,   17.7319851,   59.2507668,    4.5454545
  10772,   17.4263744,   59.8143501,    4.5454545
  10773,   17.1028557,   60.3678513,    4.5454545
  10774,   16.7617626,   60.9106979,    4.5454545
  10775,   16.4034443,   61.4423332,    4.5454545
  10776,   16.0282726,   61.9622116,    4.5454545
  10777,   15.6366301,   62.4697952,    4.5454545
  10778,   15.2289181,   62.9645691,    4.5454545
  10779,   14.8055601,   63.4460182,    4.5454545
  10780,   14.3669872,   63.9136505,    4.5454545
  10781,   13.9136505,   64.3669891,    4.5454545
  10782,   13.4460192,   64.8055573,    4.5454545
  10783,   12.9645672,     65.22892,    4.5454545
  10784,   12.4697971,   65.6366272,    4.5454545
  10785,   11.9622097,   66.0282745,    4.5454545
  10786,   11.4423342,   66.4034424,    4.5454545
  10787,    10.910697,   66.7617645,    4.5454545
  10788,   10.3678532,   67.1028519,    4.5454545
  10789,   9.81435013,   67.4263763,    4.5454545
  10790,    9.2507658,    67.731987,    4.5454545
  10791,   8.67767429,   68.0193787,    4.5454545
  10792,   8.09566593,   68.2882538,    4.5454545
  10793,   7.50533915,   68.5383377,    4.5454545
  10794,       6.9073,    68.769371,    4.5454545
  10795,   6.30216408,   68.9811172,    4.5454545
  10796,   5.69055223,   69.1733551,    4.5454545
  10797,   5.07309246,   69.3458939,    4.5454545
  10798,   4.45041847,    69.498558,    4.5454545
  10799,   3.82317328,   69.6311798,    4.5454545
  10800,   3.19199777,   69.7436371,    4.5454545
  10801,   2.55754328,   69.8358002,    4.5454545
  10802,   1.92046022,   69.9075851,    4.5454545
  10803,   1.28140438,   69.9589081,    4.5454545
  10804,  0.641031623,   69.9897232,    4.5454545
  10805,           0.,          70.,    4.5454545
  10806, -0.641031623,   69.9897232,    4.5454545
  10807,  -1.28140438,   69.9589081,    4.5454545
  10808,  -1.92046022,   69.9075851,    4.5454545
  10809,  -2.55754328,   69.8358002,    4.5454545
  10810,  -3.19199777,   69.7436371,    4.5454545
  10811,  -3.82317328,   69.6311798,    4.5454545
  10812,  -4.45041847,    69.498558,    4.5454545
  10813,  -5.07309246,   69.3458939,    4.5454545
  10814,  -5.69055223,   69.1733551,    4.5454545
  10815,  -6.30216408,   68.9811172,    4.5454545
  10816,      -6.9073,    68.769371,    4.5454545
  10817,  -7.50533915,   68.5383377,    4.5454545
  10818,  -8.09566593,   68.2882538,    4.5454545
  10819,  -8.67767429,   68.0193787,    4.5454545
  10820,   -9.2507658,    67.731987,    4.5454545
  10821,  -9.81435013,   67.4263763,    4.5454545
  10822,  -10.3678532,   67.1028519,    4.5454545
  10823,   -10.910697,   66.7617645,    4.5454545
  10824,  -11.4423342,   66.4034424,    4.5454545
  10825,  -11.9622097,   66.0282745,    4.5454545
  10826,  -12.4697971,   65.6366272,    4.5454545
  10827,  -12.9645672,     65.22892,    4.5454545
  10828,  -13.4460192,   64.8055573,    4.5454545
  10829,  -13.9136505,   64.3669891,    4.5454545
  10830,  -14.3669872,   63.9136505,    4.5454545
  10831,  -14.8055601,   63.4460182,    4.5454545
  10832,  -15.2289181,   62.9645691,    4.5454545
  10833,  -15.6366301,   62.4697952,    4.5454545
  10834,  -16.0282726,   61.9622116,    4.5454545
  10835,  -16.4034443,   61.4423332,    4.5454545
  10836,  -16.7617626,   60.9106979,    4.5454545
  10837,  -17.1028557,   60.3678513,    4.5454545
  10838,  -17.4263744,   59.8143501,    4.5454545
  10839,  -17.7319851,   59.2507668,    4.5454545
  10840,  -18.0193787,   58.6776733,    4.5454545
  10841,  -18.2882538,    58.095665,    4.5454545
  10842,  -18.5383358,   57.5053406,    4.5454545
  10843,  -18.7693672,   56.9073029,    4.5454545
  10844,  -18.9811153,    56.302166,    4.5454545
  10845,   -19.173357,   55.6905518,    4.5454545
  10846,  -19.3458977,   55.0730934,    4.5454545
  10847,   -19.498558,   54.4504204,    4.5454545
  10848,  -19.6311836,   53.8231735,    4.5454545
  10849,  -19.7436352,   53.1919975,    4.5454545
  10850,  -19.8358002,   52.5575447,    4.5454545
  10851,  -19.9075832,   51.9204597,    4.5454545
  10852,  -19.9589081,   51.2814026,    4.5454545
  10853,  -19.9897251,   50.6410332,    4.5454545
  10854,   19.9897251,   50.6410332,    5.4545455
  10855,   19.9589081,   51.2814026,    5.4545455
  10856,   19.9075832,   51.9204597,    5.4545455
  10857,   19.8358002,   52.5575447,    5.4545455
  10858,   19.7436352,   53.1919975,    5.4545455
  10859,   19.6311836,   53.8231735,    5.4545455
  10860,    19.498558,   54.4504204,    5.4545455
  10861,   19.3458977,   55.0730934,    5.4545455
  10862,    19.173357,   55.6905518,    5.4545455
  10863,   18.9811153,    56.302166,    5.4545455
  10864,   18.7693672,   56.9073029,    5.4545455
  10865,   18.5383358,   57.5053406,    5.4545455
  10866,   18.2882538,    58.095665,    5.4545455
  10867,   18.0193787,   58.6776733,    5.4545455
  10868,   17.7319851,   59.2507668,    5.4545455
  10869,   17.4263744,   59.8143501,    5.4545455
  10870,   17.1028557,   60.3678513,    5.4545455
  10871,   16.7617626,   60.9106979,    5.4545455
  10872,   16.4034443,   61.4423332,    5.4545455
  10873,   16.0282726,   61.9622116,    5.4545455
  10874,   15.6366301,   62.4697952,    5.4545455
  10875,   15.2289181,   62.9645691,    5.4545455
  10876,   14.8055601,   63.4460182,    5.4545455
  10877,   14.3669872,   63.9136505,    5.4545455
  10878,   13.9136505,   64.3669891,    5.4545455
  10879,   13.4460192,   64.8055573,    5.4545455
  10880,   12.9645672,     65.22892,    5.4545455
  10881,   12.4697971,   65.6366272,    5.4545455
  10882,   11.9622097,   66.0282745,    5.4545455
  10883,   11.4423342,   66.4034424,    5.4545455
  10884,    10.910697,   66.7617645,    5.4545455
  10885,   10.3678532,   67.1028519,    5.4545455
  10886,   9.81435013,   67.4263763,    5.4545455
  10887,    9.2507658,    67.731987,    5.4545455
  10888,   8.67767429,   68.0193787,    5.4545455
  10889,   8.09566593,   68.2882538,    5.4545455
  10890,   7.50533915,   68.5383377,    5.4545455
  10891,       6.9073,    68.769371,    5.4545455
  10892,   6.30216408,   68.9811172,    5.4545455
  10893,   5.69055223,   69.1733551,    5.4545455
  10894,   5.07309246,   69.3458939,    5.4545455
  10895,   4.45041847,    69.498558,    5.4545455
  10896,   3.82317328,   69.6311798,    5.4545455
  10897,   3.19199777,   69.7436371,    5.4545455
  10898,   2.55754328,   69.8358002,    5.4545455
  10899,   1.92046022,   69.9075851,    5.4545455
  10900,   1.28140438,   69.9589081,    5.4545455
  10901,  0.641031623,   69.9897232,    5.4545455
  10902,           0.,          70.,    5.4545455
  10903, -0.641031623,   69.9897232,    5.4545455
  10904,  -1.28140438,   69.9589081,    5.4545455
  10905,  -1.92046022,   69.9075851,    5.4545455
  10906,  -2.55754328,   69.8358002,    5.4545455
  10907,  -3.19199777,   69.7436371,    5.4545455
  10908,  -3.82317328,   69.6311798,    5.4545455
  10909,  -4.45041847,    69.498558,    5.4545455
  10910,  -5.07309246,   69.3458939,    5.4545455
  10911,  -5.69055223,   69.1733551,    5.4545455
  10912,  -6.30216408,   68.9811172,    5.4545455
  10913,      -6.9073,    68.769371,    5.4545455
  10914,  -7.50533915,   68.5383377,    5.4545455
  10915,  -8.09566593,   68.2882538,    5.4545455
  10916,  -8.67767429,   68.0193787,    5.4545455
  10917,   -9.2507658,    67.731987,    5.4545455
  10918,  -9.81435013,   67.4263763,    5.4545455
  10919,  -10.3678532,   67.1028519,    5.4545455
  10920,   -10.910697,   66.7617645,    5.4545455
  10921,  -11.4423342,   66.4034424,    5.4545455
  10922,  -11.9622097,   66.0282745,    5.4545455
  10923,  -12.4697971,   65.6366272,    5.4545455
  10924,  -12.9645672,     65.22892,    5.4545455
  10925,  -13.4460192,   64.8055573,    5.4545455
  10926,  -13.9136505,   64.3669891,    5.4545455
  10927,  -14.3669872,   63.9136505,    5.4545455
  10928,  -14.8055601,   63.4460182,    5.4545455
  10929,  -15.2289181,   62.9645691,    5.4545455
  10930,  -15.6366301,   62.4697952,    5.4545455
  10931,  -16.0282726,   61.9622116,    5.4545455
  10932,  -16.4034443,   61.4423332,    5.4545455
  10933,  -16.7617626,   60.9106979,    5.4545455
  10934,  -17.1028557,   60.3678513,    5.4545455
  10935,  -17.4263744,   59.8143501,    5.4545455
  10936,  -17.7319851,   59.2507668,    5.4545455
  10937,  -18.0193787,   58.6776733,    5.4545455
  10938,  -18.2882538,    58.095665,    5.4545455
  10939,  -18.5383358,   57.5053406,    5.4545455
  10940,  -18.7693672,   56.9073029,    5.4545455
  10941,  -18.9811153,    56.302166,    5.4545455
  10942,   -19.173357,   55.6905518,    5.4545455
  10943,  -19.3458977,   55.0730934,    5.4545455
  10944,   -19.498558,   54.4504204,    5.4545455
  10945,  -19.6311836,   53.8231735,    5.4545455
  10946,  -19.7436352,   53.1919975,    5.4545455
  10947,  -19.8358002,   52.5575447,    5.4545455
  10948,  -19.9075832,   51.9204597,    5.4545455
  10949,  -19.9589081,   51.2814026,    5.4545455
  10950,  -19.9897251,   50.6410332,    5.4545455
  10951,   19.9897251,   50.6410332,   6.36363649
  10952,   19.9589081,   51.2814026,   6.36363649
  10953,   19.9075832,   51.9204597,   6.36363649
  10954,   19.8358002,   52.5575447,   6.36363649
  10955,   19.7436352,   53.1919975,   6.36363649
  10956,   19.6311836,   53.8231735,   6.36363649
  10957,    19.498558,   54.4504204,   6.36363649
  10958,   19.3458977,   55.0730934,   6.36363649
  10959,    19.173357,   55.6905518,   6.36363649
  10960,   18.9811153,    56.302166,   6.36363649
  10961,   18.7693672,   56.9073029,   6.36363649
  10962,   18.5383358,   57.5053406,   6.36363649
  10963,   18.2882538,    58.095665,   6.36363649
  10964,   18.0193787,   58.6776733,   6.36363649
  10965,   17.7319851,   59.2507668,   6.36363649
  10966,   17.4263744,   59.8143501,   6.36363649
  10967,   17.1028557,   60.3678513,   6.36363649
  10968,   16.7617626,   60.9106979,   6.36363649
  10969,   16.4034443,   61.4423332,   6.36363649
  10970,   16.0282726,   61.9622116,   6.36363649
  10971,   15.6366301,   62.4697952,   6.36363649
  10972,   15.2289181,   62.9645691,   6.36363649
  10973,   14.8055601,   63.4460182,   6.36363649
  10974,   14.3669872,   63.9136505,   6.36363649
  10975,   13.9136505,   64.3669891,   6.36363649
  10976,   13.4460192,   64.8055573,   6.36363649
  10977,   12.9645672,     65.22892,   6.36363649
  10978,   12.4697971,   65.6366272,   6.36363649
  10979,   11.9622097,   66.0282745,   6.36363649
  10980,   11.4423342,   66.4034424,   6.36363649
  10981,    10.910697,   66.7617645,   6.36363649
  10982,   10.3678532,   67.1028519,   6.36363649
  10983,   9.81435013,   67.4263763,   6.36363649
  10984,    9.2507658,    67.731987,   6.36363649
  10985,   8.67767429,   68.0193787,   6.36363649
  10986,   8.09566593,   68.2882538,   6.36363649
  10987,   7.50533915,   68.5383377,   6.36363649
  10988,       6.9073,    68.769371,   6.36363649
  10989,   6.30216408,   68.9811172,   6.36363649
  10990,   5.69055223,   69.1733551,   6.36363649
  10991,   5.07309246,   69.3458939,   6.36363649
  10992,   4.45041847,    69.498558,   6.36363649
  10993,   3.82317328,   69.6311798,   6.36363649
  10994,   3.19199777,   69.7436371,   6.36363649
  10995,   2.55754328,   69.8358002,   6.36363649
  10996,   1.92046022,   69.9075851,   6.36363649
  10997,   1.28140438,   69.9589081,   6.36363649
  10998,  0.641031623,   69.9897232,   6.36363649
  10999,           0.,          70.,   6.36363649
  11000, -0.641031623,   69.9897232,   6.36363649
  11001,  -1.28140438,   69.9589081,   6.36363649
  11002,  -1.92046022,   69.9075851,   6.36363649
  11003,  -2.55754328,   69.8358002,   6.36363649
  11004,  -3.19199777,   69.7436371,   6.36363649
  11005,  -3.82317328,   69.6311798,   6.36363649
  11006,  -4.45041847,    69.498558,   6.36363649
  11007,  -5.07309246,   69.3458939,   6.36363649
  11008,  -5.69055223,   69.1733551,   6.36363649
  11009,  -6.30216408,   68.9811172,   6.36363649
  11010,      -6.9073,    68.769371,   6.36363649
  11011,  -7.50533915,   68.5383377,   6.36363649
  11012,  -8.09566593,   68.2882538,   6.36363649
  11013,  -8.67767429,   68.0193787,   6.36363649
  11014,   -9.2507658,    67.731987,   6.36363649
  11015,  -9.81435013,   67.4263763,   6.36363649
  11016,  -10.3678532,   67.1028519,   6.36363649
  11017,   -10.910697,   66.7617645,   6.36363649
  11018,  -11.4423342,   66.4034424,   6.36363649
  11019,  -11.9622097,   66.0282745,   6.36363649
  11020,  -12.4697971,   65.6366272,   6.36363649
  11021,  -12.9645672,     65.22892,   6.36363649
  11022,  -13.4460192,   64.8055573,   6.36363649
  11023,  -13.9136505,   64.3669891,   6.36363649
  11024,  -14.3669872,   63.9136505,   6.36363649
  11025,  -14.8055601,   63.4460182,   6.36363649
  11026,  -15.2289181,   62.9645691,   6.36363649
  11027,  -15.6366301,   62.4697952,   6.36363649
  11028,  -16.0282726,   61.9622116,   6.36363649
  11029,  -16.4034443,   61.4423332,   6.36363649
  11030,  -16.7617626,   60.9106979,   6.36363649
  11031,  -17.1028557,   60.3678513,   6.36363649
  11032,  -17.4263744,   59.8143501,   6.36363649
  11033,  -17.7319851,   59.2507668,   6.36363649
  11034,  -18.0193787,   58.6776733,   6.36363649
  11035,  -18.2882538,    58.095665,   6.36363649
  11036,  -18.5383358,   57.5053406,   6.36363649
  11037,  -18.7693672,   56.9073029,   6.36363649
  11038,  -18.9811153,    56.302166,   6.36363649
  11039,   -19.173357,   55.6905518,   6.36363649
  11040,  -19.3458977,   55.0730934,   6.36363649
  11041,   -19.498558,   54.4504204,   6.36363649
  11042,  -19.6311836,   53.8231735,   6.36363649
  11043,  -19.7436352,   53.1919975,   6.36363649
  11044,  -19.8358002,   52.5575447,   6.36363649
  11045,  -19.9075832,   51.9204597,   6.36363649
  11046,  -19.9589081,   51.2814026,   6.36363649
  11047,  -19.9897251,   50.6410332,   6.36363649
  11048,   19.9897251,   50.6410332,   7.27272749
  11049,   19.9589081,   51.2814026,   7.27272749
  11050,   19.9075832,   51.9204597,   7.27272749
  11051,   19.8358002,   52.5575447,   7.27272749
  11052,   19.7436352,   53.1919975,   7.27272749
  11053,   19.6311836,   53.8231735,   7.27272749
  11054,    19.498558,   54.4504204,   7.27272749
  11055,   19.3458977,   55.0730934,   7.27272749
  11056,    19.173357,   55.6905518,   7.27272749
  11057,   18.9811153,    56.302166,   7.27272749
  11058,   18.7693672,   56.9073029,   7.27272749
  11059,   18.5383358,   57.5053406,   7.27272749
  11060,   18.2882538,    58.095665,   7.27272749
  11061,   18.0193787,   58.6776733,   7.27272749
  11062,   17.7319851,   59.2507668,   7.27272749
  11063,   17.4263744,   59.8143501,   7.27272749
  11064,   17.1028557,   60.3678513,   7.27272749
  11065,   16.7617626,   60.9106979,   7.27272749
  11066,   16.4034443,   61.4423332,   7.27272749
  11067,   16.0282726,   61.9622116,   7.27272749
  11068,   15.6366301,   62.4697952,   7.27272749
  11069,   15.2289181,   62.9645691,   7.27272749
  11070,   14.8055601,   63.4460182,   7.27272749
  11071,   14.3669872,   63.9136505,   7.27272749
  11072,   13.9136505,   64.3669891,   7.27272749
  11073,   13.4460192,   64.8055573,   7.27272749
  11074,   12.9645672,     65.22892,   7.27272749
  11075,   12.4697971,   65.6366272,   7.27272749
  11076,   11.9622097,   66.0282745,   7.27272749
  11077,   11.4423342,   66.4034424,   7.27272749
  11078,    10.910697,   66.7617645,   7.27272749
  11079,   10.3678532,   67.1028519,   7.27272749
  11080,   9.81435013,   67.4263763,   7.27272749
  11081,    9.2507658,    67.731987,   7.27272749
  11082,   8.67767429,   68.0193787,   7.27272749
  11083,   8.09566593,   68.2882538,   7.27272749
  11084,   7.50533915,   68.5383377,   7.27272749
  11085,       6.9073,    68.769371,   7.27272749
  11086,   6.30216408,   68.9811172,   7.27272749
  11087,   5.69055223,   69.1733551,   7.27272749
  11088,   5.07309246,   69.3458939,   7.27272749
  11089,   4.45041847,    69.498558,   7.27272749
  11090,   3.82317328,   69.6311798,   7.27272749
  11091,   3.19199777,   69.7436371,   7.27272749
  11092,   2.55754328,   69.8358002,   7.27272749
  11093,   1.92046022,   69.9075851,   7.27272749
  11094,   1.28140438,   69.9589081,   7.27272749
  11095,  0.641031623,   69.9897232,   7.27272749
  11096,           0.,          70.,   7.27272749
  11097, -0.641031623,   69.9897232,   7.27272749
  11098,  -1.28140438,   69.9589081,   7.27272749
  11099,  -1.92046022,   69.9075851,   7.27272749
  11100,  -2.55754328,   69.8358002,   7.27272749
  11101,  -3.19199777,   69.7436371,   7.27272749
  11102,  -3.82317328,   69.6311798,   7.27272749
  11103,  -4.45041847,    69.498558,   7.27272749
  11104,  -5.07309246,   69.3458939,   7.27272749
  11105,  -5.69055223,   69.1733551,   7.27272749
  11106,  -6.30216408,   68.9811172,   7.27272749
  11107,      -6.9073,    68.769371,   7.27272749
  11108,  -7.50533915,   68.5383377,   7.27272749
  11109,  -8.09566593,   68.2882538,   7.27272749
  11110,  -8.67767429,   68.0193787,   7.27272749
  11111,   -9.2507658,    67.731987,   7.27272749
  11112,  -9.81435013,   67.4263763,   7.27272749
  11113,  -10.3678532,   67.1028519,   7.27272749
  11114,   -10.910697,   66.7617645,   7.27272749
  11115,  -11.4423342,   66.4034424,   7.27272749
  11116,  -11.9622097,   66.0282745,   7.27272749
  11117,  -12.4697971,   65.6366272,   7.27272749
  11118,  -12.9645672,     65.22892,   7.27272749
  11119,  -13.4460192,   64.8055573,   7.27272749
  11120,  -13.9136505,   64.3669891,   7.27272749
  11121,  -14.3669872,   63.9136505,   7.27272749
  11122,  -14.8055601,   63.4460182,   7.27272749
  11123,  -15.2289181,   62.9645691,   7.27272749
  11124,  -15.6366301,   62.4697952,   7.27272749
  11125,  -16.0282726,   61.9622116,   7.27272749
  11126,  -16.4034443,   61.4423332,   7.27272749
  11127,  -16.7617626,   60.9106979,   7.27272749
  11128,  -17.1028557,   60.3678513,   7.27272749
  11129,  -17.4263744,   59.8143501,   7.27272749
  11130,  -17.7319851,   59.2507668,   7.27272749
  11131,  -18.0193787,   58.6776733,   7.27272749
  11132,  -18.2882538,    58.095665,   7.27272749
  11133,  -18.5383358,   57.5053406,   7.27272749
  11134,  -18.7693672,   56.9073029,   7.27272749
  11135,  -18.9811153,    56.302166,   7.27272749
  11136,   -19.173357,   55.6905518,   7.27272749
  11137,  -19.3458977,   55.0730934,   7.27272749
  11138,   -19.498558,   54.4504204,   7.27272749
  11139,  -19.6311836,   53.8231735,   7.27272749
  11140,  -19.7436352,   53.1919975,   7.27272749
  11141,  -19.8358002,   52.5575447,   7.27272749
  11142,  -19.9075832,   51.9204597,   7.27272749
  11143,  -19.9589081,   51.2814026,   7.27272749
  11144,  -19.9897251,   50.6410332,   7.27272749
  11145,   19.9897251,   50.6410332,   8.18181801
  11146,   19.9589081,   51.2814026,   8.18181801
  11147,   19.9075832,   51.9204597,   8.18181801
  11148,   19.8358002,   52.5575447,   8.18181801
  11149,   19.7436352,   53.1919975,   8.18181801
  11150,   19.6311836,   53.8231735,   8.18181801
  11151,    19.498558,   54.4504204,   8.18181801
  11152,   19.3458977,   55.0730934,   8.18181801
  11153,    19.173357,   55.6905518,   8.18181801
  11154,   18.9811153,    56.302166,   8.18181801
  11155,   18.7693672,   56.9073029,   8.18181801
  11156,   18.5383358,   57.5053406,   8.18181801
  11157,   18.2882538,    58.095665,   8.18181801
  11158,   18.0193787,   58.6776733,   8.18181801
  11159,   17.7319851,   59.2507668,   8.18181801
  11160,   17.4263744,   59.8143501,   8.18181801
  11161,   17.1028557,   60.3678513,   8.18181801
  11162,   16.7617626,   60.9106979,   8.18181801
  11163,   16.4034443,   61.4423332,   8.18181801
  11164,   16.0282726,   61.9622116,   8.18181801
  11165,   15.6366301,   62.4697952,   8.18181801
  11166,   15.2289181,   62.9645691,   8.18181801
  11167,   14.8055601,   63.4460182,   8.18181801
  11168,   14.3669872,   63.9136505,   8.18181801
  11169,   13.9136505,   64.3669891,   8.18181801
  11170,   13.4460192,   64.8055573,   8.18181801
  11171,   12.9645672,     65.22892,   8.18181801
  11172,   12.4697971,   65.6366272,   8.18181801
  11173,   11.9622097,   66.0282745,   8.18181801
  11174,   11.4423342,   66.4034424,   8.18181801
  11175,    10.910697,   66.7617645,   8.18181801
  11176,   10.3678532,   67.1028519,   8.18181801
  11177,   9.81435013,   67.4263763,   8.18181801
  11178,    9.2507658,    67.731987,   8.18181801
  11179,   8.67767429,   68.0193787,   8.18181801
  11180,   8.09566593,   68.2882538,   8.18181801
  11181,   7.50533915,   68.5383377,   8.18181801
  11182,       6.9073,    68.769371,   8.18181801
  11183,   6.30216408,   68.9811172,   8.18181801
  11184,   5.69055223,   69.1733551,   8.18181801
  11185,   5.07309246,   69.3458939,   8.18181801
  11186,   4.45041847,    69.498558,   8.18181801
  11187,   3.82317328,   69.6311798,   8.18181801
  11188,   3.19199777,   69.7436371,   8.18181801
  11189,   2.55754328,   69.8358002,   8.18181801
  11190,   1.92046022,   69.9075851,   8.18181801
  11191,   1.28140438,   69.9589081,   8.18181801
  11192,  0.641031623,   69.9897232,   8.18181801
  11193,           0.,          70.,   8.18181801
  11194, -0.641031623,   69.9897232,   8.18181801
  11195,  -1.28140438,   69.9589081,   8.18181801
  11196,  -1.92046022,   69.9075851,   8.18181801
  11197,  -2.55754328,   69.8358002,   8.18181801
  11198,  -3.19199777,   69.7436371,   8.18181801
  11199,  -3.82317328,   69.6311798,   8.18181801
  11200,  -4.45041847,    69.498558,   8.18181801
  11201,  -5.07309246,   69.3458939,   8.18181801
  11202,  -5.69055223,   69.1733551,   8.18181801
  11203,  -6.30216408,   68.9811172,   8.18181801
  11204,      -6.9073,    68.769371,   8.18181801
  11205,  -7.50533915,   68.5383377,   8.18181801
  11206,  -8.09566593,   68.2882538,   8.18181801
  11207,  -8.67767429,   68.0193787,   8.18181801
  11208,   -9.2507658,    67.731987,   8.18181801
  11209,  -9.81435013,   67.4263763,   8.18181801
  11210,  -10.3678532,   67.1028519,   8.18181801
  11211,   -10.910697,   66.7617645,   8.18181801
  11212,  -11.4423342,   66.4034424,   8.18181801
  11213,  -11.9622097,   66.0282745,   8.18181801
  11214,  -12.4697971,   65.6366272,   8.18181801
  11215,  -12.9645672,     65.22892,   8.18181801
  11216,  -13.4460192,   64.8055573,   8.18181801
  11217,  -13.9136505,   64.3669891,   8.18181801
  11218,  -14.3669872,   63.9136505,   8.18181801
  11219,  -14.8055601,   63.4460182,   8.18181801
  11220,  -15.2289181,   62.9645691,   8.18181801
  11221,  -15.6366301,   62.4697952,   8.18181801
  11222,  -16.0282726,   61.9622116,   8.18181801
  11223,  -16.4034443,   61.4423332,   8.18181801
  11224,  -16.7617626,   60.9106979,   8.18181801
  11225,  -17.1028557,   60.3678513,   8.18181801
  11226,  -17.4263744,   59.8143501,   8.18181801
  11227,  -17.7319851,   59.2507668,   8.18181801
  11228,  -18.0193787,   58.6776733,   8.18181801
  11229,  -18.2882538,    58.095665,   8.18181801
  11230,  -18.5383358,   57.5053406,   8.18181801
  11231,  -18.7693672,   56.9073029,   8.18181801
  11232,  -18.9811153,    56.302166,   8.18181801
  11233,   -19.173357,   55.6905518,   8.18181801
  11234,  -19.3458977,   55.0730934,   8.18181801
  11235,   -19.498558,   54.4504204,   8.18181801
  11236,  -19.6311836,   53.8231735,   8.18181801
  11237,  -19.7436352,   53.1919975,   8.18181801
  11238,  -19.8358002,   52.5575447,   8.18181801
  11239,  -19.9075832,   51.9204597,   8.18181801
  11240,  -19.9589081,   51.2814026,   8.18181801
  11241,  -19.9897251,   50.6410332,   8.18181801
  11242,   19.9897251,   50.6410332,     9.090909
  11243,   19.9589081,   51.2814026,     9.090909
  11244,   19.9075832,   51.9204597,     9.090909
  11245,   19.8358002,   52.5575447,     9.090909
  11246,   19.7436352,   53.1919975,     9.090909
  11247,   19.6311836,   53.8231735,     9.090909
  11248,    19.498558,   54.4504204,     9.090909
  11249,   19.3458977,   55.0730934,     9.090909
  11250,    19.173357,   55.6905518,     9.090909
  11251,   18.9811153,    56.302166,     9.090909
  11252,   18.7693672,   56.9073029,     9.090909
  11253,   18.5383358,   57.5053406,     9.090909
  11254,   18.2882538,    58.095665,     9.090909
  11255,   18.0193787,   58.6776733,     9.090909
  11256,   17.7319851,   59.2507668,     9.090909
  11257,   17.4263744,   59.8143501,     9.090909
  11258,   17.1028557,   60.3678513,     9.090909
  11259,   16.7617626,   60.9106979,     9.090909
  11260,   16.4034443,   61.4423332,     9.090909
  11261,   16.0282726,   61.9622116,     9.090909
  11262,   15.6366301,   62.4697952,     9.090909
  11263,   15.2289181,   62.9645691,     9.090909
  11264,   14.8055601,   63.4460182,     9.090909
  11265,   14.3669872,   63.9136505,     9.090909
  11266,   13.9136505,   64.3669891,     9.090909
  11267,   13.4460192,   64.8055573,     9.090909
  11268,   12.9645672,     65.22892,     9.090909
  11269,   12.4697971,   65.6366272,     9.090909
  11270,   11.9622097,   66.0282745,     9.090909
  11271,   11.4423342,   66.4034424,     9.090909
  11272,    10.910697,   66.7617645,     9.090909
  11273,   10.3678532,   67.1028519,     9.090909
  11274,   9.81435013,   67.4263763,     9.090909
  11275,    9.2507658,    67.731987,     9.090909
  11276,   8.67767429,   68.0193787,     9.090909
  11277,   8.09566593,   68.2882538,     9.090909
  11278,   7.50533915,   68.5383377,     9.090909
  11279,       6.9073,    68.769371,     9.090909
  11280,   6.30216408,   68.9811172,     9.090909
  11281,   5.69055223,   69.1733551,     9.090909
  11282,   5.07309246,   69.3458939,     9.090909
  11283,   4.45041847,    69.498558,     9.090909
  11284,   3.82317328,   69.6311798,     9.090909
  11285,   3.19199777,   69.7436371,     9.090909
  11286,   2.55754328,   69.8358002,     9.090909
  11287,   1.92046022,   69.9075851,     9.090909
  11288,   1.28140438,   69.9589081,     9.090909
  11289,  0.641031623,   69.9897232,     9.090909
  11290,           0.,          70.,     9.090909
  11291, -0.641031623,   69.9897232,     9.090909
  11292,  -1.28140438,   69.9589081,     9.090909
  11293,  -1.92046022,   69.9075851,     9.090909
  11294,  -2.55754328,   69.8358002,     9.090909
  11295,  -3.19199777,   69.7436371,     9.090909
  11296,  -3.82317328,   69.6311798,     9.090909
  11297,  -4.45041847,    69.498558,     9.090909
  11298,  -5.07309246,   69.3458939,     9.090909
  11299,  -5.69055223,   69.1733551,     9.090909
  11300,  -6.30216408,   68.9811172,     9.090909
  11301,      -6.9073,    68.769371,     9.090909
  11302,  -7.50533915,   68.5383377,     9.090909
  11303,  -8.09566593,   68.2882538,     9.090909
  11304,  -8.67767429,   68.0193787,     9.090909
  11305,   -9.2507658,    67.731987,     9.090909
  11306,  -9.81435013,   67.4263763,     9.090909
  11307,  -10.3678532,   67.1028519,     9.090909
  11308,   -10.910697,   66.7617645,     9.090909
  11309,  -11.4423342,   66.4034424,     9.090909
  11310,  -11.9622097,   66.0282745,     9.090909
  11311,  -12.4697971,   65.6366272,     9.090909
  11312,  -12.9645672,     65.22892,     9.090909
  11313,  -13.4460192,   64.8055573,     9.090909
  11314,  -13.9136505,   64.3669891,     9.090909
  11315,  -14.3669872,   63.9136505,     9.090909
  11316,  -14.8055601,   63.4460182,     9.090909
  11317,  -15.2289181,   62.9645691,     9.090909
  11318,  -15.6366301,   62.4697952,     9.090909
  11319,  -16.0282726,   61.9622116,     9.090909
  11320,  -16.4034443,   61.4423332,     9.090909
  11321,  -16.7617626,   60.9106979,     9.090909
  11322,  -17.1028557,   60.3678513,     9.090909
  11323,  -17.4263744,   59.8143501,     9.090909
  11324,  -17.7319851,   59.2507668,     9.090909
  11325,  -18.0193787,   58.6776733,     9.090909
  11326,  -18.2882538,    58.095665,     9.090909
  11327,  -18.5383358,   57.5053406,     9.090909
  11328,  -18.7693672,   56.9073029,     9.090909
  11329,  -18.9811153,    56.302166,     9.090909
  11330,   -19.173357,   55.6905518,     9.090909
  11331,  -19.3458977,   55.0730934,     9.090909
  11332,   -19.498558,   54.4504204,     9.090909
  11333,  -19.6311836,   53.8231735,     9.090909
  11334,  -19.7436352,   53.1919975,     9.090909
  11335,  -19.8358002,   52.5575447,     9.090909
  11336,  -19.9075832,   51.9204597,     9.090909
  11337,  -19.9589081,   51.2814026,     9.090909
  11338,  -19.9897251,   50.6410332,     9.090909
  11339,     29.09091,          50.,  0.909090936
  11340,     29.09091,          50.,   1.81818187
  11341,     29.09091,          50.,   2.72727275
  11342,     29.09091,          50.,   3.63636374
  11343,     29.09091,          50.,    4.5454545
  11344,     29.09091,          50.,    5.4545455
  11345,     29.09091,          50.,   6.36363649
  11346,     29.09091,          50.,   7.27272749
  11347,     29.09091,          50.,   8.18181801
  11348,     29.09091,          50.,     9.090909
  11349,    28.181818,          50.,  0.909090936
  11350,    28.181818,          50.,   1.81818187
  11351,    28.181818,          50.,   2.72727275
  11352,    28.181818,          50.,   3.63636374
  11353,    28.181818,          50.,    4.5454545
  11354,    28.181818,          50.,    5.4545455
  11355,    28.181818,          50.,   6.36363649
  11356,    28.181818,          50.,   7.27272749
  11357,    28.181818,          50.,   8.18181801
  11358,    28.181818,          50.,     9.090909
  11359,    27.272728,          50.,  0.909090936
  11360,    27.272728,          50.,   1.81818187
  11361,    27.272728,          50.,   2.72727275
  11362,    27.272728,          50.,   3.63636374
  11363,    27.272728,          50.,    4.5454545
  11364,    27.272728,          50.,    5.4545455
  11365,    27.272728,          50.,   6.36363649
  11366,    27.272728,          50.,   7.27272749
  11367,    27.272728,          50.,   8.18181801
  11368,    27.272728,          50.,     9.090909
  11369,    26.363636,          50.,  0.909090936
  11370,    26.363636,          50.,   1.81818187
  11371,    26.363636,          50.,   2.72727275
  11372,    26.363636,          50.,   3.63636374
  11373,    26.363636,          50.,    4.5454545
  11374,    26.363636,          50.,    5.4545455
  11375,    26.363636,          50.,   6.36363649
  11376,    26.363636,          50.,   7.27272749
  11377,    26.363636,          50.,   8.18181801
  11378,    26.363636,          50.,     9.090909
  11379,    25.454546,          50.,  0.909090936
  11380,    25.454546,          50.,   1.81818187
  11381,    25.454546,          50.,   2.72727275
  11382,    25.454546,          50.,   3.63636374
  11383,    25.454546,          50.,    4.5454545
  11384,    25.454546,          50.,    5.4545455
  11385,    25.454546,          50.,   6.36363649
  11386,    25.454546,          50.,   7.27272749
  11387,    25.454546,          50.,   8.18181801
  11388,    25.454546,          50.,     9.090909
  11389,    24.545454,          50.,  0.909090936
  11390,    24.545454,          50.,   1.81818187
  11391,    24.545454,          50.,   2.72727275
  11392,    24.545454,          50.,   3.63636374
  11393,    24.545454,          50.,    4.5454545
  11394,    24.545454,          50.,    5.4545455
  11395,    24.545454,          50.,   6.36363649
  11396,    24.545454,          50.,   7.27272749
  11397,    24.545454,          50.,   8.18181801
  11398,    24.545454,          50.,     9.090909
  11399,    23.636364,          50.,  0.909090936
  11400,    23.636364,          50.,   1.81818187
  11401,    23.636364,          50.,   2.72727275
  11402,    23.636364,          50.,   3.63636374
  11403,    23.636364,          50.,    4.5454545
  11404,    23.636364,          50.,    5.4545455
  11405,    23.636364,          50.,   6.36363649
  11406,    23.636364,          50.,   7.27272749
  11407,    23.636364,          50.,   8.18181801
  11408,    23.636364,          50.,     9.090909
  11409,    22.727272,          50.,  0.909090936
  11410,    22.727272,          50.,   1.81818187
  11411,    22.727272,          50.,   2.72727275
  11412,    22.727272,          50.,   3.63636374
  11413,    22.727272,          50.,    4.5454545
  11414,    22.727272,          50.,    5.4545455
  11415,    22.727272,          50.,   6.36363649
  11416,    22.727272,          50.,   7.27272749
  11417,    22.727272,          50.,   8.18181801
  11418,    22.727272,          50.,     9.090909
  11419,    21.818182,          50.,  0.909090936
  11420,    21.818182,          50.,   1.81818187
  11421,    21.818182,          50.,   2.72727275
  11422,    21.818182,          50.,   3.63636374
  11423,    21.818182,          50.,    4.5454545
  11424,    21.818182,          50.,    5.4545455
  11425,    21.818182,          50.,   6.36363649
  11426,    21.818182,          50.,   7.27272749
  11427,    21.818182,          50.,   8.18181801
  11428,    21.818182,          50.,     9.090909
  11429,     20.90909,          50.,  0.909090936
  11430,     20.90909,          50.,   1.81818187
  11431,     20.90909,          50.,   2.72727275
  11432,     20.90909,          50.,   3.63636374
  11433,     20.90909,          50.,    4.5454545
  11434,     20.90909,          50.,    5.4545455
  11435,     20.90909,          50.,   6.36363649
  11436,     20.90909,          50.,   7.27272749
  11437,     20.90909,          50.,   8.18181801
  11438,     20.90909,          50.,     9.090909
  11439,    -29.09091,          50.,  0.909090936
  11440,    -29.09091,          50.,   1.81818187
  11441,    -29.09091,          50.,   2.72727275
  11442,    -29.09091,          50.,   3.63636374
  11443,    -29.09091,          50.,    4.5454545
  11444,    -29.09091,          50.,    5.4545455
  11445,    -29.09091,          50.,   6.36363649
  11446,    -29.09091,          50.,   7.27272749
  11447,    -29.09091,          50.,   8.18181801
  11448,    -29.09091,          50.,     9.090909
  11449,   -28.181818,          50.,  0.909090936
  11450,   -28.181818,          50.,   1.81818187
  11451,   -28.181818,          50.,   2.72727275
  11452,   -28.181818,          50.,   3.63636374
  11453,   -28.181818,          50.,    4.5454545
  11454,   -28.181818,          50.,    5.4545455
  11455,   -28.181818,          50.,   6.36363649
  11456,   -28.181818,          50.,   7.27272749
  11457,   -28.181818,          50.,   8.18181801
  11458,   -28.181818,          50.,     9.090909
  11459,   -27.272728,          50.,  0.909090936
  11460,   -27.272728,          50.,   1.81818187
  11461,   -27.272728,          50.,   2.72727275
  11462,   -27.272728,          50.,   3.63636374
  11463,   -27.272728,          50.,    4.5454545
  11464,   -27.272728,          50.,    5.4545455
  11465,   -27.272728,          50.,   6.36363649
  11466,   -27.272728,          50.,   7.27272749
  11467,   -27.272728,          50.,   8.18181801
  11468,   -27.272728,          50.,     9.090909
  11469,   -26.363636,          50.,  0.909090936
  11470,   -26.363636,          50.,   1.81818187
  11471,   -26.363636,          50.,   2.72727275
  11472,   -26.363636,          50.,   3.63636374
  11473,   -26.363636,          50.,    4.5454545
  11474,   -26.363636,          50.,    5.4545455
  11475,   -26.363636,          50.,   6.36363649
  11476,   -26.363636,          50.,   7.27272749
  11477,   -26.363636,          50.,   8.18181801
  11478,   -26.363636,          50.,     9.090909
  11479,   -25.454546,          50.,  0.909090936
  11480,   -25.454546,          50.,   1.81818187
  11481,   -25.454546,          50.,   2.72727275
  11482,   -25.454546,          50.,   3.63636374
  11483,   -25.454546,          50.,    4.5454545
  11484,   -25.454546,          50.,    5.4545455
  11485,   -25.454546,          50.,   6.36363649
  11486,   -25.454546,          50.,   7.27272749
  11487,   -25.454546,          50.,   8.18181801
  11488,   -25.454546,          50.,     9.090909
  11489,   -24.545454,          50.,  0.909090936
  11490,   -24.545454,          50.,   1.81818187
  11491,   -24.545454,          50.,   2.72727275
  11492,   -24.545454,          50.,   3.63636374
  11493,   -24.545454,          50.,    4.5454545
  11494,   -24.545454,          50.,    5.4545455
  11495,   -24.545454,          50.,   6.36363649
  11496,   -24.545454,          50.,   7.27272749
  11497,   -24.545454,          50.,   8.18181801
  11498,   -24.545454,          50.,     9.090909
  11499,   -23.636364,          50.,  0.909090936
  11500,   -23.636364,          50.,   1.81818187
  11501,   -23.636364,          50.,   2.72727275
  11502,   -23.636364,          50.,   3.63636374
  11503,   -23.636364,          50.,    4.5454545
  11504,   -23.636364,          50.,    5.4545455
  11505,   -23.636364,          50.,   6.36363649
  11506,   -23.636364,          50.,   7.27272749
  11507,   -23.636364,          50.,   8.18181801
  11508,   -23.636364,          50.,     9.090909
  11509,   -22.727272,          50.,  0.909090936
  11510,   -22.727272,          50.,   1.81818187
  11511,   -22.727272,          50.,   2.72727275
  11512,   -22.727272,          50.,   3.63636374
  11513,   -22.727272,          50.,    4.5454545
  11514,   -22.727272,          50.,    5.4545455
  11515,   -22.727272,          50.,   6.36363649
  11516,   -22.727272,          50.,   7.27272749
  11517,   -22.727272,          50.,   8.18181801
  11518,   -22.727272,          50.,     9.090909
  11519,   -21.818182,          50.,  0.909090936
  11520,   -21.818182,          50.,   1.81818187
  11521,   -21.818182,          50.,   2.72727275
  11522,   -21.818182,          50.,   3.63636374
  11523,   -21.818182,          50.,    4.5454545
  11524,   -21.818182,          50.,    5.4545455
  11525,   -21.818182,          50.,   6.36363649
  11526,   -21.818182,          50.,   7.27272749
  11527,   -21.818182,          50.,   8.18181801
  11528,   -21.818182,          50.,     9.090909
  11529,    -20.90909,          50.,  0.909090936
  11530,    -20.90909,          50.,   1.81818187
  11531,    -20.90909,          50.,   2.72727275
  11532,    -20.90909,          50.,   3.63636374
  11533,    -20.90909,          50.,    4.5454545
  11534,    -20.90909,          50.,    5.4545455
  11535,    -20.90909,          50.,   6.36363649
  11536,    -20.90909,          50.,   7.27272749
  11537,    -20.90909,          50.,   8.18181801
  11538,    -20.90909,          50.,     9.090909
  11539,   29.0759621,   50.9324112,          10.
  11540,   29.0311394,   51.8638611,          10.
  11541,   28.9564838,    52.793396,          10.
  11542,   28.8520737,   53.7200623,          10.
  11543,   28.7180157,   54.6429062,          10.
  11544,   28.5544491,   55.5609779,          10.
  11545,   28.3615398,   56.4733353,          10.
  11546,   28.1394863,   57.3790436,          10.
  11547,   27.8885193,   58.2771645,          10.
  11548,   27.6088943,   59.1667862,          10.
  11549,   27.3008995,   60.0469818,          10.
  11550,   26.9648514,   60.9168587,          10.
  11551,   26.6010952,   61.7755165,          10.
  11552,   26.2100029,   62.6220741,          10.
  11553,   25.7919807,    63.455658,          10.
  11554,   25.3474541,   64.2754211,          10.
  11555,   24.8768806,    65.080513,          10.
  11556,   24.3807449,   65.8701096,          10.
  11557,   23.8595562,   66.6433945,          10.
  11558,   23.3138504,   67.3995819,          10.
  11559,   22.7441883,    68.137886,          10.
  11560,   22.1511555,   68.8575516,          10.
  11561,   21.5353603,   69.5578461,          10.
  11562,   20.8974361,   70.2380371,          10.
  11563,   20.2380371,    70.897438,          10.
  11564,   19.5578442,   71.5353622,          10.
  11565,   18.8575535,   72.1511536,          10.
  11566,    18.137886,   72.7441864,          10.
  11567,     17.39958,   73.3138504,          10.
  11568,   16.6433945,   73.8595581,          10.
  11569,   15.8701057,   74.3807449,          10.
  11570,   15.0805111,   74.8768768,          10.
  11571,   14.2754192,   75.3474503,          10.
  11572,   13.4556589,   75.7919769,          10.
  11573,   12.6220722,   76.2100067,          10.
  11574,   11.7755156,   76.6010971,          10.
  11575,   10.9168587,   76.9648514,          10.
  11576,   10.0469837,   77.3009033,          10.
  11577,   9.16678429,   77.6088943,          10.
  11578,   8.27716637,   77.8885193,          10.
  11579,   7.37904263,   78.1394882,          10.
  11580,   6.47333622,   78.3615417,          10.
  11581,   5.56097841,    78.554451,          10.
  11582,   4.64290619,   78.7180176,          10.
  11583,   3.72006297,   78.8520737,          10.
  11584,   2.79339719,   78.9564819,          10.
  11585,   1.86386096,   79.0311356,          10.
  11586,  0.932409525,   79.0759659,          10.
  11587,           0.,   79.0909119,          10.
  11588, -0.932409525,   79.0759659,          10.
  11589,  -1.86386096,   79.0311356,          10.
  11590,  -2.79339719,   78.9564819,          10.
  11591,  -3.72006297,   78.8520737,          10.
  11592,  -4.64290619,   78.7180176,          10.
  11593,  -5.56097841,    78.554451,          10.
  11594,  -6.47333622,   78.3615417,          10.
  11595,  -7.37904263,   78.1394882,          10.
  11596,  -8.27716637,   77.8885193,          10.
  11597,  -9.16678429,   77.6088943,          10.
  11598,  -10.0469837,   77.3009033,          10.
  11599,  -10.9168587,   76.9648514,          10.
  11600,  -11.7755156,   76.6010971,          10.
  11601,  -12.6220722,   76.2100067,          10.
  11602,  -13.4556589,   75.7919769,          10.
  11603,  -14.2754192,   75.3474503,          10.
  11604,  -15.0805111,   74.8768768,          10.
  11605,  -15.8701057,   74.3807449,          10.
  11606,  -16.6433945,   73.8595581,          10.
  11607,    -17.39958,   73.3138504,          10.
  11608,   -18.137886,   72.7441864,          10.
  11609,  -18.8575535,   72.1511536,          10.
  11610,  -19.5578442,   71.5353622,          10.
  11611,  -20.2380371,    70.897438,          10.
  11612,  -20.8974361,   70.2380371,          10.
  11613,  -21.5353603,   69.5578461,          10.
  11614,  -22.1511555,   68.8575516,          10.
  11615,  -22.7441883,    68.137886,          10.
  11616,  -23.3138504,   67.3995819,          10.
  11617,  -23.8595562,   66.6433945,          10.
  11618,  -24.3807449,   65.8701096,          10.
  11619,  -24.8768806,    65.080513,          10.
  11620,  -25.3474541,   64.2754211,          10.
  11621,  -25.7919807,    63.455658,          10.
  11622,  -26.2100029,   62.6220741,          10.
  11623,  -26.6010952,   61.7755165,          10.
  11624,  -26.9648514,   60.9168587,          10.
  11625,  -27.3008995,   60.0469818,          10.
  11626,  -27.6088943,   59.1667862,          10.
  11627,  -27.8885193,   58.2771645,          10.
  11628,  -28.1394863,   57.3790436,          10.
  11629,  -28.3615398,   56.4733353,          10.
  11630,  -28.5544491,   55.5609779,          10.
  11631,  -28.7180157,   54.6429062,          10.
  11632,  -28.8520737,   53.7200623,          10.
  11633,  -28.9564838,    52.793396,          10.
  11634,  -29.0311394,   51.8638611,          10.
  11635,  -29.0759621,   50.9324112,          10.
  11636,   28.1673393,   50.9032707,          10.
  11637,   28.1239147,   51.8056145,          10.
  11638,   28.0515938,   52.7061043,          10.
  11639,   27.9504452,   53.6038094,          10.
  11640,   27.8205776,   54.4978142,          10.
  11641,   27.6621208,   55.3871994,          10.
  11642,   27.4752407,   56.2710457,          10.
  11643,    27.260128,   57.1484489,          10.
  11644,    27.017004,   58.0185051,          10.
  11645,   26.7461166,   58.8803215,          10.
  11646,   26.4477463,    59.733017,          10.
  11647,      26.1222,   60.5757065,          10.
  11648,   25.7698097,   61.4075317,          10.
  11649,   25.3909416,   62.2276344,          10.
  11650,    24.985981,   63.0351715,          10.
  11651,   24.5553455,   63.8293114,          10.
  11652,   24.0994778,   64.6092453,          10.
  11653,   23.6188469,   65.3741684,          10.
  11654,    23.113945,    66.123291,          10.
  11655,   22.5852928,   66.8558426,          10.
  11656,    22.033432,   67.5710754,          10.
  11657,    21.458931,   68.2682571,          10.
  11658,   20.8623791,   68.9466629,          10.
  11659,   20.2443905,   69.6055984,          10.
  11660,   19.6055984,   70.2443924,          10.
  11661,    18.946661,    70.862381,          10.
  11662,   18.2682552,    71.458931,          10.
  11663,   17.5710754,    72.033432,          10.
  11664,   16.8558426,   72.5852966,          10.
  11665,   16.1232872,    73.113945,          10.
  11666,   15.3741655,   73.6188431,          10.
  11667,   14.6092453,   74.0994797,          10.
  11668,   13.8293133,   74.5553436,          10.
  11669,   13.0351696,   74.9859772,          10.
  11670,   12.2276325,   75.3909378,          10.
  11671,   11.4075308,   75.7698135,          10.
  11672,   10.5757065,      76.1222,          10.
  11673,   9.73301506,   76.4477463,          10.
  11674,   8.88032246,   76.7461166,          10.
  11675,    8.0185051,   77.0170059,          10.
  11676,   7.14844751,   77.2601242,          10.
  11677,   6.27104473,   77.4752426,          10.
  11678,   5.38719749,   77.6621246,          10.
  11679,   4.49781513,   77.8205795,          10.
  11680,   3.60381103,   77.9504471,          10.
  11681,   2.70610356,     78.05159,          10.
  11682,   1.80561531,   78.1239166,          10.
  11683,  0.903271735,   78.1673355,          10.
  11684,           0.,   78.1818161,          10.
  11685, -0.903271735,   78.1673355,          10.
  11686,  -1.80561531,   78.1239166,          10.
  11687,  -2.70610356,     78.05159,          10.
  11688,  -3.60381103,   77.9504471,          10.
  11689,  -4.49781513,   77.8205795,          10.
  11690,  -5.38719749,   77.6621246,          10.
  11691,  -6.27104473,   77.4752426,          10.
  11692,  -7.14844751,   77.2601242,          10.
  11693,   -8.0185051,   77.0170059,          10.
  11694,  -8.88032246,   76.7461166,          10.
  11695,  -9.73301506,   76.4477463,          10.
  11696,  -10.5757065,      76.1222,          10.
  11697,  -11.4075308,   75.7698135,          10.
  11698,  -12.2276325,   75.3909378,          10.
  11699,  -13.0351696,   74.9859772,          10.
  11700,  -13.8293133,   74.5553436,          10.
  11701,  -14.6092453,   74.0994797,          10.
  11702,  -15.3741655,   73.6188431,          10.
  11703,  -16.1232872,    73.113945,          10.
  11704,  -16.8558426,   72.5852966,          10.
  11705,  -17.5710754,    72.033432,          10.
  11706,  -18.2682552,    71.458931,          10.
  11707,   -18.946661,    70.862381,          10.
  11708,  -19.6055984,   70.2443924,          10.
  11709,  -20.2443905,   69.6055984,          10.
  11710,  -20.8623791,   68.9466629,          10.
  11711,   -21.458931,   68.2682571,          10.
  11712,   -22.033432,   67.5710754,          10.
  11713,  -22.5852928,   66.8558426,          10.
  11714,   -23.113945,    66.123291,          10.
  11715,  -23.6188469,   65.3741684,          10.
  11716,  -24.0994778,   64.6092453,          10.
  11717,  -24.5553455,   63.8293114,          10.
  11718,   -24.985981,   63.0351715,          10.
  11719,  -25.3909416,   62.2276344,          10.
  11720,  -25.7698097,   61.4075317,          10.
  11721,     -26.1222,   60.5757065,          10.
  11722,  -26.4477463,    59.733017,          10.
  11723,  -26.7461166,   58.8803215,          10.
  11724,   -27.017004,   58.0185051,          10.
  11725,   -27.260128,   57.1484489,          10.
  11726,  -27.4752407,   56.2710457,          10.
  11727,  -27.6621208,   55.3871994,          10.
  11728,  -27.8205776,   54.4978142,          10.
  11729,  -27.9504452,   53.6038094,          10.
  11730,  -28.0515938,   52.7061043,          10.
  11731,  -28.1239147,   51.8056145,          10.
  11732,  -28.1673393,   50.9032707,          10.
  11733,   27.2587147,   50.8741341,          10.
  11734,    27.216692,   51.7473679,          10.
  11735,   27.1467037,   52.6188087,          10.
  11736,   27.0488186,   53.4875603,          10.
  11737,   26.9231396,    54.352726,          10.
  11738,   26.7697945,   55.2134171,          10.
  11739,   26.5889435,   56.0687523,          10.
  11740,   26.3807697,   56.9178505,          10.
  11741,   26.1454868,   57.7598419,          10.
  11742,   25.8833389,   58.5938606,          10.
  11743,    25.594593,   59.4190483,          10.
  11744,   25.2795486,   60.2345543,          10.
  11745,   24.9385262,    61.039547,          10.
  11746,   24.5718784,   61.8331947,          10.
  11747,   24.1799812,   62.6146812,          10.
  11748,    23.763237,   63.3832054,          10.
  11749,   23.3220749,   64.1379776,          10.
  11750,   22.8569489,   64.8782272,          10.
  11751,   22.3683338,   65.6031799,          10.
  11752,   21.8567352,   66.3121033,          10.
  11753,   21.3226776,   67.0042648,          10.
  11754,   20.7667084,   67.6789551,          10.
  11755,   20.1893997,   68.3354797,          10.
  11756,   19.5913467,   68.9731598,          10.
  11757,   18.9731598,   69.5913467,          10.
  11758,   18.3354797,   70.1893997,          10.
  11759,    17.678957,   70.7667084,          10.
  11760,   17.0042667,   71.3226776,          10.
  11761,   16.3121052,   71.8567352,          10.
  11762,   15.6031818,   72.3683319,          10.
  11763,   14.8782244,   72.8569489,          10.
  11764,   14.1379795,   73.3220749,          10.
  11765,   13.3832064,    73.763237,          10.
  11766,   12.6146803,   74.1799774,          10.
  11767,   11.8331928,   74.5718765,          10.
  11768,    11.039546,   74.9385223,          10.
  11769,   10.2345543,   75.2795486,          10.
  11770,   9.41904736,   75.5945969,          10.
  11771,   8.59386063,   75.8833389,          10.
  11772,   7.75984335,   76.1454849,          10.
  11773,    6.9178524,   76.3807678,          10.
  11774,   6.06875277,   76.5889435,          10.
  11775,   5.21341705,   76.7697983,          10.
  11776,   4.35272455,   76.9231415,          10.
  11777,   3.48755884,   77.0488205,          10.
  11778,    2.6188097,   77.1467056,          10.
  11779,   1.74736965,   77.2166901,          10.
  11780,  0.874133945,   77.2587128,          10.
  11781,           0.,    77.272728,          10.
  11782, -0.874133945,   77.2587128,          10.
  11783,  -1.74736965,   77.2166901,          10.
  11784,   -2.6188097,   77.1467056,          10.
  11785,  -3.48755884,   77.0488205,          10.
  11786,  -4.35272455,   76.9231415,          10.
  11787,  -5.21341705,   76.7697983,          10.
  11788,  -6.06875277,   76.5889435,          10.
  11789,   -6.9178524,   76.3807678,          10.
  11790,  -7.75984335,   76.1454849,          10.
  11791,  -8.59386063,   75.8833389,          10.
  11792,  -9.41904736,   75.5945969,          10.
  11793,  -10.2345543,   75.2795486,          10.
  11794,   -11.039546,   74.9385223,          10.
  11795,  -11.8331928,   74.5718765,          10.
  11796,  -12.6146803,   74.1799774,          10.
  11797,  -13.3832064,    73.763237,          10.
  11798,  -14.1379795,   73.3220749,          10.
  11799,  -14.8782244,   72.8569489,          10.
  11800,  -15.6031818,   72.3683319,          10.
  11801,  -16.3121052,   71.8567352,          10.
  11802,  -17.0042667,   71.3226776,          10.
  11803,   -17.678957,   70.7667084,          10.
  11804,  -18.3354797,   70.1893997,          10.
  11805,  -18.9731598,   69.5913467,          10.
  11806,  -19.5913467,   68.9731598,          10.
  11807,  -20.1893997,   68.3354797,          10.
  11808,  -20.7667084,   67.6789551,          10.
  11809,  -21.3226776,   67.0042648,          10.
  11810,  -21.8567352,   66.3121033,          10.
  11811,  -22.3683338,   65.6031799,          10.
  11812,  -22.8569489,   64.8782272,          10.
  11813,  -23.3220749,   64.1379776,          10.
  11814,   -23.763237,   63.3832054,          10.
  11815,  -24.1799812,   62.6146812,          10.
  11816,  -24.5718784,   61.8331947,          10.
  11817,  -24.9385262,    61.039547,          10.
  11818,  -25.2795486,   60.2345543,          10.
  11819,   -25.594593,   59.4190483,          10.
  11820,  -25.8833389,   58.5938606,          10.
  11821,  -26.1454868,   57.7598419,          10.
  11822,  -26.3807697,   56.9178505,          10.
  11823,  -26.5889435,   56.0687523,          10.
  11824,  -26.7697945,   55.2134171,          10.
  11825,  -26.9231396,    54.352726,          10.
  11826,  -27.0488186,   53.4875603,          10.
  11827,  -27.1467037,   52.6188087,          10.
  11828,   -27.216692,   51.7473679,          10.
  11829,  -27.2587147,   50.8741341,          10.
  11830,   26.3500919,   50.8449974,          10.
  11831,   26.3094692,   51.6891251,          10.
  11832,   26.2418137,    52.531517,          10.
  11833,    26.147192,   53.3713074,          10.
  11834,   26.0257015,    54.207634,          10.
  11835,   25.8774681,   55.0396347,          10.
  11836,   25.7026443,   55.8664627,          10.
  11837,   25.5014095,   56.6872559,          10.
  11838,   25.2739716,   57.5011826,          10.
  11839,   25.0205612,   58.3073997,          10.
  11840,   24.7414398,   59.1050797,          10.
  11841,   24.4368973,   59.8934021,          10.
  11842,   24.1072426,   60.6715622,          10.
  11843,   23.7528152,   61.4387512,          10.
  11844,   23.3739815,    62.194191,          10.
  11845,   22.9711304,   62.9370995,          10.
  11846,    22.544672,   63.6667137,          10.
  11847,   22.0950508,   64.3822861,          10.
  11848,   21.6227226,   65.0830765,          10.
  11849,   21.1281776,   65.7683716,          10.
  11850,   20.6119213,   66.4374619,          10.
  11851,   20.0744839,   67.0896606,          10.
  11852,   19.5164204,   67.7242966,          10.
  11853,   18.9383011,   68.3407211,          10.
  11854,   18.3407211,   68.9383011,          10.
  11855,   17.7242966,   69.5164185,          10.
  11856,   17.0896568,   70.0744858,          10.
  11857,    16.437458,   70.6119232,          10.
  11858,   15.7683687,   71.1281738,          10.
  11859,   15.0830755,   71.6227264,          10.
  11860,   14.3822842,    72.095047,          10.
  11861,   13.6667128,   72.5446701,          10.
  11862,   12.9370995,   72.9711304,          10.
  11863,    12.194191,   73.3739853,          10.
  11864,   11.4387531,   73.7528152,          10.
  11865,   10.6715612,   74.1072388,          10.
  11866,   9.89340305,   74.4368973,          10.
  11867,    9.1050787,   74.7414398,          10.
  11868,    8.3073988,   75.0205612,          10.
  11869,    7.5011816,   75.2739716,          10.
  11870,   6.68725729,   75.5014114,          10.
  11871,    5.8664608,   75.7026443,          10.
  11872,   5.03963661,   75.8774719,          10.
  11873,    4.2076335,   76.0257034,          10.
  11874,    3.3713069,   76.1471939,          10.
  11875,   2.53151608,   76.2418137,          10.
  11876,   1.68912399,   76.3094711,          10.
  11877,  0.844996154,     76.35009,          10.
  11878,           0.,   76.3636398,          10.
  11879, -0.844996154,     76.35009,          10.
  11880,  -1.68912399,   76.3094711,          10.
  11881,  -2.53151608,   76.2418137,          10.
  11882,   -3.3713069,   76.1471939,          10.
  11883,   -4.2076335,   76.0257034,          10.
  11884,  -5.03963661,   75.8774719,          10.
  11885,   -5.8664608,   75.7026443,          10.
  11886,  -6.68725729,   75.5014114,          10.
  11887,   -7.5011816,   75.2739716,          10.
  11888,   -8.3073988,   75.0205612,          10.
  11889,   -9.1050787,   74.7414398,          10.
  11890,  -9.89340305,   74.4368973,          10.
  11891,  -10.6715612,   74.1072388,          10.
  11892,  -11.4387531,   73.7528152,          10.
  11893,   -12.194191,   73.3739853,          10.
  11894,  -12.9370995,   72.9711304,          10.
  11895,  -13.6667128,   72.5446701,          10.
  11896,  -14.3822842,    72.095047,          10.
  11897,  -15.0830755,   71.6227264,          10.
  11898,  -15.7683687,   71.1281738,          10.
  11899,   -16.437458,   70.6119232,          10.
  11900,  -17.0896568,   70.0744858,          10.
  11901,  -17.7242966,   69.5164185,          10.
  11902,  -18.3407211,   68.9383011,          10.
  11903,  -18.9383011,   68.3407211,          10.
  11904,  -19.5164204,   67.7242966,          10.
  11905,  -20.0744839,   67.0896606,          10.
  11906,  -20.6119213,   66.4374619,          10.
  11907,  -21.1281776,   65.7683716,          10.
  11908,  -21.6227226,   65.0830765,          10.
  11909,  -22.0950508,   64.3822861,          10.
  11910,   -22.544672,   63.6667137,          10.
  11911,  -22.9711304,   62.9370995,          10.
  11912,  -23.3739815,    62.194191,          10.
  11913,  -23.7528152,   61.4387512,          10.
  11914,  -24.1072426,   60.6715622,          10.
  11915,  -24.4368973,   59.8934021,          10.
  11916,  -24.7414398,   59.1050797,          10.
  11917,  -25.0205612,   58.3073997,          10.
  11918,  -25.2739716,   57.5011826,          10.
  11919,  -25.5014095,   56.6872559,          10.
  11920,  -25.7026443,   55.8664627,          10.
  11921,  -25.8774681,   55.0396347,          10.
  11922,  -26.0257015,    54.207634,          10.
  11923,   -26.147192,   53.3713074,          10.
  11924,  -26.2418137,    52.531517,          10.
  11925,  -26.3094692,   51.6891251,          10.
  11926,  -26.3500919,   50.8449974,          10.
  11927,   25.4414673,   50.8158569,          10.
  11928,   25.4022465,   51.6308784,          10.
  11929,   25.3369236,   52.4442215,          10.
  11930,   25.2455635,   53.2550545,          10.
  11931,   25.1282635,    54.062542,          10.
  11932,   24.9851418,   54.8658562,          10.
  11933,   24.8163471,   55.6641693,          10.
  11934,   24.6220512,   56.4566612,          10.
  11935,   24.4024544,   57.2425194,          10.
  11936,   24.1577835,   58.0209351,          10.
  11937,   23.8882866,    58.791111,          10.
  11938,    23.594244,   59.5522499,          10.
  11939,   23.2759571,   60.3035774,          10.
  11940,   22.9337521,   61.0443115,          10.
  11941,   22.5679817,   61.7737007,          10.
  11942,   22.1790218,   62.4909935,          10.
  11943,    21.767271,    63.195446,          10.
  11944,   21.3331509,   63.8863411,          10.
  11945,   20.8771114,    64.562973,          10.
  11946,   20.3996201,   65.2246323,          10.
  11947,    19.901165,   65.8706512,          10.
  11948,   19.3822613,   66.5003586,          10.
  11949,   18.8434391,   67.1131134,          10.
  11950,   18.2852554,   67.7082825,          10.
  11951,   17.7082825,   68.2852554,          10.
  11952,   17.1131134,   68.8434372,          10.
  11953,   16.5003586,   69.3822632,          10.
  11954,   15.8706493,   69.9011612,          10.
  11955,   15.2246313,   70.3996201,          10.
  11956,   14.5629692,   70.8771133,          10.
  11957,    13.886343,   71.3331528,          10.
  11958,    13.195447,   71.7672729,          10.
  11959,   12.4909925,   72.1790237,          10.
  11960,   11.7737017,   72.5679855,          10.
  11961,   11.0443134,    72.933754,          10.
  11962,   10.3035765,   73.2759552,          10.
  11963,   9.55225086,   73.5942459,          10.
  11964,   8.79111004,   73.8882904,          10.
  11965,   8.02093601,   74.1577835,          10.
  11966,   7.24252033,   74.4024582,          10.
  11967,   6.45666218,   74.6220474,          10.
  11968,   5.66416931,   74.8163452,          10.
  11969,   4.86585617,   74.9851456,          10.
  11970,   4.06254292,   75.1282654,          10.
  11971,   3.25505495,   75.2455673,          10.
  11972,   2.44422245,   75.3369217,          10.
  11973,   1.63087833,   75.4022446,          10.
  11974,  0.815858364,   75.4414673,          10.
  11975,           0.,   75.4545441,          10.
  11976, -0.815858364,   75.4414673,          10.
  11977,  -1.63087833,   75.4022446,          10.
  11978,  -2.44422245,   75.3369217,          10.
  11979,  -3.25505495,   75.2455673,          10.
  11980,  -4.06254292,   75.1282654,          10.
  11981,  -4.86585617,   74.9851456,          10.
  11982,  -5.66416931,   74.8163452,          10.
  11983,  -6.45666218,   74.6220474,          10.
  11984,  -7.24252033,   74.4024582,          10.
  11985,  -8.02093601,   74.1577835,          10.
  11986,  -8.79111004,   73.8882904,          10.
  11987,  -9.55225086,   73.5942459,          10.
  11988,  -10.3035765,   73.2759552,          10.
  11989,  -11.0443134,    72.933754,          10.
  11990,  -11.7737017,   72.5679855,          10.
  11991,  -12.4909925,   72.1790237,          10.
  11992,   -13.195447,   71.7672729,          10.
  11993,   -13.886343,   71.3331528,          10.
  11994,  -14.5629692,   70.8771133,          10.
