*Heading
** Job name: U_elastic_mesh_only Model name: Model-1
** Generated by: Abaqus/CAE 2018
*Preprint, echo=NO, model=NO, history=NO, contact=NO
** ----------------------------------------------------------------
** 
** PART INSTANCE: U_elastic
** 
*Node
      1,          20.,          20.,           0.
      2,          30.,          20.,           0.
      3,          26.,          25.,           0.
      4,          30.,          25.,           0.
      5,          20.,          25.,           0.
      6,          26.,          45.,           0.
      7,          20.,          45.,           0.
      8,          30.,          45.,           0.
      9,          30.,          50.,           0.
     10,          20.,          50.,           0.
     11,          30.,          20.,         -10.
     12,          30.,          50.,         -10.
     13,          20.,          50.,         -10.
     14,          20.,          20.,         -10.
     15,         -20.,          20.,         -10.
     16,         -30.,          20.,         -10.
     17,         -30.,          20.,           0.
     18,         -20.,          20.,           0.
     19,         -20.,          50.,         -10.
     20,         -30.,          50.,         -10.
     21,         -30.,          50.,           0.
     22,         -20.,          50.,           0.
     23,         -20.,          25.,           0.
     24,         -20.,          45.,           0.
     25,         -30.,          25.,           0.
     26,         -30.,          45.,           0.
     27,         -26.,          25.,           0.
     28,         -26.,          45.,           0.
     29,           0.,          70.,           0.
     30,           0.,          80.,           0.
     31,         -30.,          50.,          10.
     32,          30.,          50.,          10.
     33,         -20.,          50.,          10.
     34,          20.,          50.,          10.
     35,          20.,          20.,          10.
     36,          30.,          20.,          10.
     37,          22.,          15.,          10.
     38,          28.,          15.,          10.
     39,          28.,          15.,           5.
     40,          22.,          15.,           5.
     41,         -30.,          20.,          10.
     42,         -20.,          20.,          10.
     43,         -22.,          15.,           5.
     44,         -28.,          15.,           5.
     45,         -28.,          15.,          10.
     46,         -22.,          15.,          10.
     47,          28.,          15.,          -5.
     48,          28.,          15.,         -10.
     49,          22.,          15.,          -5.
     50,          22.,          15.,         -10.
     51,          20.,          10.,           0.
     52,          30.,          10.,           0.
     53,          30.,          10.,         -10.
     54,          20.,          10.,         -10.
     55,         -22.,          15.,         -10.
     56,         -28.,          15.,         -10.
     57,         -22.,          15.,          -5.
     58,         -28.,          15.,          -5.
     59,         -20.,          10.,          10.
     60,         -20.,          10.,           0.
     61,         -30.,          10.,           0.
     62,         -30.,          10.,          10.
     63,         -30.,           0.,           0.
     64,         -30.,           0.,          10.
     65,         -20.,           0.,          10.
     66,         -20.,           0.,           0.
     67,          20.,          10.,          10.
     68,          30.,          10.,          10.
     69,          20.,           0.,           0.
     70,          20.,           0.,          10.
     71,          30.,           0.,          10.
     72,          30.,           0.,           0.
     73,          30.,           0.,         -10.
     74,          20.,           0.,         -10.
     75,         -20.,           0.,         -10.
     76,         -20.,          10.,         -10.
     77,         -30.,          10.,         -10.
     78,         -30.,           0.,         -10.
     79,     20.90909,          20.,           0.
     80,    21.818182,          20.,           0.
     81,    22.727272,          20.,           0.
     82,    23.636364,          20.,           0.
     83,    24.545454,          20.,           0.
     84,    25.454546,          20.,           0.
     85,    26.363636,          20.,           0.
     86,    27.272728,          20.,           0.
     87,    28.181818,          20.,           0.
     88,     29.09091,          20.,           0.
     89,          30.,   20.7142849,           0.
     90,          30.,   21.4285717,           0.
     91,          30.,   22.1428566,           0.
     92,          30.,   22.8571434,           0.
     93,          30.,   23.5714283,           0.
     94,          30.,   24.2857151,           0.
     95,          25.,          25.,           0.
     96,          24.,          25.,           0.
     97,          23.,          25.,           0.
     98,          22.,          25.,           0.
     99,          21.,          25.,           0.
    100,   29.2000008,          25.,           0.
    101,   28.3999996,          25.,           0.
    102,   27.6000004,          25.,           0.
    103,   26.7999992,          25.,           0.
    104,          20.,   24.2857151,           0.
    105,          20.,   23.5714283,           0.
    106,          20.,   22.8571434,           0.
    107,          20.,   22.1428566,           0.
    108,          20.,   21.4285717,           0.
    109,          20.,   20.7142849,           0.
    110,          26.,   25.7999992,           0.
    111,          26.,   26.6000004,           0.
    112,          26.,   27.3999996,           0.
    113,          26.,   28.2000008,           0.
    114,          26.,          29.,           0.
    115,          26.,   29.7999992,           0.
    116,          26.,   30.6000004,           0.
    117,          26.,   31.3999996,           0.
    118,          26.,   32.2000008,           0.
    119,          26.,          33.,           0.
    120,          26.,   33.7999992,           0.
    121,          26.,   34.5999985,           0.
    122,          26.,   35.4000015,           0.
    123,          26.,   36.2000008,           0.
    124,          26.,          37.,           0.
    125,          26.,   37.7999992,           0.
    126,          26.,   38.5999985,           0.
    127,          26.,   39.4000015,           0.
    128,          26.,   40.2000008,           0.
    129,          26.,          41.,           0.
    130,          26.,   41.7999992,           0.
    131,          26.,   42.5999985,           0.
    132,          26.,   43.4000015,           0.
    133,          26.,   44.2000008,           0.
    134,          25.,          45.,           0.
    135,          24.,          45.,           0.
    136,          23.,          45.,           0.
    137,          22.,          45.,           0.
    138,          21.,          45.,           0.
    139,          20.,   44.2000008,           0.
    140,          20.,   43.4000015,           0.
    141,          20.,   42.5999985,           0.
    142,          20.,   41.7999992,           0.
    143,          20.,          41.,           0.
    144,          20.,   40.2000008,           0.
    145,          20.,   39.4000015,           0.
    146,          20.,   38.5999985,           0.
    147,          20.,   37.7999992,           0.
    148,          20.,          37.,           0.
    149,          20.,   36.2000008,           0.
    150,          20.,   35.4000015,           0.
    151,          20.,   34.5999985,           0.
    152,          20.,   33.7999992,           0.
    153,          20.,          33.,           0.
    154,          20.,   32.2000008,           0.
    155,          20.,   31.3999996,           0.
    156,          20.,   30.6000004,           0.
    157,          20.,   29.7999992,           0.
    158,          20.,          29.,           0.
    159,          20.,   28.2000008,           0.
    160,          20.,   27.3999996,           0.
    161,          20.,   26.6000004,           0.
    162,          20.,   25.7999992,           0.
    163,          30.,   25.7999992,           0.
    164,          30.,   26.6000004,           0.
    165,          30.,   27.3999996,           0.
    166,          30.,   28.2000008,           0.
    167,          30.,          29.,           0.
    168,          30.,   29.7999992,           0.
    169,          30.,   30.6000004,           0.
    170,          30.,   31.3999996,           0.
    171,          30.,   32.2000008,           0.
    172,          30.,          33.,           0.
    173,          30.,   33.7999992,           0.
    174,          30.,   34.5999985,           0.
    175,          30.,   35.4000015,           0.
    176,          30.,   36.2000008,           0.
    177,          30.,          37.,           0.
    178,          30.,   37.7999992,           0.
    179,          30.,   38.5999985,           0.
    180,          30.,   39.4000015,           0.
    181,          30.,   40.2000008,           0.
    182,          30.,          41.,           0.
    183,          30.,   41.7999992,           0.
    184,          30.,   42.5999985,           0.
    185,          30.,   43.4000015,           0.
    186,          30.,   44.2000008,           0.
    187,   29.2000008,          45.,           0.
    188,   28.3999996,          45.,           0.
    189,   27.6000004,          45.,           0.
    190,   26.7999992,          45.,           0.
    191,          30.,   45.8333321,           0.
    192,          30.,   46.6666679,           0.
    193,          30.,         47.5,           0.
    194,          30.,   48.3333321,           0.
    195,          30.,   49.1666679,           0.
    196,     29.09091,          50.,           0.
    197,    28.181818,          50.,           0.
    198,    27.272728,          50.,           0.
    199,    26.363636,          50.,           0.
    200,    25.454546,          50.,           0.
    201,    24.545454,          50.,           0.
    202,    23.636364,          50.,           0.
    203,    22.727272,          50.,           0.
    204,    21.818182,          50.,           0.
    205,     20.90909,          50.,           0.
    206,          20.,   49.1666679,           0.
    207,          20.,   48.3333321,           0.
    208,          20.,         47.5,           0.
    209,          20.,   46.6666679,           0.
    210,          20.,   45.8333321,           0.
    211,     29.09091,          20.,         -10.
    212,    28.181818,          20.,         -10.
    213,    27.272728,          20.,         -10.
    214,    26.363636,          20.,         -10.
    215,    25.454546,          20.,         -10.
    216,    24.545454,          20.,         -10.
    217,    23.636364,          20.,         -10.
    218,    22.727272,          20.,         -10.
    219,    21.818182,          20.,         -10.
    220,     20.90909,          20.,         -10.
    221,          30.,   49.2105255,         -10.
    222,          30.,    48.421051,         -10.
    223,          30.,   47.6315804,         -10.
    224,          30.,   46.8421059,         -10.
    225,          30.,   46.0526314,         -10.
    226,          30.,   45.2631569,         -10.
    227,          30.,   44.4736824,         -10.
    228,          30.,   43.6842117,         -10.
    229,          30.,   42.8947372,         -10.
    230,          30.,   42.1052628,         -10.
    231,          30.,   41.3157883,         -10.
    232,          30.,   40.5263176,         -10.
    233,          30.,   39.7368431,         -10.
    234,          30.,   38.9473686,         -10.
    235,          30.,   38.1578941,         -10.
    236,          30.,   37.3684196,         -10.
    237,          30.,    36.578949,         -10.
    238,          30.,   35.7894745,         -10.
    239,          30.,          35.,         -10.
    240,          30.,   34.2105255,         -10.
    241,          30.,    33.421051,         -10.
    242,          30.,   32.6315804,         -10.
    243,          30.,   31.8421059,         -10.
    244,          30.,   31.0526314,         -10.
    245,          30.,   30.2631588,         -10.
    246,          30.,   29.4736843,         -10.
    247,          30.,   28.6842098,         -10.
    248,          30.,   27.8947372,         -10.
    249,          30.,   27.1052628,         -10.
    250,          30.,   26.3157902,         -10.
    251,          30.,   25.5263157,         -10.
    252,          30.,   24.7368412,         -10.
    253,          30.,   23.9473686,         -10.
    254,          30.,   23.1578941,         -10.
    255,          30.,   22.3684216,         -10.
    256,          30.,   21.5789471,         -10.
    257,          30.,   20.7894745,         -10.
    258,     20.90909,          50.,         -10.
    259,    21.818182,          50.,         -10.
    260,    22.727272,          50.,         -10.
    261,    23.636364,          50.,         -10.
    262,    24.545454,          50.,         -10.
    263,    25.454546,          50.,         -10.
    264,    26.363636,          50.,         -10.
    265,    27.272728,          50.,         -10.
    266,    28.181818,          50.,         -10.
    267,     29.09091,          50.,         -10.
    268,          20.,   20.7894745,         -10.
    269,          20.,   21.5789471,         -10.
    270,          20.,   22.3684216,         -10.
    271,          20.,   23.1578941,         -10.
    272,          20.,   23.9473686,         -10.
    273,          20.,   24.7368412,         -10.
    274,          20.,   25.5263157,         -10.
    275,          20.,   26.3157902,         -10.
    276,          20.,   27.1052628,         -10.
    277,          20.,   27.8947372,         -10.
    278,          20.,   28.6842098,         -10.
    279,          20.,   29.4736843,         -10.
    280,          20.,   30.2631588,         -10.
    281,          20.,   31.0526314,         -10.
    282,          20.,   31.8421059,         -10.
    283,          20.,   32.6315804,         -10.
    284,          20.,    33.421051,         -10.
    285,          20.,   34.2105255,         -10.
    286,          20.,          35.,         -10.
    287,          20.,   35.7894745,         -10.
    288,          20.,    36.578949,         -10.
    289,          20.,   37.3684196,         -10.
    290,          20.,   38.1578941,         -10.
    291,          20.,   38.9473686,         -10.
    292,          20.,   39.7368431,         -10.
    293,          20.,   40.5263176,         -10.
    294,          20.,   41.3157883,         -10.
    295,          20.,   42.1052628,         -10.
    296,          20.,   42.8947372,         -10.
    297,          20.,   43.6842117,         -10.
    298,          20.,   44.4736824,         -10.
    299,          20.,   45.2631569,         -10.
    300,          20.,   46.0526314,         -10.
    301,          20.,   46.8421059,         -10.
    302,          20.,   47.6315804,         -10.
    303,          20.,    48.421051,         -10.
    304,          20.,   49.2105255,         -10.
    305,          20.,          50., -0.909090936
    306,          20.,          50.,  -1.81818187
    307,          20.,          50.,  -2.72727275
    308,          20.,          50.,  -3.63636374
    309,          20.,          50.,   -4.5454545
    310,          20.,          50.,   -5.4545455
    311,          20.,          50.,  -6.36363649
    312,          20.,          50.,  -7.27272749
    313,          20.,          50.,  -8.18181801
    314,          20.,          50.,    -9.090909
    315,          20.,          20.,    -9.090909
    316,          20.,          20.,  -8.18181801
    317,          20.,          20.,  -7.27272749
    318,          20.,          20.,  -6.36363649
    319,          20.,          20.,   -5.4545455
    320,          20.,          20.,   -4.5454545
    321,          20.,          20.,  -3.63636374
    322,          20.,          20.,  -2.72727275
    323,          20.,          20.,  -1.81818187
    324,          20.,          20., -0.909090936
    325,          30.,          50.,    -9.090909
    326,          30.,          50.,  -8.18181801
    327,          30.,          50.,  -7.27272749
    328,          30.,          50.,  -6.36363649
    329,          30.,          50.,   -5.4545455
    330,          30.,          50.,   -4.5454545
    331,          30.,          50.,  -3.63636374
    332,          30.,          50.,  -2.72727275
    333,          30.,          50.,  -1.81818187
    334,          30.,          50., -0.909090936
    335,          30.,          20., -0.909090936
    336,          30.,          20.,  -1.81818187
    337,          30.,          20.,  -2.72727275
    338,          30.,          20.,  -3.63636374
    339,          30.,          20.,   -4.5454545
    340,          30.,          20.,   -5.4545455
    341,          30.,          20.,  -6.36363649
    342,          30.,          20.,  -7.27272749
    343,          30.,          20.,  -8.18181801
    344,          30.,          20.,    -9.090909
    345,    -20.90909,          20.,         -10.
    346,   -21.818182,          20.,         -10.
    347,   -22.727272,          20.,         -10.
    348,   -23.636364,          20.,         -10.
    349,   -24.545454,          20.,         -10.
    350,   -25.454546,          20.,         -10.
    351,   -26.363636,          20.,         -10.
    352,   -27.272728,          20.,         -10.
    353,   -28.181818,          20.,         -10.
    354,    -29.09091,          20.,         -10.
    355,         -30.,          20.,    -9.090909
    356,         -30.,          20.,  -8.18181801
    357,         -30.,          20.,  -7.27272749
    358,         -30.,          20.,  -6.36363649
    359,         -30.,          20.,   -5.4545455
    360,         -30.,          20.,   -4.5454545
    361,         -30.,          20.,  -3.63636374
    362,         -30.,          20.,  -2.72727275
    363,         -30.,          20.,  -1.81818187
    364,         -30.,          20., -0.909090936
    365,    -29.09091,          20.,           0.
    366,   -28.181818,          20.,           0.
    367,   -27.272728,          20.,           0.
    368,   -26.363636,          20.,           0.
    369,   -25.454546,          20.,           0.
    370,   -24.545454,          20.,           0.
    371,   -23.636364,          20.,           0.
    372,   -22.727272,          20.,           0.
    373,   -21.818182,          20.,           0.
    374,    -20.90909,          20.,           0.
    375,         -20.,          20., -0.909090936
    376,         -20.,          20.,  -1.81818187
    377,         -20.,          20.,  -2.72727275
    378,         -20.,          20.,  -3.63636374
    379,         -20.,          20.,   -4.5454545
    380,         -20.,          20.,   -5.4545455
    381,         -20.,          20.,  -6.36363649
    382,         -20.,          20.,  -7.27272749
    383,         -20.,          20.,  -8.18181801
    384,         -20.,          20.,    -9.090909
    385,    -20.90909,          50.,         -10.
    386,   -21.818182,          50.,         -10.
    387,   -22.727272,          50.,         -10.
    388,   -23.636364,          50.,         -10.
    389,   -24.545454,          50.,         -10.
    390,   -25.454546,          50.,         -10.
    391,   -26.363636,          50.,         -10.
    392,   -27.272728,          50.,         -10.
    393,   -28.181818,          50.,         -10.
    394,    -29.09091,          50.,         -10.
    395,         -30.,          50.,    -9.090909
    396,         -30.,          50.,  -8.18181801
    397,         -30.,          50.,  -7.27272749
    398,         -30.,          50.,  -6.36363649
    399,         -30.,          50.,   -5.4545455
    400,         -30.,          50.,   -4.5454545
    401,         -30.,          50.,  -3.63636374
    402,         -30.,          50.,  -2.72727275
    403,         -30.,          50.,  -1.81818187
    404,         -30.,          50., -0.909090936
    405,    -29.09091,          50.,           0.
    406,   -28.181818,          50.,           0.
    407,   -27.272728,          50.,           0.
    408,   -26.363636,          50.,           0.
    409,   -25.454546,          50.,           0.
    410,   -24.545454,          50.,           0.
    411,   -23.636364,          50.,           0.
    412,   -22.727272,          50.,           0.
    413,   -21.818182,          50.,           0.
    414,    -20.90909,          50.,           0.
    415,         -20.,          50., -0.909090936
    416,         -20.,          50.,  -1.81818187
    417,         -20.,          50.,  -2.72727275
    418,         -20.,          50.,  -3.63636374
    419,         -20.,          50.,   -4.5454545
    420,         -20.,          50.,   -5.4545455
    421,         -20.,          50.,  -6.36363649
    422,         -20.,          50.,  -7.27272749
    423,         -20.,          50.,  -8.18181801
    424,         -20.,          50.,    -9.090909
    425,         -20.,   24.2857151,           0.
    426,         -20.,   23.5714283,           0.
    427,         -20.,   22.8571434,           0.
    428,         -20.,   22.1428566,           0.
    429,         -20.,   21.4285717,           0.
    430,         -20.,   20.7142849,           0.
    431,         -20.,   44.2000008,           0.
    432,         -20.,   43.4000015,           0.
    433,         -20.,   42.5999985,           0.
    434,         -20.,   41.7999992,           0.
    435,         -20.,          41.,           0.
    436,         -20.,   40.2000008,           0.
    437,         -20.,   39.4000015,           0.
    438,         -20.,   38.5999985,           0.
    439,         -20.,   37.7999992,           0.
    440,         -20.,          37.,           0.
    441,         -20.,   36.2000008,           0.
    442,         -20.,   35.4000015,           0.
    443,         -20.,   34.5999985,           0.
    444,         -20.,   33.7999992,           0.
    445,         -20.,          33.,           0.
    446,         -20.,   32.2000008,           0.
    447,         -20.,   31.3999996,           0.
    448,         -20.,   30.6000004,           0.
    449,         -20.,   29.7999992,           0.
    450,         -20.,          29.,           0.
    451,         -20.,   28.2000008,           0.
    452,         -20.,   27.3999996,           0.
    453,         -20.,   26.6000004,           0.
    454,         -20.,   25.7999992,           0.
    455,         -20.,   49.1666679,           0.
    456,         -20.,   48.3333321,           0.
    457,         -20.,         47.5,           0.
    458,         -20.,   46.6666679,           0.
    459,         -20.,   45.8333321,           0.
    460,         -20.,   20.7894745,         -10.
    461,         -20.,   21.5789471,         -10.
    462,         -20.,   22.3684216,         -10.
    463,         -20.,   23.1578941,         -10.
    464,         -20.,   23.9473686,         -10.
    465,         -20.,   24.7368412,         -10.
    466,         -20.,   25.5263157,         -10.
    467,         -20.,   26.3157902,         -10.
    468,         -20.,   27.1052628,         -10.
    469,         -20.,   27.8947372,         -10.
    470,         -20.,   28.6842098,         -10.
    471,         -20.,   29.4736843,         -10.
    472,         -20.,   30.2631588,         -10.
    473,         -20.,   31.0526314,         -10.
    474,         -20.,   31.8421059,         -10.
    475,         -20.,   32.6315804,         -10.
    476,         -20.,    33.421051,         -10.
    477,         -20.,   34.2105255,         -10.
    478,         -20.,          35.,         -10.
    479,         -20.,   35.7894745,         -10.
    480,         -20.,    36.578949,         -10.
    481,         -20.,   37.3684196,         -10.
    482,         -20.,   38.1578941,         -10.
    483,         -20.,   38.9473686,         -10.
    484,         -20.,   39.7368431,         -10.
    485,         -20.,   40.5263176,         -10.
    486,         -20.,   41.3157883,         -10.
    487,         -20.,   42.1052628,         -10.
    488,         -20.,   42.8947372,         -10.
    489,         -20.,   43.6842117,         -10.
    490,         -20.,   44.4736824,         -10.
    491,         -20.,   45.2631569,         -10.
    492,         -20.,   46.0526314,         -10.
    493,         -20.,   46.8421059,         -10.
    494,         -20.,   47.6315804,         -10.
    495,         -20.,    48.421051,         -10.
    496,         -20.,   49.2105255,         -10.
    497,         -30.,   20.7142849,           0.
    498,         -30.,   21.4285717,           0.
    499,         -30.,   22.1428566,           0.
    500,         -30.,   22.8571434,           0.
    501,         -30.,   23.5714283,           0.
    502,         -30.,   24.2857151,           0.
    503,         -30.,   25.7999992,           0.
    504,         -30.,   26.6000004,           0.
    505,         -30.,   27.3999996,           0.
    506,         -30.,   28.2000008,           0.
    507,         -30.,          29.,           0.
    508,         -30.,   29.7999992,           0.
    509,         -30.,   30.6000004,           0.
    510,         -30.,   31.3999996,           0.
    511,         -30.,   32.2000008,           0.
    512,         -30.,          33.,           0.
    513,         -30.,   33.7999992,           0.
    514,         -30.,   34.5999985,           0.
    515,         -30.,   35.4000015,           0.
    516,         -30.,   36.2000008,           0.
    517,         -30.,          37.,           0.
    518,         -30.,   37.7999992,           0.
    519,         -30.,   38.5999985,           0.
    520,         -30.,   39.4000015,           0.
    521,         -30.,   40.2000008,           0.
    522,         -30.,          41.,           0.
    523,         -30.,   41.7999992,           0.
    524,         -30.,   42.5999985,           0.
    525,         -30.,   43.4000015,           0.
    526,         -30.,   44.2000008,           0.
    527,         -30.,   45.8333321,           0.
    528,         -30.,   46.6666679,           0.
    529,         -30.,         47.5,           0.
    530,         -30.,   48.3333321,           0.
    531,         -30.,   49.1666679,           0.
    532,         -30.,   49.2105255,         -10.
    533,         -30.,    48.421051,         -10.
    534,         -30.,   47.6315804,         -10.
    535,         -30.,   46.8421059,         -10.
    536,         -30.,   46.0526314,         -10.
    537,         -30.,   45.2631569,         -10.
    538,         -30.,   44.4736824,         -10.
    539,         -30.,   43.6842117,         -10.
    540,         -30.,   42.8947372,         -10.
    541,         -30.,   42.1052628,         -10.
    542,         -30.,   41.3157883,         -10.
    543,         -30.,   40.5263176,         -10.
    544,         -30.,   39.7368431,         -10.
    545,         -30.,   38.9473686,         -10.
    546,         -30.,   38.1578941,         -10.
    547,         -30.,   37.3684196,         -10.
    548,         -30.,    36.578949,         -10.
    549,         -30.,   35.7894745,         -10.
    550,         -30.,          35.,         -10.
    551,         -30.,   34.2105255,         -10.
    552,         -30.,    33.421051,         -10.
    553,         -30.,   32.6315804,         -10.
    554,         -30.,   31.8421059,         -10.
    555,         -30.,   31.0526314,         -10.
    556,         -30.,   30.2631588,         -10.
    557,         -30.,   29.4736843,         -10.
    558,         -30.,   28.6842098,         -10.
    559,         -30.,   27.8947372,         -10.
    560,         -30.,   27.1052628,         -10.
    561,         -30.,   26.3157902,         -10.
    562,         -30.,   25.5263157,         -10.
    563,         -30.,   24.7368412,         -10.
    564,         -30.,   23.9473686,         -10.
    565,         -30.,   23.1578941,         -10.
    566,         -30.,   22.3684216,         -10.
    567,         -30.,   21.5789471,         -10.
    568,         -30.,   20.7894745,         -10.
    569,  -20.8571434,          25.,           0.
    570,  -21.7142849,          25.,           0.
    571,  -22.5714283,          25.,           0.
    572,  -23.4285717,          25.,           0.
    573,  -24.2857151,          25.,           0.
    574,  -25.1428566,          25.,           0.
    575,         -27.,          25.,           0.
    576,         -28.,          25.,           0.
    577,         -29.,          25.,           0.
    578,         -26.,   44.2000008,           0.
    579,         -26.,   43.4000015,           0.
    580,         -26.,   42.5999985,           0.
    581,         -26.,   41.7999992,           0.
    582,         -26.,          41.,           0.
    583,         -26.,   40.2000008,           0.
    584,         -26.,   39.4000015,           0.
    585,         -26.,   38.5999985,           0.
    586,         -26.,   37.7999992,           0.
    587,         -26.,          37.,           0.
    588,         -26.,   36.2000008,           0.
    589,         -26.,   35.4000015,           0.
    590,         -26.,   34.5999985,           0.
    591,         -26.,   33.7999992,           0.
    592,         -26.,          33.,           0.
    593,         -26.,   32.2000008,           0.
    594,         -26.,   31.3999996,           0.
    595,         -26.,   30.6000004,           0.
    596,         -26.,   29.7999992,           0.
    597,         -26.,          29.,           0.
    598,         -26.,   28.2000008,           0.
    599,         -26.,   27.3999996,           0.
    600,         -26.,   26.6000004,           0.
    601,         -26.,   25.7999992,           0.
    602,  -20.8571434,          45.,           0.
    603,  -21.7142849,          45.,           0.
    604,  -22.5714283,          45.,           0.
    605,  -23.4285717,          45.,           0.
    606,  -24.2857151,          45.,           0.
    607,  -25.1428566,          45.,           0.
    608,         -27.,          45.,           0.
    609,         -28.,          45.,           0.
    610,         -29.,          45.,           0.
    611,  -19.9897251,   50.6410332,         -10.
    612,  -19.9589081,   51.2814026,         -10.
    613,  -19.9075813,   51.9204597,         -10.
    614,  -19.8358002,   52.5575447,         -10.
    615,  -19.7436352,   53.1919975,         -10.
    616,  -19.6311836,   53.8231735,         -10.
    617,   -19.498558,   54.4504204,         -10.
    618,  -19.3458977,   55.0730934,         -10.
    619,   -19.173357,   55.6905518,         -10.
    620,  -18.9811153,    56.302166,         -10.
    621,  -18.7693691,   56.9073029,         -10.
    622,  -18.5383358,   57.5053406,         -10.
    623,  -18.2882519,    58.095665,         -10.
    624,  -18.0193768,   58.6776733,         -10.
    625,   -17.731987,   59.2507668,         -10.
    626,  -17.4263744,   59.8143501,         -10.
    627,  -17.1028557,   60.3678513,         -10.
    628,  -16.7617626,   60.9106979,         -10.
    629,  -16.4034443,   61.4423332,         -10.
    630,  -16.0282726,   61.9622116,         -10.
    631,  -15.6366301,   62.4697952,         -10.
    632,   -15.228919,   62.9645691,         -10.
    633,  -14.8055601,   63.4460182,         -10.
    634,  -14.3669872,   63.9136505,         -10.
    635,  -13.9136515,   64.3669891,         -10.
    636,  -13.4460182,   64.8055573,         -10.
    637,  -12.9645681,     65.22892,         -10.
    638,  -12.4697962,   65.6366272,         -10.
    639,  -11.9622107,   66.0282745,         -10.
    640,  -11.4423332,   66.4034424,         -10.
    641,  -10.9106979,   66.7617645,         -10.
    642,  -10.3678513,   67.1028519,         -10.
    643,  -9.81435108,   67.4263763,         -10.
    644,   -9.2507658,    67.731987,         -10.
    645,  -8.67767525,   68.0193787,         -10.
    646,  -8.09566689,   68.2882538,         -10.
    647,   -7.5053401,   68.5383377,         -10.
    648,  -6.90730095,    68.769371,         -10.
    649,  -6.30216455,   68.9811172,         -10.
    650,  -5.69055176,   69.1733551,         -10.
    651,  -5.07309151,   69.3458939,         -10.
    652,  -4.45041847,    69.498558,         -10.
    653,  -3.82317257,   69.6311798,         -10.
    654,    -3.191998,   69.7436371,         -10.
    655,  -2.55754328,   69.8358002,         -10.
    656,  -1.92046046,   69.9075851,         -10.
    657,  -1.28140438,   69.9589081,         -10.
    658, -0.641031563,   69.9897232,         -10.
    659,           0.,          70.,         -10.
    660,  0.641031563,   69.9897232,         -10.
    661,   1.28140438,   69.9589081,         -10.
    662,   1.92046046,   69.9075851,         -10.
    663,   2.55754328,   69.8358002,         -10.
    664,     3.191998,   69.7436371,         -10.
    665,   3.82317257,   69.6311798,         -10.
    666,   4.45041847,    69.498558,         -10.
    667,   5.07309151,   69.3458939,         -10.
    668,   5.69055176,   69.1733551,         -10.
    669,   6.30216455,   68.9811172,         -10.
    670,   6.90730095,    68.769371,         -10.
    671,    7.5053401,   68.5383377,         -10.
    672,   8.09566689,   68.2882538,         -10.
    673,   8.67767525,   68.0193787,         -10.
    674,    9.2507658,    67.731987,         -10.
    675,   9.81435108,   67.4263763,         -10.
    676,   10.3678513,   67.1028519,         -10.
    677,   10.9106979,   66.7617645,         -10.
    678,   11.4423332,   66.4034424,         -10.
    679,   11.9622107,   66.0282745,         -10.
    680,   12.4697962,   65.6366272,         -10.
    681,   12.9645681,     65.22892,         -10.
    682,   13.4460182,   64.8055573,         -10.
    683,   13.9136515,   64.3669891,         -10.
    684,   14.3669872,   63.9136505,         -10.
    685,   14.8055601,   63.4460182,         -10.
    686,    15.228919,   62.9645691,         -10.
    687,   15.6366301,   62.4697952,         -10.
    688,   16.0282726,   61.9622116,         -10.
    689,   16.4034443,   61.4423332,         -10.
    690,   16.7617626,   60.9106979,         -10.
    691,   17.1028557,   60.3678513,         -10.
    692,   17.4263744,   59.8143501,         -10.
    693,    17.731987,   59.2507668,         -10.
    694,   18.0193768,   58.6776733,         -10.
    695,   18.2882519,    58.095665,         -10.
    696,   18.5383358,   57.5053406,         -10.
    697,   18.7693691,   56.9073029,         -10.
    698,   18.9811153,    56.302166,         -10.
    699,    19.173357,   55.6905518,         -10.
    700,   19.3458977,   55.0730934,         -10.
    701,    19.498558,   54.4504204,         -10.
    702,   19.6311836,   53.8231735,         -10.
    703,   19.7436352,   53.1919975,         -10.
    704,   19.8358002,   52.5575447,         -10.
    705,   19.9075813,   51.9204597,         -10.
    706,   19.9589081,   51.2814026,         -10.
    707,   19.9897251,   50.6410332,         -10.
    708,   19.9897251,   50.6410332,           0.
    709,   19.9589081,   51.2814026,           0.
    710,   19.9075813,   51.9204597,           0.
    711,   19.8358002,   52.5575447,           0.
    712,   19.7436352,   53.1919975,           0.
    713,   19.6311836,   53.8231735,           0.
    714,    19.498558,   54.4504204,           0.
    715,   19.3458977,   55.0730934,           0.
    716,    19.173357,   55.6905518,           0.
    717,   18.9811153,    56.302166,           0.
    718,   18.7693691,   56.9073029,           0.
    719,   18.5383358,   57.5053406,           0.
    720,   18.2882519,    58.095665,           0.
    721,   18.0193768,   58.6776733,           0.
    722,    17.731987,   59.2507668,           0.
    723,   17.4263744,   59.8143501,           0.
    724,   17.1028557,   60.3678513,           0.
    725,   16.7617626,   60.9106979,           0.
    726,   16.4034443,   61.4423332,           0.
    727,   16.0282726,   61.9622116,           0.
    728,   15.6366301,   62.4697952,           0.
    729,    15.228919,   62.9645691,           0.
    730,   14.8055601,   63.4460182,           0.
    731,   14.3669872,   63.9136505,           0.
    732,   13.9136515,   64.3669891,           0.
    733,   13.4460182,   64.8055573,           0.
    734,   12.9645681,     65.22892,           0.
    735,   12.4697962,   65.6366272,           0.
    736,   11.9622107,   66.0282745,           0.
    737,   11.4423332,   66.4034424,           0.
    738,   10.9106979,   66.7617645,           0.
    739,   10.3678513,   67.1028519,           0.
    740,   9.81435108,   67.4263763,           0.
    741,    9.2507658,    67.731987,           0.
    742,   8.67767525,   68.0193787,           0.
    743,   8.09566689,   68.2882538,           0.
    744,    7.5053401,   68.5383377,           0.
    745,   6.90730095,    68.769371,           0.
    746,   6.30216455,   68.9811172,           0.
    747,   5.69055176,   69.1733551,           0.
    748,   5.07309151,   69.3458939,           0.
    749,   4.45041847,    69.498558,           0.
    750,   3.82317257,   69.6311798,           0.
    751,     3.191998,   69.7436371,           0.
    752,   2.55754328,   69.8358002,           0.
    753,   1.92046046,   69.9075851,           0.
    754,   1.28140438,   69.9589081,           0.
    755,  0.641031563,   69.9897232,           0.
    756, -0.641031563,   69.9897232,           0.
    757,  -1.28140438,   69.9589081,           0.
    758,  -1.92046046,   69.9075851,           0.
    759,  -2.55754328,   69.8358002,           0.
    760,    -3.191998,   69.7436371,           0.
    761,  -3.82317257,   69.6311798,           0.
    762,  -4.45041847,    69.498558,           0.
    763,  -5.07309151,   69.3458939,           0.
    764,  -5.69055176,   69.1733551,           0.
    765,  -6.30216455,   68.9811172,           0.
    766,  -6.90730095,    68.769371,           0.
    767,   -7.5053401,   68.5383377,           0.
    768,  -8.09566689,   68.2882538,           0.
    769,  -8.67767525,   68.0193787,           0.
    770,   -9.2507658,    67.731987,           0.
    771,  -9.81435108,   67.4263763,           0.
    772,  -10.3678513,   67.1028519,           0.
    773,  -10.9106979,   66.7617645,           0.
    774,  -11.4423332,   66.4034424,           0.
    775,  -11.9622107,   66.0282745,           0.
    776,  -12.4697962,   65.6366272,           0.
    777,  -12.9645681,     65.22892,           0.
    778,  -13.4460182,   64.8055573,           0.
    779,  -13.9136515,   64.3669891,           0.
    780,  -14.3669872,   63.9136505,           0.
    781,  -14.8055601,   63.4460182,           0.
    782,   -15.228919,   62.9645691,           0.
    783,  -15.6366301,   62.4697952,           0.
    784,  -16.0282726,   61.9622116,           0.
    785,  -16.4034443,   61.4423332,           0.
    786,  -16.7617626,   60.9106979,           0.
    787,  -17.1028557,   60.3678513,           0.
    788,  -17.4263744,   59.8143501,           0.
    789,   -17.731987,   59.2507668,           0.
    790,  -18.0193768,   58.6776733,           0.
    791,  -18.2882519,    58.095665,           0.
    792,  -18.5383358,   57.5053406,           0.
    793,  -18.7693691,   56.9073029,           0.
    794,  -18.9811153,    56.302166,           0.
    795,   -19.173357,   55.6905518,           0.
    796,  -19.3458977,   55.0730934,           0.
    797,   -19.498558,   54.4504204,           0.
    798,  -19.6311836,   53.8231735,           0.
    799,  -19.7436352,   53.1919975,           0.
    800,  -19.8358002,   52.5575447,           0.
    801,  -19.9075813,   51.9204597,           0.
    802,  -19.9589081,   51.2814026,           0.
    803,  -19.9897251,   50.6410332,           0.
    804,   29.9845867,   50.9615479,         -10.
    805,   29.9383621,   51.9221077,         -10.
    806,   29.8613739,   52.8806915,         -10.
    807,   29.7537003,   53.8363152,         -10.
    808,   29.6154537,   54.7879982,         -10.
    809,   29.4467754,   55.7347603,         -10.
    810,   29.2478371,   56.6756287,         -10.
    811,   29.0188465,   57.6096382,         -10.
    812,   28.7600365,   58.5358276,         -10.
    813,   28.4716721,   59.4532471,         -10.
    814,   28.1540527,   60.3609505,         -10.
    815,   27.8075027,   61.2580109,         -10.
    816,   27.4323788,   62.1435013,         -10.
    817,   27.0290661,   63.0165138,         -10.
    818,   26.5979786,   63.8761482,         -10.
    819,   26.1395607,   64.7215271,         -10.
    820,   25.6542835,   65.5517807,         -10.
    821,    25.142643,   66.3660507,         -10.
    822,   24.6051674,   67.1634979,         -10.
    823,    24.042408,   67.9433136,         -10.
    824,   23.4549446,   68.7046967,         -10.
    825,   22.8433781,   69.4468536,         -10.
    826,   22.2083397,   70.1690292,         -10.
    827,   21.5504799,   70.8704758,         -10.
    828,   20.8704758,   71.5504837,         -10.
    829,   20.1690273,   72.2083435,         -10.
    830,   19.4468517,   72.8433762,         -10.
    831,   18.7046947,   73.4549408,         -10.
    832,   17.9433155,   74.0424118,         -10.
    833,   17.1634998,   74.6051712,         -10.
    834,   16.3660469,   75.1426468,         -10.
    835,   15.5517769,   75.6542816,         -10.
    836,   14.7215261,   76.1395645,         -10.
    837,   13.8761492,   76.5979767,         -10.
    838,   13.0165119,    77.029068,         -10.
    839,   12.1435003,   77.4323807,         -10.
    840,   11.2580099,   77.8075027,         -10.
    841,   10.3609514,   78.1540527,         -10.
    842,   9.45324612,   78.4716721,         -10.
    843,   8.53582764,   78.7600327,         -10.
    844,   7.60963774,   79.0188446,         -10.
    845,   6.67562819,   79.2478409,         -10.
    846,   5.73475885,   79.4467773,         -10.
    847,   4.78799677,   79.6154556,         -10.
    848,   3.83631492,   79.7537003,         -10.
    849,   2.88069081,   79.8613739,         -10.
    850,   1.92210662,   79.9383621,         -10.
    851,  0.961547315,   79.9845886,         -10.
    852,           0.,          80.,         -10.
    853, -0.961547315,   79.9845886,         -10.
    854,  -1.92210662,   79.9383621,         -10.
    855,  -2.88069081,   79.8613739,         -10.
    856,  -3.83631492,   79.7537003,         -10.
    857,  -4.78799677,   79.6154556,         -10.
    858,  -5.73475885,   79.4467773,         -10.
    859,  -6.67562819,   79.2478409,         -10.
    860,  -7.60963774,   79.0188446,         -10.
    861,  -8.53582764,   78.7600327,         -10.
    862,  -9.45324612,   78.4716721,         -10.
    863,  -10.3609514,   78.1540527,         -10.
    864,  -11.2580099,   77.8075027,         -10.
    865,  -12.1435003,   77.4323807,         -10.
    866,  -13.0165119,    77.029068,         -10.
    867,  -13.8761492,   76.5979767,         -10.
    868,  -14.7215261,   76.1395645,         -10.
    869,  -15.5517769,   75.6542816,         -10.
    870,  -16.3660469,   75.1426468,         -10.
    871,  -17.1634998,   74.6051712,         -10.
    872,  -17.9433155,   74.0424118,         -10.
    873,  -18.7046947,   73.4549408,         -10.
    874,  -19.4468517,   72.8433762,         -10.
    875,  -20.1690273,   72.2083435,         -10.
    876,  -20.8704758,   71.5504837,         -10.
    877,  -21.5504799,   70.8704758,         -10.
    878,  -22.2083397,   70.1690292,         -10.
    879,  -22.8433781,   69.4468536,         -10.
    880,  -23.4549446,   68.7046967,         -10.
    881,   -24.042408,   67.9433136,         -10.
    882,  -24.6051674,   67.1634979,         -10.
    883,   -25.142643,   66.3660507,         -10.
    884,  -25.6542835,   65.5517807,         -10.
    885,  -26.1395607,   64.7215271,         -10.
    886,  -26.5979786,   63.8761482,         -10.
    887,  -27.0290661,   63.0165138,         -10.
    888,  -27.4323788,   62.1435013,         -10.
    889,  -27.8075027,   61.2580109,         -10.
    890,  -28.1540527,   60.3609505,         -10.
    891,  -28.4716721,   59.4532471,         -10.
    892,  -28.7600365,   58.5358276,         -10.
    893,  -29.0188465,   57.6096382,         -10.
    894,  -29.2478371,   56.6756287,         -10.
    895,  -29.4467754,   55.7347603,         -10.
    896,  -29.6154537,   54.7879982,         -10.
    897,  -29.7537003,   53.8363152,         -10.
    898,  -29.8613739,   52.8806915,         -10.
    899,  -29.9383621,   51.9221077,         -10.
    900,  -29.9845867,   50.9615479,         -10.
    901,  0.961547315,   79.9845886,           0.
    902,   1.92210662,   79.9383621,           0.
    903,   2.88069081,   79.8613739,           0.
    904,   3.83631492,   79.7537003,           0.
    905,   4.78799677,   79.6154556,           0.
    906,   5.73475885,   79.4467773,           0.
    907,   6.67562819,   79.2478409,           0.
    908,   7.60963774,   79.0188446,           0.
    909,   8.53582764,   78.7600327,           0.
    910,   9.45324612,   78.4716721,           0.
    911,   10.3609514,   78.1540527,           0.
    912,   11.2580099,   77.8075027,           0.
    913,   12.1435003,   77.4323807,           0.
    914,   13.0165119,    77.029068,           0.
    915,   13.8761492,   76.5979767,           0.
    916,   14.7215261,   76.1395645,           0.
    917,   15.5517769,   75.6542816,           0.
    918,   16.3660469,   75.1426468,           0.
    919,   17.1634998,   74.6051712,           0.
    920,   17.9433155,   74.0424118,           0.
    921,   18.7046947,   73.4549408,           0.
    922,   19.4468517,   72.8433762,           0.
    923,   20.1690273,   72.2083435,           0.
    924,   20.8704758,   71.5504837,           0.
    925,   21.5504799,   70.8704758,           0.
    926,   22.2083397,   70.1690292,           0.
    927,   22.8433781,   69.4468536,           0.
    928,   23.4549446,   68.7046967,           0.
    929,    24.042408,   67.9433136,           0.
    930,   24.6051674,   67.1634979,           0.
    931,    25.142643,   66.3660507,           0.
    932,   25.6542835,   65.5517807,           0.
    933,   26.1395607,   64.7215271,           0.
    934,   26.5979786,   63.8761482,           0.
    935,   27.0290661,   63.0165138,           0.
    936,   27.4323788,   62.1435013,           0.
    937,   27.8075027,   61.2580109,           0.
    938,   28.1540527,   60.3609505,           0.
    939,   28.4716721,   59.4532471,           0.
    940,   28.7600365,   58.5358276,           0.
    941,   29.0188465,   57.6096382,           0.
    942,   29.2478371,   56.6756287,           0.
    943,   29.4467754,   55.7347603,           0.
    944,   29.6154537,   54.7879982,           0.
    945,   29.7537003,   53.8363152,           0.
    946,   29.8613739,   52.8806915,           0.
    947,   29.9383621,   51.9221077,           0.
    948,   29.9845867,   50.9615479,           0.
    949,  -29.9845867,   50.9615479,           0.
    950,  -29.9383621,   51.9221077,           0.
    951,  -29.8613739,   52.8806915,           0.
    952,  -29.7537003,   53.8363152,           0.
    953,  -29.6154537,   54.7879982,           0.
    954,  -29.4467754,   55.7347603,           0.
    955,  -29.2478371,   56.6756287,           0.
    956,  -29.0188465,   57.6096382,           0.
    957,  -28.7600365,   58.5358276,           0.
    958,  -28.4716721,   59.4532471,           0.
    959,  -28.1540527,   60.3609505,           0.
    960,  -27.8075027,   61.2580109,           0.
    961,  -27.4323788,   62.1435013,           0.
    962,  -27.0290661,   63.0165138,           0.
    963,  -26.5979786,   63.8761482,           0.
    964,  -26.1395607,   64.7215271,           0.
    965,  -25.6542835,   65.5517807,           0.
    966,   -25.142643,   66.3660507,           0.
    967,  -24.6051674,   67.1634979,           0.
    968,   -24.042408,   67.9433136,           0.
    969,  -23.4549446,   68.7046967,           0.
    970,  -22.8433781,   69.4468536,           0.
    971,  -22.2083397,   70.1690292,           0.
    972,  -21.5504799,   70.8704758,           0.
    973,  -20.8704758,   71.5504837,           0.
    974,  -20.1690273,   72.2083435,           0.
    975,  -19.4468517,   72.8433762,           0.
    976,  -18.7046947,   73.4549408,           0.
    977,  -17.9433155,   74.0424118,           0.
    978,  -17.1634998,   74.6051712,           0.
    979,  -16.3660469,   75.1426468,           0.
    980,  -15.5517769,   75.6542816,           0.
    981,  -14.7215261,   76.1395645,           0.
    982,  -13.8761492,   76.5979767,           0.
    983,  -13.0165119,    77.029068,           0.
    984,  -12.1435003,   77.4323807,           0.
    985,  -11.2580099,   77.8075027,           0.
    986,  -10.3609514,   78.1540527,           0.
    987,  -9.45324612,   78.4716721,           0.
    988,  -8.53582764,   78.7600327,           0.
    989,  -7.60963774,   79.0188446,           0.
    990,  -6.67562819,   79.2478409,           0.
    991,  -5.73475885,   79.4467773,           0.
    992,  -4.78799677,   79.6154556,           0.
    993,  -3.83631492,   79.7537003,           0.
    994,  -2.88069081,   79.8613739,           0.
    995,  -1.92210662,   79.9383621,           0.
    996, -0.961547315,   79.9845886,           0.
    997,           0.,   79.0909119,           0.
    998,           0.,   78.1818161,           0.
    999,           0.,    77.272728,           0.
   1000,           0.,   76.3636398,           0.
   1001,           0.,   75.4545441,           0.
   1002,           0.,   74.5454559,           0.
   1003,           0.,   73.6363602,           0.
   1004,           0.,    72.727272,           0.
   1005,           0.,   71.8181839,           0.
   1006,           0.,   70.9090881,           0.
   1007,         -30.,          50.,  0.909090936
   1008,         -30.,          50.,   1.81818187
   1009,         -30.,          50.,   2.72727275
   1010,         -30.,          50.,   3.63636374
   1011,         -30.,          50.,    4.5454545
   1012,         -30.,          50.,    5.4545455
   1013,         -30.,          50.,   6.36363649
   1014,         -30.,          50.,   7.27272749
   1015,         -30.,          50.,   8.18181801
   1016,         -30.,          50.,     9.090909
   1017,  -29.9845867,   50.9615479,          10.
   1018,  -29.9383621,   51.9221077,          10.
   1019,  -29.8613739,   52.8806915,          10.
   1020,  -29.7537003,   53.8363152,          10.
   1021,  -29.6154537,   54.7879982,          10.
   1022,  -29.4467754,   55.7347603,          10.
   1023,  -29.2478371,   56.6756287,          10.
   1024,  -29.0188465,   57.6096382,          10.
   1025,  -28.7600365,   58.5358276,          10.
   1026,  -28.4716721,   59.4532471,          10.
   1027,  -28.1540527,   60.3609505,          10.
   1028,  -27.8075027,   61.2580109,          10.
   1029,  -27.4323788,   62.1435013,          10.
   1030,  -27.0290661,   63.0165138,          10.
   1031,  -26.5979786,   63.8761482,          10.
   1032,  -26.1395607,   64.7215271,          10.
   1033,  -25.6542835,   65.5517807,          10.
   1034,   -25.142643,   66.3660507,          10.
   1035,  -24.6051674,   67.1634979,          10.
   1036,   -24.042408,   67.9433136,          10.
   1037,  -23.4549446,   68.7046967,          10.
   1038,  -22.8433781,   69.4468536,          10.
   1039,  -22.2083397,   70.1690292,          10.
   1040,  -21.5504799,   70.8704758,          10.
   1041,  -20.8704758,   71.5504837,          10.
   1042,  -20.1690273,   72.2083435,          10.
   1043,  -19.4468517,   72.8433762,          10.
   1044,  -18.7046947,   73.4549408,          10.
   1045,  -17.9433155,   74.0424118,          10.
   1046,  -17.1634998,   74.6051712,          10.
   1047,  -16.3660469,   75.1426468,          10.
   1048,  -15.5517769,   75.6542816,          10.
   1049,  -14.7215261,   76.1395645,          10.
   1050,  -13.8761492,   76.5979767,          10.
   1051,  -13.0165119,    77.029068,          10.
   1052,  -12.1435003,   77.4323807,          10.
   1053,  -11.2580099,   77.8075027,          10.
   1054,  -10.3609514,   78.1540527,          10.
   1055,  -9.45324612,   78.4716721,          10.
   1056,  -8.53582764,   78.7600327,          10.
   1057,  -7.60963774,   79.0188446,          10.
   1058,  -6.67562819,   79.2478409,          10.
   1059,  -5.73475885,   79.4467773,          10.
   1060,  -4.78799677,   79.6154556,          10.
   1061,  -3.83631492,   79.7537003,          10.
   1062,  -2.88069081,   79.8613739,          10.
   1063,  -1.92210662,   79.9383621,          10.
   1064, -0.961547315,   79.9845886,          10.
   1065,           0.,          80.,          10.
   1066,  0.961547315,   79.9845886,          10.
   1067,   1.92210662,   79.9383621,          10.
   1068,   2.88069081,   79.8613739,          10.
   1069,   3.83631492,   79.7537003,          10.
   1070,   4.78799677,   79.6154556,          10.
   1071,   5.73475885,   79.4467773,          10.
   1072,   6.67562819,   79.2478409,          10.
   1073,   7.60963774,   79.0188446,          10.
   1074,   8.53582764,   78.7600327,          10.
   1075,   9.45324612,   78.4716721,          10.
   1076,   10.3609514,   78.1540527,          10.
   1077,   11.2580099,   77.8075027,          10.
   1078,   12.1435003,   77.4323807,          10.
   1079,   13.0165119,    77.029068,          10.
   1080,   13.8761492,   76.5979767,          10.
   1081,   14.7215261,   76.1395645,          10.
   1082,   15.5517769,   75.6542816,          10.
   1083,   16.3660469,   75.1426468,          10.
   1084,   17.1634998,   74.6051712,          10.
   1085,   17.9433155,   74.0424118,          10.
   1086,   18.7046947,   73.4549408,          10.
   1087,   19.4468517,   72.8433762,          10.
   1088,   20.1690273,   72.2083435,          10.
   1089,   20.8704758,   71.5504837,          10.
   1090,   21.5504799,   70.8704758,          10.
   1091,   22.2083397,   70.1690292,          10.
   1092,   22.8433781,   69.4468536,          10.
   1093,   23.4549446,   68.7046967,          10.
   1094,    24.042408,   67.9433136,          10.
   1095,   24.6051674,   67.1634979,          10.
   1096,    25.142643,   66.3660507,          10.
   1097,   25.6542835,   65.5517807,          10.
   1098,   26.1395607,   64.7215271,          10.
   1099,   26.5979786,   63.8761482,          10.
   1100,   27.0290661,   63.0165138,          10.
   1101,   27.4323788,   62.1435013,          10.
   1102,   27.8075027,   61.2580109,          10.
   1103,   28.1540527,   60.3609505,          10.
   1104,   28.4716721,   59.4532471,          10.
   1105,   28.7600365,   58.5358276,          10.
   1106,   29.0188465,   57.6096382,          10.
   1107,   29.2478371,   56.6756287,          10.
   1108,   29.4467754,   55.7347603,          10.
   1109,   29.6154537,   54.7879982,          10.
   1110,   29.7537003,   53.8363152,          10.
   1111,   29.8613739,   52.8806915,          10.
   1112,   29.9383621,   51.9221077,          10.
   1113,   29.9845867,   50.9615479,          10.
   1114,          30.,          50.,     9.090909
   1115,          30.,          50.,   8.18181801
   1116,          30.,          50.,   7.27272749
   1117,          30.,          50.,   6.36363649
   1118,          30.,          50.,    5.4545455
   1119,          30.,          50.,    4.5454545
   1120,          30.,          50.,   3.63636374
   1121,          30.,          50.,   2.72727275
   1122,          30.,          50.,   1.81818187
   1123,          30.,          50.,  0.909090936
   1124,         -20.,          50.,     9.090909
   1125,         -20.,          50.,   8.18181801
   1126,         -20.,          50.,   7.27272749
   1127,         -20.,          50.,   6.36363649
   1128,         -20.,          50.,    5.4545455
   1129,         -20.,          50.,    4.5454545
   1130,         -20.,          50.,   3.63636374
   1131,         -20.,          50.,   2.72727275
   1132,         -20.,          50.,   1.81818187
   1133,         -20.,          50.,  0.909090936
   1134,   19.9897251,   50.6410332,          10.
   1135,   19.9589081,   51.2814026,          10.
   1136,   19.9075813,   51.9204597,          10.
   1137,   19.8358002,   52.5575447,          10.
   1138,   19.7436352,   53.1919975,          10.
   1139,   19.6311836,   53.8231735,          10.
   1140,    19.498558,   54.4504204,          10.
   1141,   19.3458977,   55.0730934,          10.
   1142,    19.173357,   55.6905518,          10.
   1143,   18.9811153,    56.302166,          10.
   1144,   18.7693691,   56.9073029,          10.
   1145,   18.5383358,   57.5053406,          10.
   1146,   18.2882519,    58.095665,          10.
   1147,   18.0193768,   58.6776733,          10.
   1148,    17.731987,   59.2507668,          10.
   1149,   17.4263744,   59.8143501,          10.
   1150,   17.1028557,   60.3678513,          10.
   1151,   16.7617626,   60.9106979,          10.
   1152,   16.4034443,   61.4423332,          10.
   1153,   16.0282726,   61.9622116,          10.
   1154,   15.6366301,   62.4697952,          10.
   1155,    15.228919,   62.9645691,          10.
   1156,   14.8055601,   63.4460182,          10.
   1157,   14.3669872,   63.9136505,          10.
   1158,   13.9136515,   64.3669891,          10.
   1159,   13.4460182,   64.8055573,          10.
   1160,   12.9645681,     65.22892,          10.
   1161,   12.4697962,   65.6366272,          10.
   1162,   11.9622107,   66.0282745,          10.
   1163,   11.4423332,   66.4034424,          10.
   1164,   10.9106979,   66.7617645,          10.
   1165,   10.3678513,   67.1028519,          10.
   1166,   9.81435108,   67.4263763,          10.
   1167,    9.2507658,    67.731987,          10.
   1168,   8.67767525,   68.0193787,          10.
   1169,   8.09566689,   68.2882538,          10.
   1170,    7.5053401,   68.5383377,          10.
   1171,   6.90730095,    68.769371,          10.
   1172,   6.30216455,   68.9811172,          10.
   1173,   5.69055176,   69.1733551,          10.
   1174,   5.07309151,   69.3458939,          10.
   1175,   4.45041847,    69.498558,          10.
   1176,   3.82317257,   69.6311798,          10.
   1177,     3.191998,   69.7436371,          10.
   1178,   2.55754328,   69.8358002,          10.
   1179,   1.92046046,   69.9075851,          10.
   1180,   1.28140438,   69.9589081,          10.
   1181,  0.641031563,   69.9897232,          10.
   1182,           0.,          70.,          10.
   1183, -0.641031563,   69.9897232,          10.
   1184,  -1.28140438,   69.9589081,          10.
   1185,  -1.92046046,   69.9075851,          10.
   1186,  -2.55754328,   69.8358002,          10.
   1187,    -3.191998,   69.7436371,          10.
   1188,  -3.82317257,   69.6311798,          10.
   1189,  -4.45041847,    69.498558,          10.
   1190,  -5.07309151,   69.3458939,          10.
   1191,  -5.69055176,   69.1733551,          10.
   1192,  -6.30216455,   68.9811172,          10.
   1193,  -6.90730095,    68.769371,          10.
   1194,   -7.5053401,   68.5383377,          10.
   1195,  -8.09566689,   68.2882538,          10.
   1196,  -8.67767525,   68.0193787,          10.
   1197,   -9.2507658,    67.731987,          10.
   1198,  -9.81435108,   67.4263763,          10.
   1199,  -10.3678513,   67.1028519,          10.
   1200,  -10.9106979,   66.7617645,          10.
   1201,  -11.4423332,   66.4034424,          10.
   1202,  -11.9622107,   66.0282745,          10.
   1203,  -12.4697962,   65.6366272,          10.
   1204,  -12.9645681,     65.22892,          10.
   1205,  -13.4460182,   64.8055573,          10.
   1206,  -13.9136515,   64.3669891,          10.
   1207,  -14.3669872,   63.9136505,          10.
   1208,  -14.8055601,   63.4460182,          10.
   1209,   -15.228919,   62.9645691,          10.
   1210,  -15.6366301,   62.4697952,          10.
   1211,  -16.0282726,   61.9622116,          10.
   1212,  -16.4034443,   61.4423332,          10.
   1213,  -16.7617626,   60.9106979,          10.
   1214,  -17.1028557,   60.3678513,          10.
   1215,  -17.4263744,   59.8143501,          10.
   1216,   -17.731987,   59.2507668,          10.
   1217,  -18.0193768,   58.6776733,          10.
   1218,  -18.2882519,    58.095665,          10.
   1219,  -18.5383358,   57.5053406,          10.
   1220,  -18.7693691,   56.9073029,          10.
   1221,  -18.9811153,    56.302166,          10.
   1222,   -19.173357,   55.6905518,          10.
   1223,  -19.3458977,   55.0730934,          10.
   1224,   -19.498558,   54.4504204,          10.
   1225,  -19.6311836,   53.8231735,          10.
   1226,  -19.7436352,   53.1919975,          10.
   1227,  -19.8358002,   52.5575447,          10.
   1228,  -19.9075813,   51.9204597,          10.
   1229,  -19.9589081,   51.2814026,          10.
   1230,  -19.9897251,   50.6410332,          10.
   1231,          20.,          50.,  0.909090936
   1232,          20.,          50.,   1.81818187
   1233,          20.,          50.,   2.72727275
   1234,          20.,          50.,   3.63636374
   1235,          20.,          50.,    4.5454545
   1236,          20.,          50.,    5.4545455
   1237,          20.,          50.,   6.36363649
   1238,          20.,          50.,   7.27272749
   1239,          20.,          50.,   8.18181801
   1240,          20.,          50.,     9.090909
   1241,     20.90909,          50.,          10.
   1242,    21.818182,          50.,          10.
   1243,    22.727272,          50.,          10.
   1244,    23.636364,          50.,          10.
   1245,    24.545454,          50.,          10.
   1246,    25.454546,          50.,          10.
   1247,    26.363636,          50.,          10.
   1248,    27.272728,          50.,          10.
   1249,    28.181818,          50.,          10.
   1250,     29.09091,          50.,          10.
   1251,    -29.09091,          50.,          10.
   1252,   -28.181818,          50.,          10.
   1253,   -27.272728,          50.,          10.
   1254,   -26.363636,          50.,          10.
   1255,   -25.454546,          50.,          10.
   1256,   -24.545454,          50.,          10.
   1257,   -23.636364,          50.,          10.
   1258,   -22.727272,          50.,          10.
   1259,   -21.818182,          50.,          10.
   1260,    -20.90909,          50.,          10.
   1261,          20.,   49.2105255,          10.
   1262,          20.,    48.421051,          10.
   1263,          20.,   47.6315804,          10.
   1264,          20.,   46.8421059,          10.
   1265,          20.,   46.0526314,          10.
   1266,          20.,   45.2631569,          10.
   1267,          20.,   44.4736824,          10.
   1268,          20.,   43.6842117,          10.
   1269,          20.,   42.8947372,          10.
   1270,          20.,   42.1052628,          10.
   1271,          20.,   41.3157883,          10.
   1272,          20.,   40.5263176,          10.
   1273,          20.,   39.7368431,          10.
   1274,          20.,   38.9473686,          10.
   1275,          20.,   38.1578941,          10.
   1276,          20.,   37.3684196,          10.
   1277,          20.,    36.578949,          10.
   1278,          20.,   35.7894745,          10.
   1279,          20.,          35.,          10.
   1280,          20.,   34.2105255,          10.
   1281,          20.,    33.421051,          10.
   1282,          20.,   32.6315804,          10.
   1283,          20.,   31.8421059,          10.
   1284,          20.,   31.0526314,          10.
   1285,          20.,   30.2631588,          10.
   1286,          20.,   29.4736843,          10.
   1287,          20.,   28.6842098,          10.
   1288,          20.,   27.8947372,          10.
   1289,          20.,   27.1052628,          10.
   1290,          20.,   26.3157902,          10.
   1291,          20.,   25.5263157,          10.
   1292,          20.,   24.7368412,          10.
   1293,          20.,   23.9473686,          10.
   1294,          20.,   23.1578941,          10.
   1295,          20.,   22.3684216,          10.
   1296,          20.,   21.5789471,          10.
   1297,          20.,   20.7894745,          10.
   1298,     20.90909,          20.,          10.
   1299,    21.818182,          20.,          10.
   1300,    22.727272,          20.,          10.
   1301,    23.636364,          20.,          10.
   1302,    24.545454,          20.,          10.
   1303,    25.454546,          20.,          10.
   1304,    26.363636,          20.,          10.
   1305,    27.272728,          20.,          10.
   1306,    28.181818,          20.,          10.
   1307,     29.09091,          20.,          10.
   1308,          30.,   20.7894745,          10.
   1309,          30.,   21.5789471,          10.
   1310,          30.,   22.3684216,          10.
   1311,          30.,   23.1578941,          10.
   1312,          30.,   23.9473686,          10.
   1313,          30.,   24.7368412,          10.
   1314,          30.,   25.5263157,          10.
   1315,          30.,   26.3157902,          10.
   1316,          30.,   27.1052628,          10.
   1317,          30.,   27.8947372,          10.
   1318,          30.,   28.6842098,          10.
   1319,          30.,   29.4736843,          10.
   1320,          30.,   30.2631588,          10.
   1321,          30.,   31.0526314,          10.
   1322,          30.,   31.8421059,          10.
   1323,          30.,   32.6315804,          10.
   1324,          30.,    33.421051,          10.
   1325,          30.,   34.2105255,          10.
   1326,          30.,          35.,          10.
   1327,          30.,   35.7894745,          10.
   1328,          30.,    36.578949,          10.
   1329,          30.,   37.3684196,          10.
   1330,          30.,   38.1578941,          10.
   1331,          30.,   38.9473686,          10.
   1332,          30.,   39.7368431,          10.
   1333,          30.,   40.5263176,          10.
   1334,          30.,   41.3157883,          10.
   1335,          30.,   42.1052628,          10.
   1336,          30.,   42.8947372,          10.
   1337,          30.,   43.6842117,          10.
   1338,          30.,   44.4736824,          10.
   1339,          30.,   45.2631569,          10.
   1340,          30.,   46.0526314,          10.
   1341,          30.,   46.8421059,          10.
   1342,          30.,   47.6315804,          10.
   1343,          30.,    48.421051,          10.
   1344,          30.,   49.2105255,          10.
   1345,          30.,          20.,     9.090909
   1346,          30.,          20.,   8.18181801
   1347,          30.,          20.,   7.27272749
   1348,          30.,          20.,   6.36363649
   1349,          30.,          20.,    5.4545455
   1350,          30.,          20.,    4.5454545
   1351,          30.,          20.,   3.63636374
   1352,          30.,          20.,   2.72727275
   1353,          30.,          20.,   1.81818187
   1354,          30.,          20.,  0.909090936
   1355,          20.,          20.,  0.909090936
   1356,          20.,          20.,   1.81818187
   1357,          20.,          20.,   2.72727275
   1358,          20.,          20.,   3.63636374
   1359,          20.,          20.,    4.5454545
   1360,          20.,          20.,    5.4545455
   1361,          20.,          20.,   6.36363649
   1362,          20.,          20.,   7.27272749
   1363,          20.,          20.,   8.18181801
   1364,          20.,          20.,     9.090909
   1365,    22.545454,          15.,          10.
   1366,     23.09091,          15.,          10.
   1367,    23.636364,          15.,          10.
   1368,    24.181818,          15.,          10.
   1369,    24.727272,          15.,          10.
   1370,    25.272728,          15.,          10.
   1371,    25.818182,          15.,          10.
   1372,    26.363636,          15.,          10.
   1373,     26.90909,          15.,          10.
   1374,    27.454546,          15.,          10.
   1375,          28.,          15.,   9.54545498
   1376,          28.,          15.,     9.090909
   1377,          28.,          15.,   8.63636398
   1378,          28.,          15.,   8.18181801
   1379,          28.,          15.,   7.72727251
   1380,          28.,          15.,   7.27272749
   1381,          28.,          15.,   6.81818199
   1382,          28.,          15.,   6.36363649
   1383,          28.,          15.,     5.909091
   1384,          28.,          15.,    5.4545455
   1385,    27.454546,          15.,           5.
   1386,     26.90909,          15.,           5.
   1387,    26.363636,          15.,           5.
   1388,    25.818182,          15.,           5.
   1389,    25.272728,          15.,           5.
   1390,    24.727272,          15.,           5.
   1391,    24.181818,          15.,           5.
   1392,    23.636364,          15.,           5.
   1393,     23.09091,          15.,           5.
   1394,    22.545454,          15.,           5.
   1395,          22.,          15.,    5.4545455
   1396,          22.,          15.,     5.909091
   1397,          22.,          15.,   6.36363649
   1398,          22.,          15.,   6.81818199
   1399,          22.,          15.,   7.27272749
   1400,          22.,          15.,   7.72727251
   1401,          22.,          15.,   8.18181801
   1402,          22.,          15.,   8.63636398
   1403,          22.,          15.,     9.090909
   1404,          22.,          15.,   9.54545498
   1405,   20.0539474,   19.8651333,   1.15346622
   1406,   20.2112026,   19.4719944,   2.23634934
   1407,   20.4593391,   18.8516521,   3.18822384
   1408,   20.7811565,   18.0471096,   3.96423078
   1409,   21.1576805,   17.1057968,   4.53493309
   1410,   21.5700207,   16.0749474,   4.88308191
   1411,   21.7142849,   15.7142859,          10.
   1412,   21.4285717,   16.4285717,          10.
   1413,   21.1428566,   17.1428566,          10.
   1414,   20.8571434,   17.8571434,          10.
   1415,   20.5714283,   18.5714283,          10.
   1416,   20.2857151,   19.2857151,          10.
   1417,   28.4299793,   16.0749474,   4.88308191
   1418,   28.8423195,   17.1057987,   4.53493261
   1419,   29.2188435,   18.0471096,   3.96423078
   1420,   29.5406609,   18.8516521,   3.18822432
   1421,   29.7887974,   19.4719944,   2.23634982
   1422,   29.9460526,   19.8651333,    1.1534673
   1423,   29.7142849,   19.2857151,          10.
   1424,   29.4285717,   18.5714283,          10.
   1425,   29.1428566,   17.8571434,          10.
   1426,   28.8571434,   17.1428566,          10.
   1427,   28.5714283,   16.4285717,          10.
   1428,   28.2857151,   15.7142859,          10.
   1429,    -29.09091,          20.,          10.
   1430,   -28.181818,          20.,          10.
   1431,   -27.272728,          20.,          10.
   1432,   -26.363636,          20.,          10.
   1433,   -25.454546,          20.,          10.
   1434,   -24.545454,          20.,          10.
   1435,   -23.636364,          20.,          10.
   1436,   -22.727272,          20.,          10.
   1437,   -21.818182,          20.,          10.
   1438,    -20.90909,          20.,          10.
   1439,         -20.,   20.7894745,          10.
   1440,         -20.,   21.5789471,          10.
   1441,         -20.,   22.3684216,          10.
   1442,         -20.,   23.1578941,          10.
   1443,         -20.,   23.9473686,          10.
   1444,         -20.,   24.7368412,          10.
   1445,         -20.,   25.5263157,          10.
   1446,         -20.,   26.3157902,          10.
   1447,         -20.,   27.1052628,          10.
   1448,         -20.,   27.8947372,          10.
   1449,         -20.,   28.6842098,          10.
   1450,         -20.,   29.4736843,          10.
   1451,         -20.,   30.2631588,          10.
   1452,         -20.,   31.0526314,          10.
   1453,         -20.,   31.8421059,          10.
   1454,         -20.,   32.6315804,          10.
   1455,         -20.,    33.421051,          10.
   1456,         -20.,   34.2105255,          10.
   1457,         -20.,          35.,          10.
   1458,         -20.,   35.7894745,          10.
   1459,         -20.,    36.578949,          10.
   1460,         -20.,   37.3684196,          10.
   1461,         -20.,   38.1578941,          10.
   1462,         -20.,   38.9473686,          10.
   1463,         -20.,   39.7368431,          10.
   1464,         -20.,   40.5263176,          10.
   1465,         -20.,   41.3157883,          10.
   1466,         -20.,   42.1052628,          10.
   1467,         -20.,   42.8947372,          10.
   1468,         -20.,   43.6842117,          10.
   1469,         -20.,   44.4736824,          10.
   1470,         -20.,   45.2631569,          10.
   1471,         -20.,   46.0526314,          10.
   1472,         -20.,   46.8421059,          10.
   1473,         -20.,   47.6315804,          10.
   1474,         -20.,    48.421051,          10.
   1475,         -20.,   49.2105255,          10.
   1476,         -30.,   49.2105255,          10.
   1477,         -30.,    48.421051,          10.
   1478,         -30.,   47.6315804,          10.
   1479,         -30.,   46.8421059,          10.
   1480,         -30.,   46.0526314,          10.
   1481,         -30.,   45.2631569,          10.
   1482,         -30.,   44.4736824,          10.
   1483,         -30.,   43.6842117,          10.
   1484,         -30.,   42.8947372,          10.
   1485,         -30.,   42.1052628,          10.
   1486,         -30.,   41.3157883,          10.
   1487,         -30.,   40.5263176,          10.
   1488,         -30.,   39.7368431,          10.
   1489,         -30.,   38.9473686,          10.
   1490,         -30.,   38.1578941,          10.
   1491,         -30.,   37.3684196,          10.
   1492,         -30.,    36.578949,          10.
   1493,         -30.,   35.7894745,          10.
   1494,         -30.,          35.,          10.
   1495,         -30.,   34.2105255,          10.
   1496,         -30.,    33.421051,          10.
   1497,         -30.,   32.6315804,          10.
   1498,         -30.,   31.8421059,          10.
   1499,         -30.,   31.0526314,          10.
   1500,         -30.,   30.2631588,          10.
   1501,         -30.,   29.4736843,          10.
   1502,         -30.,   28.6842098,          10.
   1503,         -30.,   27.8947372,          10.
   1504,         -30.,   27.1052628,          10.
   1505,         -30.,   26.3157902,          10.
   1506,         -30.,   25.5263157,          10.
   1507,         -30.,   24.7368412,          10.
   1508,         -30.,   23.9473686,          10.
   1509,         -30.,   23.1578941,          10.
   1510,         -30.,   22.3684216,          10.
   1511,         -30.,   21.5789471,          10.
   1512,         -30.,   20.7894745,          10.
   1513,         -30.,          20.,  0.909090936
   1514,         -30.,          20.,   1.81818187
   1515,         -30.,          20.,   2.72727275
   1516,         -30.,          20.,   3.63636374
   1517,         -30.,          20.,    4.5454545
   1518,         -30.,          20.,    5.4545455
   1519,         -30.,          20.,   6.36363649
   1520,         -30.,          20.,   7.27272749
   1521,         -30.,          20.,   8.18181801
   1522,         -30.,          20.,     9.090909
   1523,         -20.,          20.,     9.090909
   1524,         -20.,          20.,   8.18181801
   1525,         -20.,          20.,   7.27272749
   1526,         -20.,          20.,   6.36363649
   1527,         -20.,          20.,    5.4545455
   1528,         -20.,          20.,    4.5454545
   1529,         -20.,          20.,   3.63636374
   1530,         -20.,          20.,   2.72727275
   1531,         -20.,          20.,   1.81818187
   1532,         -20.,          20.,  0.909090936
   1533,   -22.545454,          15.,           5.
   1534,    -23.09091,          15.,           5.
   1535,   -23.636364,          15.,           5.
   1536,   -24.181818,          15.,           5.
   1537,   -24.727272,          15.,           5.
   1538,   -25.272728,          15.,           5.
   1539,   -25.818182,          15.,           5.
   1540,   -26.363636,          15.,           5.
   1541,    -26.90909,          15.,           5.
   1542,   -27.454546,          15.,           5.
   1543,         -28.,          15.,    5.4545455
   1544,         -28.,          15.,     5.909091
   1545,         -28.,          15.,   6.36363649
   1546,         -28.,          15.,   6.81818199
   1547,         -28.,          15.,   7.27272749
   1548,         -28.,          15.,   7.72727251
   1549,         -28.,          15.,   8.18181801
   1550,         -28.,          15.,   8.63636398
   1551,         -28.,          15.,     9.090909
   1552,         -28.,          15.,   9.54545498
   1553,   -27.454546,          15.,          10.
   1554,    -26.90909,          15.,          10.
   1555,   -26.363636,          15.,          10.
   1556,   -25.818182,          15.,          10.
   1557,   -25.272728,          15.,          10.
   1558,   -24.727272,          15.,          10.
   1559,   -24.181818,          15.,          10.
   1560,   -23.636364,          15.,          10.
   1561,    -23.09091,          15.,          10.
   1562,   -22.545454,          15.,          10.
   1563,         -22.,          15.,   9.54545498
   1564,         -22.,          15.,     9.090909
   1565,         -22.,          15.,   8.63636398
   1566,         -22.,          15.,   8.18181801
   1567,         -22.,          15.,   7.72727251
   1568,         -22.,          15.,   7.27272749
   1569,         -22.,          15.,   6.81818199
   1570,         -22.,          15.,   6.36363649
   1571,         -22.,          15.,     5.909091
   1572,         -22.,          15.,    5.4545455
   1573,       -20.25,       19.375,          10.
   1574,        -20.5,        18.75,          10.
   1575,       -20.75,       18.125,          10.
   1576,         -21.,         17.5,          10.
   1577,       -21.25,       16.875,          10.
   1578,        -21.5,        16.25,          10.
   1579,       -21.75,       15.625,          10.
   1580,  -21.6231689,   15.9420767,   4.91044712
   1581,   -21.258131,   16.8546715,   4.64329576
   1582,  -20.9169693,   17.7075748,   4.20345545
   1583,  -20.6122112,   18.4694729,   3.60038233
   1584,  -20.3566628,   19.1083412,   2.84982991
   1585,   -20.162775,   19.5930634,   1.97579741
   1586,  -20.0413742,   19.8965645,   1.01175892
   1587,       -28.25,       15.625,          10.
   1588,        -28.5,        16.25,          10.
   1589,       -28.75,       16.875,          10.
   1590,         -29.,         17.5,          10.
   1591,       -29.25,       18.125,          10.
   1592,        -29.5,        18.75,          10.
   1593,       -29.75,       19.375,          10.
   1594,  -29.9586258,   19.8965645,   1.01175892
   1595,   -29.837225,   19.5930634,   1.97579706
   1596,  -29.6433372,   19.1083412,   2.84982967
   1597,  -29.3877907,   18.4694748,   3.60038114
   1598,  -29.0830307,   17.7075768,   4.20345497
   1599,   -28.741869,   16.8546734,   4.64329481
   1600,  -28.3768311,   15.9420795,   4.91044664
   1601,   29.9586258,   19.8965645,  -1.01175892
   1602,    29.837225,   19.5930634,  -1.97579706
   1603,   29.6433372,   19.1083412,  -2.84982967
   1604,   29.3877907,   18.4694748,  -3.60038114
   1605,   29.0830307,   17.7075768,  -4.20345497
   1606,    28.741869,   16.8546734,  -4.64329481
   1607,   28.3768311,   15.9420795,  -4.91044664
   1608,          28.,          15.,   -5.4545455
   1609,          28.,          15.,    -5.909091
   1610,          28.,          15.,  -6.36363649
   1611,          28.,          15.,  -6.81818199
   1612,          28.,          15.,  -7.27272749
   1613,          28.,          15.,  -7.72727251
   1614,          28.,          15.,  -8.18181801
   1615,          28.,          15.,  -8.63636398
   1616,          28.,          15.,    -9.090909
   1617,          28.,          15.,  -9.54545498
   1618,        28.25,       15.625,         -10.
   1619,         28.5,        16.25,         -10.
   1620,        28.75,       16.875,         -10.
   1621,          29.,         17.5,         -10.
   1622,        29.25,       18.125,         -10.
   1623,         29.5,        18.75,         -10.
   1624,        29.75,       19.375,         -10.
   1625,   21.6231689,   15.9420767,  -4.91044712
   1626,    21.258131,   16.8546715,  -4.64329576
   1627,   20.9169693,   17.7075748,  -4.20345545
   1628,   20.6122112,   18.4694729,  -3.60038233
   1629,   20.3566628,   19.1083412,  -2.84982991
   1630,    20.162775,   19.5930634,  -1.97579741
   1631,   20.0413742,   19.8965645,  -1.01175892
   1632,          22.,          15.,  -9.54545498
   1633,          22.,          15.,    -9.090909
   1634,          22.,          15.,  -8.63636398
   1635,          22.,          15.,  -8.18181801
   1636,          22.,          15.,  -7.72727251
   1637,          22.,          15.,  -7.27272749
   1638,          22.,          15.,  -6.81818199
   1639,          22.,          15.,  -6.36363649
   1640,          22.,          15.,    -5.909091
   1641,          22.,          15.,   -5.4545455
   1642,        20.25,       19.375,         -10.
   1643,         20.5,        18.75,         -10.
   1644,        20.75,       18.125,         -10.
   1645,          21.,         17.5,         -10.
   1646,        21.25,       16.875,         -10.
   1647,         21.5,        16.25,         -10.
   1648,        21.75,       15.625,         -10.
   1649,    27.454546,          15.,         -10.
   1650,     26.90909,          15.,         -10.
   1651,    26.363636,          15.,         -10.
   1652,    25.818182,          15.,         -10.
   1653,    25.272728,          15.,         -10.
   1654,    24.727272,          15.,         -10.
   1655,    24.181818,          15.,         -10.
   1656,    23.636364,          15.,         -10.
   1657,     23.09091,          15.,         -10.
   1658,    22.545454,          15.,         -10.
   1659,    22.545454,          15.,          -5.
   1660,     23.09091,          15.,          -5.
   1661,    23.636364,          15.,          -5.
   1662,    24.181818,          15.,          -5.
   1663,    24.727272,          15.,          -5.
   1664,    25.272728,          15.,          -5.
   1665,    25.818182,          15.,          -5.
   1666,    26.363636,          15.,          -5.
   1667,     26.90909,          15.,          -5.
   1668,    27.454546,          15.,          -5.
   1669,     20.90909,          10.,           0.
   1670,    21.818182,          10.,           0.
   1671,    22.727272,          10.,           0.
   1672,    23.636364,          10.,           0.
   1673,    24.545454,          10.,           0.
   1674,    25.454546,          10.,           0.
   1675,    26.363636,          10.,           0.
   1676,    27.272728,          10.,           0.
   1677,    28.181818,          10.,           0.
   1678,     29.09091,          10.,           0.
   1679,   29.9460526,   10.1348677,   -1.1534673
   1680,   29.7887974,   10.5280046,  -2.23634982
   1681,   29.5406609,   11.1483479,  -3.18822432
   1682,   29.2188435,   11.9528904,  -3.96423078
   1683,   28.8423195,   12.8942022,  -4.53493261
   1684,   28.4299793,   13.9250526,  -4.88308191
   1685,   21.5700207,   13.9250536,  -4.88308191
   1686,   21.1576805,   12.8942032,  -4.53493309
   1687,   20.7811565,   11.9528904,  -3.96423078
   1688,   20.4593391,   11.1483469,  -3.18822384
   1689,   20.2112026,   10.5280046,  -2.23634934
   1690,   20.0539474,   10.1348677,  -1.15346622
   1691,     29.09091,          10.,         -10.
   1692,    28.181818,          10.,         -10.
   1693,    27.272728,          10.,         -10.
   1694,    26.363636,          10.,         -10.
   1695,    25.454546,          10.,         -10.
   1696,    24.545454,          10.,         -10.
   1697,    23.636364,          10.,         -10.
   1698,    22.727272,          10.,         -10.
   1699,    21.818182,          10.,         -10.
   1700,     20.90909,          10.,         -10.
   1701,   28.2857151,   14.2857141,         -10.
   1702,   28.5714283,   13.5714283,         -10.
   1703,   28.8571434,   12.8571424,         -10.
   1704,   29.1428566,   12.1428576,         -10.
   1705,   29.4285717,   11.4285717,         -10.
   1706,   29.7142849,   10.7142859,         -10.
   1707,   20.2857151,   10.7142859,         -10.
   1708,   20.5714283,   11.4285717,         -10.
   1709,   20.8571434,   12.1428576,         -10.
   1710,   21.1428566,   12.8571424,         -10.
   1711,   21.4285717,   13.5714283,         -10.
   1712,   21.7142849,   14.2857141,         -10.
   1713,          20.,          10.,    -9.090909
   1714,          20.,          10.,  -8.18181801
   1715,          20.,          10.,  -7.27272749
   1716,          20.,          10.,  -6.36363649
   1717,          20.,          10.,   -5.4545455
   1718,          20.,          10.,   -4.5454545
   1719,          20.,          10.,  -3.63636374
   1720,          20.,          10.,  -2.72727275
   1721,          20.,          10.,  -1.81818187
   1722,          20.,          10., -0.909090936
   1723,          30.,          10., -0.909090936
   1724,          30.,          10.,  -1.81818187
   1725,          30.,          10.,  -2.72727275
   1726,          30.,          10.,  -3.63636374
   1727,          30.,          10.,   -4.5454545
   1728,          30.,          10.,   -5.4545455
   1729,          30.,          10.,  -6.36363649
   1730,          30.,          10.,  -7.27272749
   1731,          30.,          10.,  -8.18181801
   1732,          30.,          10.,    -9.090909
   1733,       -20.25,       19.375,         -10.
   1734,        -20.5,        18.75,         -10.
   1735,       -20.75,       18.125,         -10.
   1736,         -21.,         17.5,         -10.
   1737,       -21.25,       16.875,         -10.
   1738,        -21.5,        16.25,         -10.
   1739,       -21.75,       15.625,         -10.
   1740,   -22.545454,          15.,         -10.
   1741,    -23.09091,          15.,         -10.
   1742,   -23.636364,          15.,         -10.
   1743,   -24.181818,          15.,         -10.
   1744,   -24.727272,          15.,         -10.
   1745,   -25.272728,          15.,         -10.
   1746,   -25.818182,          15.,         -10.
   1747,   -26.363636,          15.,         -10.
   1748,    -26.90909,          15.,         -10.
   1749,   -27.454546,          15.,         -10.
   1750,       -28.25,       15.625,         -10.
   1751,        -28.5,        16.25,         -10.
   1752,       -28.75,       16.875,         -10.
   1753,         -29.,         17.5,         -10.
   1754,       -29.25,       18.125,         -10.
   1755,        -29.5,        18.75,         -10.
   1756,       -29.75,       19.375,         -10.
   1757,  -21.6231689,   15.9420767,  -4.91044712
   1758,   -21.258131,   16.8546715,  -4.64329576
   1759,  -20.9169693,   17.7075748,  -4.20345545
   1760,  -20.6122093,   18.4694748,  -3.60038161
   1761,  -20.3566628,   19.1083412,   -2.8498292
   1762,   -20.162775,   19.5930634,  -1.97579563
   1763,  -20.0413742,   19.8965645,  -1.01175678
   1764,   -27.454546,          15.,          -5.
   1765,    -26.90909,          15.,          -5.
   1766,   -26.363636,          15.,          -5.
   1767,   -25.818182,          15.,          -5.
   1768,   -25.272728,          15.,          -5.
   1769,   -24.727272,          15.,          -5.
   1770,   -24.181818,          15.,          -5.
   1771,   -23.636364,          15.,          -5.
   1772,    -23.09091,          15.,          -5.
   1773,   -22.545454,          15.,          -5.
   1774,  -29.9586258,   19.8965645,  -1.01175892
   1775,   -29.837225,   19.5930634,  -1.97579706
   1776,  -29.6433372,   19.1083412,  -2.84982944
   1777,  -29.3877907,   18.4694748,   -3.6003809
   1778,  -29.0830307,   17.7075768,  -4.20345449
   1779,   -28.741869,   16.8546734,  -4.64329481
   1780,  -28.3768311,   15.9420786,  -4.91044664
   1781,         -28.,          15.,  -9.54545498
   1782,         -28.,          15.,    -9.090909
   1783,         -28.,          15.,  -8.63636398
   1784,         -28.,          15.,  -8.18181801
   1785,         -28.,          15.,  -7.72727251
   1786,         -28.,          15.,  -7.27272749
   1787,         -28.,          15.,  -6.81818199
   1788,         -28.,          15.,  -6.36363649
   1789,         -28.,          15.,    -5.909091
   1790,         -28.,          15.,   -5.4545455
   1791,         -22.,          15.,   -5.4545455
   1792,         -22.,          15.,    -5.909091
   1793,         -22.,          15.,  -6.36363649
   1794,         -22.,          15.,  -6.81818199
   1795,         -22.,          15.,  -7.27272749
   1796,         -22.,          15.,  -7.72727251
   1797,         -22.,          15.,  -8.18181801
   1798,         -22.,          15.,  -8.63636398
   1799,         -22.,          15.,    -9.090909
   1800,         -22.,          15.,  -9.54545498
   1801,         -20.,          10.,     9.090909
   1802,         -20.,          10.,   8.18181801
   1803,         -20.,          10.,   7.27272749
   1804,         -20.,          10.,   6.36363649
   1805,         -20.,          10.,    5.4545455
   1806,         -20.,          10.,    4.5454545
   1807,         -20.,          10.,   3.63636374
   1808,         -20.,          10.,   2.72727275
   1809,         -20.,          10.,   1.81818187
   1810,         -20.,          10.,  0.909090936
   1811,  -20.0413742,   10.1034355,   1.01175678
   1812,   -20.162775,   10.4069366,   1.97579563
   1813,  -20.3566628,   10.8916578,    2.8498292
   1814,  -20.6122093,   11.5305252,   3.60038161
   1815,  -20.9169693,   12.2924242,   4.20345545
   1816,   -21.258131,   13.1453285,   4.64329576
   1817,  -21.6231689,   14.0579233,   4.91044712
   1818,       -21.75,       14.375,          10.
   1819,        -21.5,        13.75,          10.
   1820,       -21.25,       13.125,          10.
   1821,         -21.,         12.5,          10.
   1822,       -20.75,       11.875,          10.
   1823,        -20.5,        11.25,          10.
   1824,       -20.25,       10.625,          10.
   1825,         -30.,          10.,  0.909090936
   1826,         -30.,          10.,   1.81818187
   1827,         -30.,          10.,   2.72727275
   1828,         -30.,          10.,   3.63636374
   1829,         -30.,          10.,    4.5454545
   1830,         -30.,          10.,    5.4545455
   1831,         -30.,          10.,   6.36363649
   1832,         -30.,          10.,   7.27272749
   1833,         -30.,          10.,   8.18181801
   1834,         -30.,          10.,     9.090909
   1835,  -28.3768311,   14.0579214,   4.91044664
   1836,   -28.741869,   13.1453266,   4.64329481
   1837,  -29.0830307,   12.2924232,   4.20345449
   1838,  -29.3877907,   11.5305252,    3.6003809
   1839,  -29.6433372,   10.8916578,   2.84982944
   1840,   -29.837225,   10.4069376,   1.97579706
   1841,  -29.9586258,   10.1034355,   1.01175892
   1842,       -29.75,       10.625,          10.
   1843,        -29.5,        11.25,          10.
   1844,       -29.25,       11.875,          10.
   1845,         -29.,         12.5,          10.
   1846,       -28.75,       13.125,          10.
   1847,        -28.5,        13.75,          10.
   1848,       -28.25,       14.375,          10.
   1849,    -29.09091,          10.,          10.
   1850,   -28.181818,          10.,          10.
   1851,   -27.272728,          10.,          10.
   1852,   -26.363636,          10.,          10.
   1853,   -25.454546,          10.,          10.
   1854,   -24.545454,          10.,          10.
   1855,   -23.636364,          10.,          10.
   1856,   -22.727272,          10.,          10.
   1857,   -21.818182,          10.,          10.
   1858,    -20.90909,          10.,          10.
   1859,    -20.90909,          10.,           0.
   1860,   -21.818182,          10.,           0.
   1861,   -22.727272,          10.,           0.
   1862,   -23.636364,          10.,           0.
   1863,   -24.545454,          10.,           0.
   1864,   -25.454546,          10.,           0.
   1865,   -26.363636,          10.,           0.
   1866,   -27.272728,          10.,           0.
   1867,   -28.181818,          10.,           0.
   1868,    -29.09091,          10.,           0.
   1869,    -29.09091,           0.,           0.
   1870,   -28.181818,           0.,           0.
   1871,   -27.272728,           0.,           0.
   1872,   -26.363636,           0.,           0.
   1873,   -25.454546,           0.,           0.
   1874,   -24.545454,           0.,           0.
   1875,   -23.636364,           0.,           0.
   1876,   -22.727272,           0.,           0.
   1877,   -21.818182,           0.,           0.
   1878,    -20.90909,           0.,           0.
   1879,         -30.,           0.,     9.090909
   1880,         -30.,           0.,   8.18181801
   1881,         -30.,           0.,   7.27272749
   1882,         -30.,           0.,   6.36363649
   1883,         -30.,           0.,    5.4545455
   1884,         -30.,           0.,    4.5454545
   1885,         -30.,           0.,   3.63636374
   1886,         -30.,           0.,   2.72727275
   1887,         -30.,           0.,   1.81818187
   1888,         -30.,           0.,  0.909090936
   1889,    -20.90909,           0.,          10.
   1890,   -21.818182,           0.,          10.
   1891,   -22.727272,           0.,          10.
   1892,   -23.636364,           0.,          10.
   1893,   -24.545454,           0.,          10.
   1894,   -25.454546,           0.,          10.
   1895,   -26.363636,           0.,          10.
   1896,   -27.272728,           0.,          10.
   1897,   -28.181818,           0.,          10.
   1898,    -29.09091,           0.,          10.
   1899,         -20.,           0.,  0.909090936
   1900,         -20.,           0.,   1.81818187
   1901,         -20.,           0.,   2.72727275
   1902,         -20.,           0.,   3.63636374
   1903,         -20.,           0.,    4.5454545
   1904,         -20.,           0.,    5.4545455
   1905,         -20.,           0.,   6.36363649
   1906,         -20.,           0.,   7.27272749
   1907,         -20.,           0.,   8.18181801
   1908,         -20.,           0.,     9.090909
   1909,         -20.,   9.16666698,          10.
   1910,         -20.,   8.33333302,          10.
   1911,         -20.,          7.5,          10.
   1912,         -20.,   6.66666651,          10.
   1913,         -20.,   5.83333349,          10.
   1914,         -20.,           5.,          10.
   1915,         -20.,   4.16666651,          10.
   1916,         -20.,   3.33333325,          10.
   1917,         -20.,          2.5,          10.
   1918,         -20.,   1.66666663,          10.
   1919,         -20.,  0.833333313,          10.
   1920,         -20.,  0.833333313,           0.
   1921,         -20.,   1.66666663,           0.
   1922,         -20.,          2.5,           0.
   1923,         -20.,   3.33333325,           0.
   1924,         -20.,   4.16666651,           0.
   1925,         -20.,           5.,           0.
   1926,         -20.,   5.83333349,           0.
   1927,         -20.,   6.66666651,           0.
   1928,         -20.,          7.5,           0.
   1929,         -20.,   8.33333302,           0.
   1930,         -20.,   9.16666698,           0.
   1931,         -30.,  0.833333313,          10.
   1932,         -30.,   1.66666663,          10.
   1933,         -30.,          2.5,          10.
   1934,         -30.,   3.33333325,          10.
   1935,         -30.,   4.16666651,          10.
   1936,         -30.,           5.,          10.
   1937,         -30.,   5.83333349,          10.
   1938,         -30.,   6.66666651,          10.
   1939,         -30.,          7.5,          10.
   1940,         -30.,   8.33333302,          10.
   1941,         -30.,   9.16666698,          10.
   1942,         -30.,   9.16666698,           0.
   1943,         -30.,   8.33333302,           0.
   1944,         -30.,          7.5,           0.
   1945,         -30.,   6.66666651,           0.
   1946,         -30.,   5.83333349,           0.
   1947,         -30.,           5.,           0.
   1948,         -30.,   4.16666651,           0.
   1949,         -30.,   3.33333325,           0.
   1950,         -30.,          2.5,           0.
   1951,         -30.,   1.66666663,           0.
   1952,         -30.,  0.833333313,           0.
   1953,          20.,          10.,  0.909090936
   1954,          20.,          10.,   1.81818187
   1955,          20.,          10.,   2.72727275
   1956,          20.,          10.,   3.63636374
   1957,          20.,          10.,    4.5454545
   1958,          20.,          10.,    5.4545455
   1959,          20.,          10.,   6.36363649
   1960,          20.,          10.,   7.27272749
   1961,          20.,          10.,   8.18181801
   1962,          20.,          10.,     9.090909
   1963,     20.90909,          10.,          10.
   1964,    21.818182,          10.,          10.
   1965,    22.727272,          10.,          10.
   1966,    23.636364,          10.,          10.
   1967,    24.545454,          10.,          10.
   1968,    25.454546,          10.,          10.
   1969,    26.363636,          10.,          10.
   1970,    27.272728,          10.,          10.
   1971,    28.181818,          10.,          10.
   1972,     29.09091,          10.,          10.
   1973,          30.,          10.,     9.090909
   1974,          30.,          10.,   8.18181801
   1975,          30.,          10.,   7.27272749
   1976,          30.,          10.,   6.36363649
   1977,          30.,          10.,    5.4545455
   1978,          30.,          10.,    4.5454545
   1979,          30.,          10.,   3.63636374
   1980,          30.,          10.,   2.72727275
   1981,          30.,          10.,   1.81818187
   1982,          30.,          10.,  0.909090936
   1983,     20.90909,           0.,           0.
   1984,    21.818182,           0.,           0.
   1985,    22.727272,           0.,           0.
   1986,    23.636364,           0.,           0.
   1987,    24.545454,           0.,           0.
   1988,    25.454546,           0.,           0.
   1989,    26.363636,           0.,           0.
   1990,    27.272728,           0.,           0.
   1991,    28.181818,           0.,           0.
   1992,     29.09091,           0.,           0.
   1993,          20.,           0.,     9.090909
   1994,          20.,           0.,   8.18181801
