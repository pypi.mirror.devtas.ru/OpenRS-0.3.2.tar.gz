  15995,    24.181818,          15.,  -6.81818199
  15996,    24.181818,          15.,  -6.36363649
  15997,    24.181818,          15.,    -5.909091
  15998,    24.181818,          15.,   -5.4545455
  15999,    23.636364,          15.,  -9.54545498
  16000,    23.636364,          15.,    -9.090909
  16001,    23.636364,          15.,  -8.63636398
  16002,    23.636364,          15.,  -8.18181801
  16003,    23.636364,          15.,  -7.72727251
  16004,    23.636364,          15.,  -7.27272749
  16005,    23.636364,          15.,  -6.81818199
  16006,    23.636364,          15.,  -6.36363649
  16007,    23.636364,          15.,    -5.909091
  16008,    23.636364,          15.,   -5.4545455
  16009,     23.09091,          15.,  -9.54545498
  16010,     23.09091,          15.,    -9.090909
  16011,     23.09091,          15.,  -8.63636398
  16012,     23.09091,          15.,  -8.18181801
  16013,     23.09091,          15.,  -7.72727251
  16014,     23.09091,          15.,  -7.27272749
  16015,     23.09091,          15.,  -6.81818199
  16016,     23.09091,          15.,  -6.36363649
  16017,     23.09091,          15.,    -5.909091
  16018,     23.09091,          15.,   -5.4545455
  16019,    22.545454,          15.,  -9.54545498
  16020,    22.545454,          15.,    -9.090909
  16021,    22.545454,          15.,  -8.63636398
  16022,    22.545454,          15.,  -8.18181801
  16023,    22.545454,          15.,  -7.72727251
  16024,    22.545454,          15.,  -7.27272749
  16025,    22.545454,          15.,  -6.81818199
  16026,    22.545454,          15.,  -6.36363649
  16027,    22.545454,          15.,    -5.909091
  16028,    22.545454,          15.,   -5.4545455
  16029,   20.9532299,   10.1348677,  -1.15346646
  16030,   21.8525124,   10.1348677,  -1.15346646
  16031,   22.7517948,   10.1348677,  -1.15346646
  16032,   23.6510773,   10.1348677,  -1.15346658
  16033,   24.5503578,   10.1348677,   -1.1534667
  16034,   25.4496403,   10.1348677,  -1.15346682
  16035,   26.3489227,   10.1348677,  -1.15346682
  16036,   27.2482052,   10.1348677,  -1.15346694
  16037,   28.1474876,   10.1348677,  -1.15346706
  16038,   29.0467701,   10.1348677,  -1.15346718
  16039,    21.081892,   10.5280046,  -2.23634934
  16040,   21.9525833,   10.5280046,  -2.23634934
  16041,   22.8232727,   10.5280046,  -2.23634958
  16042,    23.693964,   10.5280046,  -2.23634958
  16043,   24.5646553,   10.5280046,  -2.23634958
  16044,   25.4353447,   10.5280046,  -2.23634958
  16045,    26.306036,   10.5280046,  -2.23634958
  16046,   27.1767254,   10.5280046,  -2.23634958
  16047,   28.0474167,   10.5280046,  -2.23634958
  16048,    28.918108,   10.5280046,  -2.23634958
  16049,    21.284914,   11.1483469,   -3.1882236
  16050,   22.1104889,   11.1483479,  -3.18822432
  16051,   22.9360638,   11.1483479,  -3.18822432
  16052,   23.7616386,   11.1483479,  -3.18822432
  16053,   24.5872116,   11.1483479,  -3.18822432
  16054,   25.4127865,   11.1483479,  -3.18822432
  16055,   26.2383614,   11.1483479,  -3.18822432
  16056,   27.0639362,   11.1483479,  -3.18822432
  16057,   27.8895111,   11.1483479,  -3.18822432
  16058,    28.715086,   11.1483479,  -3.18822432
  16059,   21.5482197,   11.9528904,  -3.96423054
  16060,   22.3152809,   11.9528904,  -3.96423054
  16061,   23.0823441,   11.9528904,  -3.96423054
  16062,   23.8494072,   11.9528904,  -3.96423054
  16063,   24.6164684,   11.9528904,  -3.96423054
  16064,   25.3835316,   11.9528904,  -3.96423054
  16065,   26.1505928,   11.9528904,  -3.96423054
  16066,   26.9176559,   11.9528904,  -3.96423054
  16067,   27.6847191,   11.9528904,  -3.96423054
  16068,   28.4517803,   11.9528904,  -3.96423054
  16069,   21.8562851,   12.8942032,  -4.53493309
  16070,   22.5548878,   12.8942022,  -4.53493309
  16071,   23.2534924,   12.8942022,  -4.53493309
  16072,    23.952095,   12.8942022,  -4.53493309
  16073,   24.6506977,   12.8942022,  -4.53493309
  16074,   25.3493023,   12.8942022,  -4.53493309
  16075,    26.047905,   12.8942022,  -4.53493309
  16076,   26.7465096,   12.8942022,  -4.53493261
  16077,   27.4451122,   12.8942022,  -4.53493261
  16078,   28.1437149,   12.8942022,  -4.53493261
  16079,   22.1936531,   13.9250536,  -4.88308191
  16080,   22.8172855,   13.9250536,  -4.88308191
  16081,    23.440918,   13.9250536,  -4.88308191
  16082,   24.0645523,   13.9250536,  -4.88308191
  16083,   24.6881847,   13.9250536,  -4.88308191
  16084,   25.3118172,   13.9250526,  -4.88308191
  16085,   25.9354496,   13.9250526,  -4.88308191
  16086,    26.559082,   13.9250526,  -4.88308191
  16087,   27.1827145,   13.9250526,  -4.88308191
  16088,   27.8063469,   13.9250526,  -4.88308191
  16089,   21.1428566,   10.7142859,         -10.
  16090,          22.,   10.7142859,         -10.
  16091,   22.8571434,   10.7142859,         -10.
  16092,   23.7142849,   10.7142859,         -10.
  16093,   24.5714283,   10.7142859,         -10.
  16094,   25.4285717,   10.7142859,         -10.
  16095,   26.2857151,   10.7142859,         -10.
  16096,   27.1428566,   10.7142859,         -10.
  16097,          28.,   10.7142859,         -10.
  16098,   28.8571434,   10.7142859,         -10.
  16099,   21.3766232,   11.4285717,         -10.
  16100,    22.181818,   11.4285717,         -10.
  16101,   22.9870129,   11.4285717,         -10.
  16102,   23.7922077,   11.4285717,         -10.
  16103,   24.5974026,   11.4285717,         -10.
  16104,   25.4025974,   11.4285717,         -10.
  16105,   26.2077923,   11.4285717,         -10.
  16106,   27.0129871,   11.4285717,         -10.
  16107,    27.818182,   11.4285717,         -10.
  16108,   28.6233768,   11.4285717,         -10.
  16109,   21.6103897,   12.1428576,         -10.
  16110,    22.363636,   12.1428576,         -10.
  16111,   23.1168823,   12.1428576,         -10.
  16112,   23.8701305,   12.1428576,         -10.
  16113,   24.6233768,   12.1428576,         -10.
  16114,   25.3766232,   12.1428576,         -10.
  16115,   26.1298695,   12.1428576,         -10.
  16116,   26.8831177,   12.1428576,         -10.
  16117,    27.636364,   12.1428576,         -10.
  16118,   28.3896103,   12.1428576,         -10.
  16119,   21.8441563,   12.8571424,         -10.
  16120,    22.545454,   12.8571424,         -10.
  16121,   23.2467537,   12.8571424,         -10.
  16122,   23.9480515,   12.8571424,         -10.
  16123,   24.6493511,   12.8571424,         -10.
  16124,   25.3506489,   12.8571424,         -10.
  16125,   26.0519485,   12.8571424,         -10.
  16126,   26.7532463,   12.8571424,         -10.
  16127,    27.454546,   12.8571424,         -10.
  16128,   28.1558437,   12.8571424,         -10.
  16129,   22.0779228,   13.5714283,         -10.
  16130,    22.727272,   13.5714283,         -10.
  16131,   23.3766232,   13.5714283,         -10.
  16132,   24.0259743,   13.5714283,         -10.
  16133,   24.6753254,   13.5714283,         -10.
  16134,   25.3246746,   13.5714283,         -10.
  16135,   25.9740257,   13.5714283,         -10.
  16136,   26.6233768,   13.5714283,         -10.
  16137,    27.272728,   13.5714283,         -10.
  16138,   27.9220772,   13.5714283,         -10.
  16139,   22.3116875,   14.2857141,         -10.
  16140,     22.90909,   14.2857141,         -10.
  16141,   23.5064926,   14.2857141,         -10.
  16142,   24.1038952,   14.2857141,         -10.
  16143,   24.7012978,   14.2857141,         -10.
  16144,   25.2987022,   14.2857141,         -10.
  16145,   25.8961048,   14.2857141,         -10.
  16146,   26.4935074,   14.2857141,         -10.
  16147,     27.09091,   14.2857141,         -10.
  16148,   27.6883125,   14.2857141,         -10.
  16149,    20.075016,    10.187542,  -1.95769656
  16150,   20.2439499,   10.6098747,  -2.94213581
  16151,   20.4955025,   11.2387571,  -3.80747628
  16152,   20.8140373,   12.0350952,  -4.51293707
  16153,   21.1823082,   12.9557686,  -5.03175735
  16154,   21.5831356,   13.9578409,  -5.34825659
  16155,   20.0960865,   10.2402163,  -2.76192689
  16156,   20.2766972,   10.6917439,  -3.64792204
  16157,   20.5316677,   11.3291674,  -4.42672873
  16158,     20.84692,      12.1173,  -5.06164312
  16159,    21.206934,   13.0173349,  -5.52858162
  16160,   21.5962505,   13.9906282,  -5.81343079
  16161,    20.117157,   10.2928905,  -3.56615734
  16162,   20.3094463,   10.7736139,  -4.35370874
  16163,    20.567831,   11.4195776,  -5.04598093
  16164,   20.8798027,   12.1995049,  -5.61034966
  16165,   21.2315598,   13.0789003,  -6.02540588
  16166,   21.6093655,   14.0234156,  -6.27860498
  16167,   20.1382256,   10.3455648,  -4.37038755
  16168,   20.3421936,   10.8554831,  -5.05949497
  16169,   20.6039944,   11.5099869,  -5.66523361
  16170,   20.9126835,   12.2817097,  -6.15905571
  16171,   21.2561874,   13.1404667,  -6.52223015
  16172,   21.6224804,   14.0562029,  -6.74377966
  16173,    20.159296,   10.3982391,  -5.17461777
  16174,   20.3749409,   10.9373531,   -5.7652812
  16175,   20.6401596,   11.6003971,  -6.28448582
  16176,   20.9455662,   12.3639145,  -6.70776224
  16177,   21.2808132,    13.202033,  -7.01905441
  16178,   21.6355953,   14.0889902,  -7.20895386
  16179,   20.1803646,   10.4509134,  -5.97884846
  16180,     20.40769,   11.0192232,  -6.47106791
  16181,   20.6763229,   11.6908073,  -6.90373802
  16182,    20.978447,   12.4461193,   -7.2564683
  16183,    21.305439,   13.2635984,  -7.51587868
  16184,   21.6487103,   14.1217775,  -7.67412806
  16185,   20.2014351,   10.5035877,  -6.78307867
  16186,   20.4404373,   11.1010923,  -7.17685413
  16187,   20.7124863,   11.7812176,   -7.5229907
  16188,   21.0113297,   12.5283241,  -7.80517483
  16189,   21.3300667,   13.3251648,  -8.01270294
  16190,   21.6618252,   14.1545649,  -8.13930225
  16191,   20.2225056,    10.556263,  -7.58730888
  16192,   20.4731846,   11.1829624,  -7.88264084
  16193,   20.7486515,   11.8716269,  -8.14224243
  16194,   21.0442123,   12.6105289,  -8.35388088
  16195,   21.3546925,   13.3867302,  -8.50952721
  16196,   21.6749401,   14.1873522,  -8.60447693
  16197,   20.2435741,   10.6089373,  -8.39153957
  16198,   20.5059338,   11.2648325,  -8.58842754
  16199,   20.7848148,   11.9620371,  -8.76149559
  16200,   21.0770931,   12.6927338,  -8.90258694
  16201,   21.3793182,   13.4482965,  -9.00635147
  16202,    21.688055,   14.2201395,   -9.0696516
  16203,   20.2646446,   10.6616116,  -9.19576931
  16204,    20.538681,   11.3467016,  -9.29421329
  16205,   20.8209782,   12.0524473,   -9.3807478
  16206,   21.1099758,   12.7749386,  -9.45129395
  16207,   21.4039459,   13.5098629,  -9.50317574
  16208,     21.70117,   14.2529268,  -9.53482533
  16209,    29.924984,    10.187542,  -1.95769751
  16210,   29.7560501,   10.6098747,  -2.94213629
  16211,   29.5044975,   11.2387581,  -3.80747676
  16212,   29.1859627,   12.0350952,  -4.51293707
  16213,   28.8176937,   12.9557676,  -5.03175688
  16214,   28.4168644,     13.95784,  -5.34825611
  16215,   29.9039135,   10.2402163,  -2.76192784
  16216,   29.7233028,   10.6917448,  -3.64792275
  16217,   29.4683323,   11.3291674,   -4.4267292
  16218,     29.15308,      12.1173,   -5.0616436
  16219,    28.793066,    13.017334,  -5.52858114
  16220,   28.4037495,   13.9906273,  -5.81343079
  16221,    29.882843,   10.2928905,  -3.56615806
  16222,   29.6905537,   10.7736139,  -4.35370922
  16223,    29.432169,   11.4195776,  -5.04598141
  16224,   29.1201973,   12.1995049,  -5.61034966
  16225,   28.7684402,   13.0789003,  -6.02540541
  16226,   28.3906345,   14.0234146,  -6.27860498
  16227,   29.8617744,   10.3455648,  -4.37038803
  16228,   29.6578064,    10.855484,  -5.05949545
  16229,   29.3960056,   11.5099878,  -5.66523361
  16230,   29.0873165,   12.2817097,  -6.15905619
  16231,   28.7438126,   13.1404667,  -6.52223015
  16232,   28.3775196,   14.0562029,  -6.74377918
  16233,    29.840704,   10.3982391,  -5.17461872
  16234,   29.6250591,   10.9373531,  -5.76528168
  16235,   29.3598404,   11.6003971,  -6.28448582
  16236,   29.0544338,   12.3639145,  -6.70776224
  16237,   28.7191868,   13.2020321,  -7.01905441
  16238,   28.3644047,   14.0889902,  -7.20895386
  16239,   29.8196354,   10.4509134,  -5.97884893
  16240,     29.59231,   11.0192232,  -6.47106838
  16241,   29.3236771,   11.6908073,   -6.9037385
  16242,    29.021553,   12.4461193,  -7.25646877
  16243,    28.694561,   13.2635984,  -7.51587868
  16244,   28.3512897,   14.1217775,  -7.67412806
  16245,   29.7985649,   10.5035887,  -6.78307915
  16246,   29.5595627,   11.1010923,  -7.17685461
  16247,   29.2875137,   11.7812176,   -7.5229907
  16248,   28.9886703,   12.5283241,  -7.80517483
  16249,   28.6699333,   13.3251648,  -8.01270294
  16250,   28.3381748,   14.1545649,  -8.13930225
  16251,   29.7774944,    10.556263,  -7.58730936
  16252,   29.5268154,   11.1829624,  -7.88264084
  16253,   29.2513485,   11.8716269,  -8.14224339
  16254,   28.9557877,   12.6105289,  -8.35388088
  16255,   28.6453075,   13.3867302,  -8.50952721
  16256,   28.3250599,   14.1873522,  -8.60447693
  16257,   29.7564259,   10.6089373,  -8.39153957
  16258,   29.4940662,   11.2648325,  -8.58842754
  16259,   29.2151852,   11.9620371,  -8.76149559
  16260,   28.9229069,   12.6927338,  -8.90258789
  16261,   28.6206818,   13.4482965,  -9.00635147
  16262,    28.311945,   14.2201395,   -9.0696516
  16263,   29.7353554,   10.6616116,  -9.19576931
  16264,    29.461319,   11.3467016,  -9.29421329
  16265,   29.1790218,   12.0524473,   -9.3807478
  16266,   28.8900242,   12.7749386,  -9.45129395
  16267,   28.5960541,   13.5098629,  -9.50317574
  16268,     28.29883,   14.2529268,  -9.53482533
  16269,     20.90909,          10., -0.909090936
  16270,    21.818182,          10., -0.909090936
  16271,    22.727272,          10., -0.909090936
  16272,    23.636364,          10., -0.909090936
  16273,    24.545454,          10., -0.909090936
  16274,    25.454546,          10., -0.909090936
  16275,    26.363636,          10., -0.909090936
  16276,    27.272728,          10., -0.909090936
  16277,    28.181818,          10., -0.909090936
  16278,     29.09091,          10., -0.909090936
  16279,     20.90909,          10.,  -1.81818187
  16280,    21.818182,          10.,  -1.81818187
  16281,    22.727272,          10.,  -1.81818187
  16282,    23.636364,          10.,  -1.81818187
  16283,    24.545454,          10.,  -1.81818187
  16284,    25.454546,          10.,  -1.81818187
  16285,    26.363636,          10.,  -1.81818187
  16286,    27.272728,          10.,  -1.81818187
  16287,    28.181818,          10.,  -1.81818187
  16288,     29.09091,          10.,  -1.81818187
  16289,     20.90909,          10.,  -2.72727275
  16290,    21.818182,          10.,  -2.72727275
  16291,    22.727272,          10.,  -2.72727275
  16292,    23.636364,          10.,  -2.72727275
  16293,    24.545454,          10.,  -2.72727275
  16294,    25.454546,          10.,  -2.72727275
  16295,    26.363636,          10.,  -2.72727275
  16296,    27.272728,          10.,  -2.72727275
  16297,    28.181818,          10.,  -2.72727275
  16298,     29.09091,          10.,  -2.72727275
  16299,     20.90909,          10.,  -3.63636374
  16300,    21.818182,          10.,  -3.63636374
  16301,    22.727272,          10.,  -3.63636374
  16302,    23.636364,          10.,  -3.63636374
  16303,    24.545454,          10.,  -3.63636374
  16304,    25.454546,          10.,  -3.63636374
  16305,    26.363636,          10.,  -3.63636374
  16306,    27.272728,          10.,  -3.63636374
  16307,    28.181818,          10.,  -3.63636374
  16308,     29.09091,          10.,  -3.63636374
  16309,     20.90909,          10.,   -4.5454545
  16310,    21.818182,          10.,   -4.5454545
  16311,    22.727272,          10.,   -4.5454545
  16312,    23.636364,          10.,   -4.5454545
  16313,    24.545454,          10.,   -4.5454545
  16314,    25.454546,          10.,   -4.5454545
  16315,    26.363636,          10.,   -4.5454545
  16316,    27.272728,          10.,   -4.5454545
  16317,    28.181818,          10.,   -4.5454545
  16318,     29.09091,          10.,   -4.5454545
  16319,     20.90909,          10.,   -5.4545455
  16320,    21.818182,          10.,   -5.4545455
  16321,    22.727272,          10.,   -5.4545455
  16322,    23.636364,          10.,   -5.4545455
  16323,    24.545454,          10.,   -5.4545455
  16324,    25.454546,          10.,   -5.4545455
  16325,    26.363636,          10.,   -5.4545455
  16326,    27.272728,          10.,   -5.4545455
  16327,    28.181818,          10.,   -5.4545455
  16328,     29.09091,          10.,   -5.4545455
  16329,     20.90909,          10.,  -6.36363649
  16330,    21.818182,          10.,  -6.36363649
  16331,    22.727272,          10.,  -6.36363649
  16332,    23.636364,          10.,  -6.36363649
  16333,    24.545454,          10.,  -6.36363649
  16334,    25.454546,          10.,  -6.36363649
  16335,    26.363636,          10.,  -6.36363649
  16336,    27.272728,          10.,  -6.36363649
  16337,    28.181818,          10.,  -6.36363649
  16338,     29.09091,          10.,  -6.36363649
  16339,     20.90909,          10.,  -7.27272749
  16340,    21.818182,          10.,  -7.27272749
  16341,    22.727272,          10.,  -7.27272749
  16342,    23.636364,          10.,  -7.27272749
  16343,    24.545454,          10.,  -7.27272749
  16344,    25.454546,          10.,  -7.27272749
  16345,    26.363636,          10.,  -7.27272749
  16346,    27.272728,          10.,  -7.27272749
  16347,    28.181818,          10.,  -7.27272749
  16348,     29.09091,          10.,  -7.27272749
  16349,     20.90909,          10.,  -8.18181801
  16350,    21.818182,          10.,  -8.18181801
  16351,    22.727272,          10.,  -8.18181801
  16352,    23.636364,          10.,  -8.18181801
  16353,    24.545454,          10.,  -8.18181801
  16354,    25.454546,          10.,  -8.18181801
  16355,    26.363636,          10.,  -8.18181801
  16356,    27.272728,          10.,  -8.18181801
  16357,    28.181818,          10.,  -8.18181801
  16358,     29.09091,          10.,  -8.18181801
  16359,     20.90909,          10.,    -9.090909
  16360,    21.818182,          10.,    -9.090909
  16361,    22.727272,          10.,    -9.090909
  16362,    23.636364,          10.,    -9.090909
  16363,    24.545454,          10.,    -9.090909
  16364,    25.454546,          10.,    -9.090909
  16365,    26.363636,          10.,    -9.090909
  16366,    27.272728,          10.,    -9.090909
  16367,    28.181818,          10.,    -9.090909
  16368,     29.09091,          10.,    -9.090909
  16369,   -28.886364,       19.375,         -10.
  16370,   -28.022728,       19.375,         -10.
  16371,    -27.15909,       19.375,         -10.
  16372,   -26.295454,       19.375,         -10.
  16373,   -25.431818,       19.375,         -10.
  16374,   -24.568182,       19.375,         -10.
  16375,   -23.704546,       19.375,         -10.
  16376,    -22.84091,       19.375,         -10.
  16377,   -21.977272,       19.375,         -10.
  16378,   -21.113636,       19.375,         -10.
  16379,   -28.681818,        18.75,         -10.
  16380,   -27.863636,        18.75,         -10.
  16381,   -27.045454,        18.75,         -10.
  16382,   -26.227272,        18.75,         -10.
  16383,    -25.40909,        18.75,         -10.
  16384,    -24.59091,        18.75,         -10.
  16385,   -23.772728,        18.75,         -10.
  16386,   -22.954546,        18.75,         -10.
  16387,   -22.136364,        18.75,         -10.
  16388,   -21.318182,        18.75,         -10.
  16389,   -28.477272,       18.125,         -10.
  16390,   -27.704546,       18.125,         -10.
  16391,   -26.931818,       18.125,         -10.
  16392,    -26.15909,       18.125,         -10.
  16393,   -25.386364,       18.125,         -10.
  16394,   -24.613636,       18.125,         -10.
  16395,    -23.84091,       18.125,         -10.
  16396,   -23.068182,       18.125,         -10.
  16397,   -22.295454,       18.125,         -10.
  16398,   -21.522728,       18.125,         -10.
  16399,   -28.272728,         17.5,         -10.
  16400,   -27.545454,         17.5,         -10.
  16401,   -26.818182,         17.5,         -10.
  16402,    -26.09091,         17.5,         -10.
  16403,   -25.363636,         17.5,         -10.
  16404,   -24.636364,         17.5,         -10.
  16405,    -23.90909,         17.5,         -10.
  16406,   -23.181818,         17.5,         -10.
  16407,   -22.454546,         17.5,         -10.
  16408,   -21.727272,         17.5,         -10.
  16409,   -28.068182,       16.875,         -10.
  16410,   -27.386364,       16.875,         -10.
  16411,   -26.704546,       16.875,         -10.
  16412,   -26.022728,       16.875,         -10.
  16413,    -25.34091,       16.875,         -10.
  16414,    -24.65909,       16.875,         -10.
  16415,   -23.977272,       16.875,         -10.
  16416,   -23.295454,       16.875,         -10.
  16417,   -22.613636,       16.875,         -10.
  16418,   -21.931818,       16.875,         -10.
  16419,   -27.863636,        16.25,         -10.
  16420,   -27.227272,        16.25,         -10.
  16421,    -26.59091,        16.25,         -10.
  16422,   -25.954546,        16.25,         -10.
  16423,   -25.318182,        16.25,         -10.
  16424,   -24.681818,        16.25,         -10.
  16425,   -24.045454,        16.25,         -10.
  16426,    -23.40909,        16.25,         -10.
  16427,   -22.772728,        16.25,         -10.
  16428,   -22.136364,        16.25,         -10.
  16429,    -27.65909,       15.625,         -10.
  16430,   -27.068182,       15.625,         -10.
  16431,   -26.477272,       15.625,         -10.
  16432,   -25.886364,       15.625,         -10.
  16433,   -25.295454,       15.625,         -10.
  16434,   -24.704546,       15.625,         -10.
  16435,   -24.113636,       15.625,         -10.
  16436,   -23.522728,       15.625,         -10.
  16437,   -22.931818,       15.625,         -10.
  16438,    -22.34091,       15.625,         -10.
  16439,  -29.0570583,   19.8965645,  -1.01175869
  16440,   -28.155489,   19.8965645,  -1.01175857
  16441,  -27.2539215,   19.8965645,  -1.01175833
  16442,  -26.3523521,   19.8965645,  -1.01175809
  16443,  -25.4507847,   19.8965645,  -1.01175797
  16444,  -24.5492153,   19.8965645,  -1.01175773
  16445,  -23.6476479,   19.8965645,  -1.01175761
  16446,  -22.7460785,   19.8965645,  -1.01175749
  16447,   -21.844511,   19.8965645,  -1.01175725
  16448,  -20.9429417,   19.8965645,  -1.01175714
  16449,  -28.9577293,   19.5930634,  -1.97579682
  16450,  -28.0782337,   19.5930634,  -1.97579658
  16451,  -27.1987381,   19.5930634,  -1.97579646
  16452,  -26.3192425,   19.5930634,  -1.97579634
  16453,  -25.4397469,   19.5930634,  -1.97579622
  16454,  -24.5602512,   19.5930634,   -1.9757961
  16455,  -23.6807575,   19.5930634,   -1.9757961
  16456,  -22.8012619,   19.5930634,  -1.97579598
  16457,  -21.9217663,   19.5930634,  -1.97579587
  16458,  -21.0422707,   19.5930634,  -1.97579575
  16459,  -28.7990932,   19.1083412,  -2.84982967
  16460,  -27.9548512,   19.1083412,  -2.84982967
  16461,  -27.1106071,   19.1083412,  -2.84982967
  16462,  -26.2663651,   19.1083412,  -2.84982967
  16463,   -25.422121,   19.1083412,  -2.84982967
  16464,   -24.577879,   19.1083412,  -2.84982944
  16465,  -23.7336349,   19.1083412,  -2.84982944
  16466,  -22.8893929,   19.1083412,  -2.84982944
  16467,  -22.0451488,   19.1083412,  -2.84982944
  16468,  -21.2009068,   19.1083412,  -2.84982944
  16469,  -28.5900097,   18.4694748,  -3.60038114
  16470,  -27.7922306,   18.4694748,  -3.60038114
  16471,  -26.9944496,   18.4694748,  -3.60038114
  16472,  -26.1966705,   18.4694748,  -3.60038114
  16473,  -25.3988895,   18.4694748,  -3.60038114
  16474,  -24.6011105,   18.4694748,  -3.60038114
  16475,  -23.8033295,   18.4694748,  -3.60038137
  16476,  -23.0055504,   18.4694748,  -3.60038137
  16477,  -22.2077694,   18.4694748,  -3.60038137
  16478,  -21.4099903,   18.4694748,  -3.60038137
  16479,   -28.340662,   17.7075768,  -4.20345449
  16480,  -27.5982914,   17.7075768,  -4.20345449
  16481,  -26.8559227,   17.7075768,  -4.20345449
  16482,   -26.113554,   17.7075768,  -4.20345449
  16483,  -25.3711853,   17.7075768,  -4.20345449
  16484,  -24.6288147,   17.7075748,  -4.20345545
  16485,   -23.886446,   17.7075748,  -4.20345545
  16486,  -23.1440773,   17.7075748,  -4.20345545
  16487,  -22.4017086,   17.7075748,  -4.20345545
  16488,  -21.6593399,   17.7075748,  -4.20345545
  16489,  -28.0615292,   16.8546734,  -4.64329481
  16490,  -27.3811893,   16.8546734,  -4.64329481
  16491,  -26.7008495,   16.8546734,  -4.64329481
  16492,  -26.0205097,   16.8546734,  -4.64329481
  16493,  -25.3401699,   16.8546715,  -4.64329576
  16494,  -24.6598301,   16.8546715,  -4.64329576
  16495,  -23.9794903,   16.8546715,  -4.64329576
  16496,  -23.2991505,   16.8546715,  -4.64329576
  16497,  -22.6188107,   16.8546715,  -4.64329576
  16498,  -21.9384708,   16.8546715,  -4.64329576
  16499,  -27.7628613,   15.9420786,  -4.91044664
  16500,  -27.1488934,   15.9420786,  -4.91044664
  16501,  -26.5349236,   15.9420786,  -4.91044664
  16502,  -25.9209538,   15.9420776,  -4.91044712
  16503,  -25.3069859,   15.9420776,  -4.91044712
  16504,  -24.6930161,   15.9420776,  -4.91044712
  16505,  -24.0790462,   15.9420776,  -4.91044712
  16506,  -23.4650764,   15.9420776,  -4.91044712
  16507,  -22.8511086,   15.9420776,  -4.91044712
  16508,  -22.2371387,   15.9420776,  -4.91044712
  16509,  -29.7689667,   19.4224148,  -9.18288708
  16510,  -29.5306568,    18.826643,  -9.27052689
  16511,   -29.285759,   18.2143955,  -9.34998417
  16512,  -29.0352535,   17.5881348,  -9.41821671
  16513,  -28.7802753,   16.9506893,  -9.47304153
  16514,  -28.5219879,   16.3049698,  -9.51302719
  16515,  -28.2615299,   15.6538258,  -9.53731346
  16516,  -29.7879314,   19.4698296,  -8.36577415
  16517,  -29.5613136,   18.9032841,  -8.54105377
  16518,   -29.321516,   18.3037891,  -8.69996929
  16519,   -29.070507,   17.6762676,  -8.83643246
  16520,  -28.8105507,   17.0263767,  -8.94608307
  16521,  -28.5439758,   16.3599415,  -9.02605343
  16522,  -28.2730598,   15.6826506,  -9.07462692
  16523,  -29.8068981,   19.5172443,  -7.54866171
  16524,  -29.5919704,   18.9799271,  -7.81158113
  16525,  -29.3572731,   18.3931847,  -8.04995346
  16526,  -29.1057606,   17.7644024,  -8.25464916
  16527,   -28.840826,    17.102066,  -8.41912365
  16528,  -28.5659637,   16.4149113,  -8.53908062
  16529,  -28.2845898,   15.7114763,  -8.61194038
  16530,  -29.8258629,   19.5646591,  -6.73154879
  16531,  -29.6226273,   19.0565681,  -7.08210802
  16532,  -29.3930321,   18.4825783,  -7.39993811
  16533,  -29.1410141,   17.8525372,  -7.67286587
  16534,  -28.8711014,   17.1777554,  -7.89216518
  16535,  -28.5879517,   16.4698811,  -8.05210686
  16536,  -28.2961197,   15.7403011,  -8.14925385
  16537,  -29.8448296,   19.6120739,  -5.91443586
  16538,  -29.6532841,   19.1332111,  -6.35263491
  16539,  -29.4287891,   18.5719738,  -6.74992228
  16540,  -29.1762676,     17.94067,   -7.0910821
  16541,  -28.9013786,   17.2534447,  -7.36520672
  16542,  -28.6099396,   16.5248508,  -7.56513405
  16543,  -28.3076515,   15.7691269,  -7.68656683
  16544,  -29.8637962,   19.6594906,  -5.09732294
  16545,  -29.6839409,   19.2098522,  -5.62316179
  16546,  -29.4645462,   18.6613674,  -6.09990692
  16547,  -29.2115211,   18.0288048,   -6.5092988
  16548,  -28.9316521,   17.3291321,  -6.83824778
  16549,  -28.6319294,   16.5798225,  -7.07816076
  16550,  -28.3191814,   15.7979517,  -7.22388029
  16551,  -29.8827629,   19.7069054,  -4.28021002
  16552,  -29.7145977,   19.2864952,  -4.89368916
  16553,  -29.5003052,   18.7507629,  -5.44989157
  16554,  -29.2467766,   18.1169395,  -5.92751503
  16555,  -28.9619293,   17.4048214,  -6.31128931
  16556,  -28.6539173,   16.6347923,  -6.59118748
  16557,  -28.3307114,   15.8267775,  -6.76119328
  16558,  -29.9017277,   19.7543201,  -3.46309733
  16559,  -29.7452545,   19.3631363,  -4.16421604
  16560,  -29.5360641,   18.8401585,  -4.79987574
  16561,  -29.2820282,   18.2050724,  -5.34573174
  16562,  -28.9922047,   17.4805107,  -5.78433037
  16563,  -28.6759052,   16.6897621,  -6.10421467
  16564,  -28.3422413,   15.8556023,  -6.29850674
  16565,  -29.9206944,   19.8017349,  -2.64598465
  16566,  -29.7759113,   19.4397793,  -3.43474293
  16567,  -29.5718212,   18.9295521,  -4.14986038
  16568,  -29.3172836,   18.2932072,  -4.76394796
  16569,    -29.02248,   17.5561981,   -5.2573719
  16570,  -28.6978931,   16.7447319,  -5.61724138
  16571,  -28.3537712,    15.884428,   -5.8358202
  16572,  -29.9396591,   19.8491497,  -1.82887173
  16573,  -29.8065681,   19.5164204,  -2.70527005
  16574,  -29.6075783,   19.0189476,  -3.49984503
  16575,  -29.3525372,   18.3813419,  -4.18216419
  16576,  -29.0527554,   17.6318874,  -4.73041344
  16577,  -28.7198811,   16.7997036,   -5.1302681
  16578,  -28.3653011,   15.9132538,  -5.37313366
  16579,  -20.2310333,   19.4224148,  -9.18288708
  16580,  -20.4693432,    18.826643,  -9.27052689
  16581,   -20.714241,   18.2143955,  -9.34998417
  16582,  -20.9647465,   17.5881348,  -9.41821671
  16583,  -21.2197247,   16.9506893,  -9.47304153
  16584,  -21.4780121,   16.3049698,  -9.51302719
  16585,  -21.7384701,   15.6538248,  -9.53731346
  16586,  -20.2120686,   19.4698296,  -8.36577415
  16587,  -20.4386864,   18.9032841,  -8.54105377
  16588,   -20.678484,   18.3037891,  -8.69996929
  16589,   -20.929493,   17.6762676,  -8.83643341
  16590,  -21.1894493,   17.0263767,  -8.94608307
  16591,  -21.4560242,   16.3599396,  -9.02605343
  16592,  -21.7269402,   15.6826506,  -9.07462692
  16593,  -20.1931019,   19.5172443,  -7.54866076
  16594,  -20.4080296,   18.9799271,  -7.81158066
  16595,  -20.6427269,   18.3931847,  -8.04995346
  16596,  -20.8942394,   17.7644024,  -8.25464916
  16597,   -21.159174,    17.102066,   -8.4191246
  16598,  -21.4340363,   16.4149113,  -8.53908062
  16599,  -21.7154102,   15.7114754,  -8.61194038
  16600,  -20.1741371,   19.5646591,  -6.73154783
  16601,  -20.3773727,   19.0565681,  -7.08210754
  16602,  -20.6069679,   18.4825783,  -7.39993811
  16603,  -20.8589859,   17.8525352,  -7.67286587
  16604,  -21.1288986,   17.1777554,  -7.89216566
  16605,  -21.4120483,   16.4698811,  -8.05210781
  16606,  -21.7038803,   15.7403011,  -8.14925385
  16607,  -20.1551704,   19.6120758,  -5.91443491
  16608,  -20.3467159,   19.1332111,  -6.35263443
  16609,  -20.5712109,   18.5719738,  -6.74992228
  16610,  -20.8237324,     17.94067,  -7.09108257
  16611,  -21.0986233,   17.2534428,  -7.36520672
  16612,  -21.3900604,   16.5248508,  -7.56513453
  16613,  -21.6923504,   15.7691259,  -7.68656683
  16614,  -20.1362038,   19.6594906,  -5.09732199
  16615,  -20.3160591,   19.2098522,  -5.62316132
  16616,  -20.5354538,   18.6613674,  -6.09990692
  16617,  -20.7884789,   18.0288048,   -6.5092988
  16618,  -21.0683479,   17.3291321,  -6.83824825
  16619,  -21.3680725,   16.5798206,  -7.07816124
  16620,  -21.6808205,   15.7979507,  -7.22388029
  16621,  -20.1172371,   19.7069054,  -4.28020906
  16622,  -20.2854023,   19.2864952,   -4.8936882
  16623,  -20.4996948,   18.7507629,  -5.44989109
  16624,  -20.7532253,   18.1169376,  -5.92751551
  16625,  -21.0380707,   17.4048214,  -6.31128979
  16626,  -21.3460846,   16.6347904,  -6.59118795
  16627,  -21.6692886,   15.8267765,  -6.76119375
  16628,  -20.0982723,   19.7543201,   -3.4630959
  16629,  -20.2547455,   19.3631363,  -4.16421509
  16630,  -20.4639359,   18.8401585,  -4.79987574
  16631,  -20.7179718,   18.2050724,  -5.34573221
  16632,  -21.0077972,   17.4805088,  -5.78433084
  16633,  -21.3240967,   16.6897602,  -6.10421515
  16634,  -21.6577587,   15.8556013,  -6.29850721
  16635,  -20.0793056,   19.8017349,  -2.64598274
  16636,  -20.2240887,   19.4397793,  -3.43474174
  16637,  -20.4281788,   18.9295521,  -4.14986038
  16638,  -20.6827164,   18.2932072,  -4.76394844
  16639,    -20.97752,   17.5561981,  -5.25737238
  16640,  -21.3021069,   16.7447319,  -5.61724186
  16641,  -21.6462288,   15.8844271,   -5.8358202
  16642,  -20.0603409,   19.8491497,  -1.82886982
  16643,  -20.1934319,   19.5164223,  -2.70526862
  16644,  -20.3924217,   19.0189476,  -3.49984479
  16645,  -20.6474648,     18.38134,  -4.18216515
  16646,  -20.9472446,   17.6318874,  -4.73041391
  16647,  -21.2801189,   16.7997017,  -5.13026857
  16648,  -21.6346989,   15.9132519,  -5.37313366
  16649,   -27.454546,          15.,  -9.54545498
  16650,    -26.90909,          15.,  -9.54545498
  16651,   -26.363636,          15.,  -9.54545498
  16652,   -25.818182,          15.,  -9.54545498
  16653,   -25.272728,          15.,  -9.54545498
  16654,   -24.727272,          15.,  -9.54545498
  16655,   -24.181818,          15.,  -9.54545498
  16656,   -23.636364,          15.,  -9.54545498
  16657,    -23.09091,          15.,  -9.54545498
  16658,   -22.545454,          15.,  -9.54545498
  16659,   -27.454546,          15.,    -9.090909
  16660,    -26.90909,          15.,    -9.090909
  16661,   -26.363636,          15.,    -9.090909
  16662,   -25.818182,          15.,    -9.090909
  16663,   -25.272728,          15.,    -9.090909
  16664,   -24.727272,          15.,    -9.090909
  16665,   -24.181818,          15.,    -9.090909
  16666,   -23.636364,          15.,    -9.090909
  16667,    -23.09091,          15.,    -9.090909
  16668,   -22.545454,          15.,    -9.090909
  16669,   -27.454546,          15.,  -8.63636398
  16670,    -26.90909,          15.,  -8.63636398
  16671,   -26.363636,          15.,  -8.63636398
  16672,   -25.818182,          15.,  -8.63636398
  16673,   -25.272728,          15.,  -8.63636398
  16674,   -24.727272,          15.,  -8.63636398
  16675,   -24.181818,          15.,  -8.63636398
  16676,   -23.636364,          15.,  -8.63636398
  16677,    -23.09091,          15.,  -8.63636398
  16678,   -22.545454,          15.,  -8.63636398
  16679,   -27.454546,          15.,  -8.18181801
  16680,    -26.90909,          15.,  -8.18181801
  16681,   -26.363636,          15.,  -8.18181801
  16682,   -25.818182,          15.,  -8.18181801
  16683,   -25.272728,          15.,  -8.18181801
  16684,   -24.727272,          15.,  -8.18181801
  16685,   -24.181818,          15.,  -8.18181801
  16686,   -23.636364,          15.,  -8.18181801
  16687,    -23.09091,          15.,  -8.18181801
  16688,   -22.545454,          15.,  -8.18181801
  16689,   -27.454546,          15.,  -7.72727251
  16690,    -26.90909,          15.,  -7.72727251
  16691,   -26.363636,          15.,  -7.72727251
  16692,   -25.818182,          15.,  -7.72727251
  16693,   -25.272728,          15.,  -7.72727251
  16694,   -24.727272,          15.,  -7.72727251
  16695,   -24.181818,          15.,  -7.72727251
  16696,   -23.636364,          15.,  -7.72727251
  16697,    -23.09091,          15.,  -7.72727251
  16698,   -22.545454,          15.,  -7.72727251
  16699,   -27.454546,          15.,  -7.27272749
  16700,    -26.90909,          15.,  -7.27272749
  16701,   -26.363636,          15.,  -7.27272749
  16702,   -25.818182,          15.,  -7.27272749
  16703,   -25.272728,          15.,  -7.27272749
  16704,   -24.727272,          15.,  -7.27272749
  16705,   -24.181818,          15.,  -7.27272749
  16706,   -23.636364,          15.,  -7.27272749
  16707,    -23.09091,          15.,  -7.27272749
  16708,   -22.545454,          15.,  -7.27272749
  16709,   -27.454546,          15.,  -6.81818199
  16710,    -26.90909,          15.,  -6.81818199
  16711,   -26.363636,          15.,  -6.81818199
  16712,   -25.818182,          15.,  -6.81818199
  16713,   -25.272728,          15.,  -6.81818199
  16714,   -24.727272,          15.,  -6.81818199
  16715,   -24.181818,          15.,  -6.81818199
  16716,   -23.636364,          15.,  -6.81818199
  16717,    -23.09091,          15.,  -6.81818199
  16718,   -22.545454,          15.,  -6.81818199
  16719,   -27.454546,          15.,  -6.36363649
  16720,    -26.90909,          15.,  -6.36363649
  16721,   -26.363636,          15.,  -6.36363649
  16722,   -25.818182,          15.,  -6.36363649
  16723,   -25.272728,          15.,  -6.36363649
  16724,   -24.727272,          15.,  -6.36363649
  16725,   -24.181818,          15.,  -6.36363649
  16726,   -23.636364,          15.,  -6.36363649
  16727,    -23.09091,          15.,  -6.36363649
  16728,   -22.545454,          15.,  -6.36363649
  16729,   -27.454546,          15.,    -5.909091
  16730,    -26.90909,          15.,    -5.909091
  16731,   -26.363636,          15.,    -5.909091
  16732,   -25.818182,          15.,    -5.909091
  16733,   -25.272728,          15.,    -5.909091
  16734,   -24.727272,          15.,    -5.909091
  16735,   -24.181818,          15.,    -5.909091
  16736,   -23.636364,          15.,    -5.909091
  16737,    -23.09091,          15.,    -5.909091
  16738,   -22.545454,          15.,    -5.909091
  16739,   -27.454546,          15.,   -5.4545455
  16740,    -26.90909,          15.,   -5.4545455
  16741,   -26.363636,          15.,   -5.4545455
  16742,   -25.818182,          15.,   -5.4545455
  16743,   -25.272728,          15.,   -5.4545455
  16744,   -24.727272,          15.,   -5.4545455
  16745,   -24.181818,          15.,   -5.4545455
  16746,   -23.636364,          15.,   -5.4545455
  16747,    -23.09091,          15.,   -5.4545455
  16748,   -22.545454,          15.,   -5.4545455
  16749,  -20.2310333,   10.5775852,   9.18288708
  16750,  -20.2120686,   10.5301704,   8.36577415
  16751,  -20.1931019,   10.4827547,   7.54866076
  16752,  -20.1741352,   10.4353399,   6.73154783
  16753,  -20.1551704,   10.3879251,   5.91443491
  16754,  -20.1362038,   10.3405104,   5.09732199
  16755,  -20.1172371,   10.2930946,   4.28020906
  16756,  -20.0982723,   10.2456799,    3.4630959
  16757,  -20.0793056,   10.1982651,   2.64598274
  16758,  -20.0603409,   10.1508503,   1.82886982
  16759,  -20.4693432,    11.173358,   9.27052689
  16760,  -20.4386864,   11.0967159,   8.54105377
  16761,  -20.4080296,   11.0200739,   7.81158066
  16762,  -20.3773727,   10.9434319,   7.08210754
  16763,  -20.3467159,   10.8667889,   6.35263443
  16764,  -20.3160591,   10.7901468,   5.62316132
  16765,  -20.2854023,   10.7135048,    4.8936882
  16766,  -20.2547455,   10.6368628,   4.16421509
  16767,  -20.2240887,   10.5602207,   3.43474174
  16768,  -20.1934319,   10.4835787,   2.70526862
  16769,  -20.7142429,   11.7856054,   9.34998417
  16770,   -20.678484,   11.6962109,   8.69996929
  16771,  -20.6427269,   11.6068163,   8.04995346
  16772,  -20.6069679,   11.5174208,   7.39993811
  16773,  -20.5712109,   11.4280262,   6.74992228
  16774,  -20.5354519,   11.3386316,   6.09990692
  16775,  -20.4996948,   11.2492371,   5.44989109
  16776,  -20.4639378,   11.1598425,   4.79987574
  16777,  -20.4281788,   11.0704479,   4.14986038
  16778,  -20.3924217,   10.9810524,   3.49984479
  16779,  -20.9647465,   12.4118662,   9.41821671
  16780,   -20.929493,   12.3237324,   8.83643341
  16781,  -20.8942394,   12.2355976,   8.25464916
  16782,  -20.8589859,   12.1474638,   7.67286587
  16783,  -20.8237324,     12.05933,   7.09108257
  16784,  -20.7884789,   11.9711962,    6.5092988
  16785,  -20.7532253,   11.8830614,   5.92751551
  16786,  -20.7179718,   11.7949276,   5.34573221
  16787,  -20.6827183,   11.7067938,   4.76394844
  16788,  -20.6474648,     11.61866,   4.18216515
  16789,  -21.2197247,   13.0493116,   9.47304153
  16790,  -21.1894493,   12.9736223,   8.94608307
  16791,   -21.159174,    12.897934,    8.4191246
  16792,  -21.1288986,   12.8222456,   7.89216566
  16793,  -21.0986233,   12.7465563,   7.36520672
  16794,  -21.0683479,   12.6708679,   6.83824825
  16795,  -21.0380726,   12.5951796,   6.31128979
  16796,  -21.0077953,   12.5194902,   5.78433084
  16797,    -20.97752,   12.4438019,   5.25737238
  16798,  -20.9472446,   12.3681135,   4.73041391
  16799,  -21.4780121,   13.6950302,   9.51302719
  16800,  -21.4560242,   13.6400595,   9.02605343
  16801,  -21.4340363,   13.5850897,   8.53908062
  16802,  -21.4120483,   13.5301199,   8.05210781
  16803,  -21.3900604,   13.4751492,   7.56513453
  16804,  -21.3680725,   13.4201794,   7.07816124
  16805,  -21.3460846,   13.3652096,   6.59118795
  16806,  -21.3240948,   13.3102388,   6.10421515
  16807,  -21.3021069,   13.2552691,   5.61724186
  16808,  -21.2801189,   13.2002983,   5.13026857
  16809,  -21.7384701,   14.3461752,   9.53731346
  16810,  -21.7269402,   14.3173494,   9.07462692
  16811,  -21.7154102,   14.2885246,   8.61194038
  16812,  -21.7038803,   14.2596989,   8.14925385
  16813,  -21.6923504,   14.2308741,   7.68656683
  16814,  -21.6808205,   14.2020493,   7.22388029
  16815,  -21.6692886,   14.1732235,   6.76119375
  16816,  -21.6577587,   14.1443987,   6.29850721
  16817,  -21.6462288,   14.1155729,    5.8358202
  16818,  -21.6346989,   14.0867481,   5.37313366
  16819,  -29.7689667,   10.5775852,   9.18288708
  16820,  -29.7879314,   10.5301704,   8.36577415
  16821,  -29.8068981,   10.4827547,   7.54866171
  16822,  -29.8258648,   10.4353399,   6.73154879
  16823,  -29.8448296,   10.3879251,   5.91443586
  16824,  -29.8637962,   10.3405104,   5.09732294
  16825,   -29.882761,   10.2930956,   4.28021002
  16826,  -29.9017277,   10.2456808,   3.46309733
  16827,  -29.9206944,   10.1982651,   2.64598465
  16828,  -29.9396591,   10.1508503,   1.82887173
  16829,  -29.5306568,    11.173358,   9.27052689
  16830,  -29.5613136,   11.0967159,   8.54105377
  16831,  -29.5919704,   11.0200739,   7.81158113
  16832,  -29.6226273,   10.9434319,   7.08210802
  16833,  -29.6532841,   10.8667898,   6.35263491
  16834,  -29.6839409,   10.7901478,   5.62316179
  16835,  -29.7145977,   10.7135057,   4.89368916
  16836,  -29.7452545,   10.6368637,   4.16421604
  16837,  -29.7759113,   10.5602217,   3.43474293
  16838,  -29.8065681,   10.4835796,   2.70527005
  16839,  -29.2857571,   11.7856054,   9.34998417
  16840,   -29.321516,   11.6962109,   8.69996929
  16841,  -29.3572731,   11.6068163,   8.04995346
  16842,  -29.3930321,   11.5174208,   7.39993811
  16843,  -29.4287891,   11.4280262,   6.74992228
  16844,  -29.4645481,   11.3386316,   6.09990692
  16845,  -29.5003052,   11.2492371,   5.44989157
  16846,  -29.5360622,   11.1598425,   4.79987574
  16847,  -29.5718212,   11.0704479,   4.14986038
  16848,  -29.6075783,   10.9810534,   3.49984503
  16849,  -29.0352535,   12.4118662,   9.41821671
  16850,   -29.070507,   12.3237314,   8.83643246
  16851,  -29.1057606,   12.2355976,   8.25464916
  16852,  -29.1410141,   12.1474638,   7.67286587
  16853,  -29.1762676,    12.059329,    7.0910821
  16854,  -29.2115211,   11.9711952,    6.5092988
  16855,  -29.2467747,   11.8830614,   5.92751503
  16856,  -29.2820282,   11.7949276,   5.34573174
  16857,  -29.3172836,   11.7067928,   4.76394796
  16858,  -29.3525372,    11.618659,   4.18216419
  16859,  -28.7802753,   13.0493116,   9.47304153
  16860,  -28.8105507,   12.9736223,   8.94608307
  16861,   -28.840826,    12.897934,   8.41912365
  16862,  -28.8711014,   12.8222446,   7.89216518
  16863,  -28.9013767,   12.7465563,   7.36520672
  16864,  -28.9316521,   12.6708679,   6.83824778
  16865,  -28.9619293,   12.5951786,   6.31128931
  16866,  -28.9922047,   12.5194902,   5.78433037
  16867,    -29.02248,   12.4438009,    5.2573719
  16868,  -29.0527554,   12.3681126,   4.73041344
  16869,  -28.5219879,   13.6950293,   9.51302719
  16870,  -28.5439758,   13.6400595,   9.02605343
  16871,  -28.5659637,   13.5850887,   8.53908062
  16872,  -28.5879517,   13.5301189,   8.05210686
  16873,  -28.6099415,   13.4751482,   7.56513405
  16874,  -28.6319294,   13.4201784,   7.07816076
  16875,  -28.6539173,   13.3652077,   6.59118748
  16876,  -28.6759052,   13.3102379,   6.10421467
  16877,  -28.6978931,   13.2552671,   5.61724138
  16878,  -28.7198811,   13.2002974,    5.1302681
  16879,  -28.2615299,   14.3461742,   9.53731346
  16880,  -28.2730598,   14.3173494,   9.07462692
  16881,  -28.2845898,   14.2885237,   8.61194038
  16882,  -28.2961197,   14.2596989,   8.14925385
  16883,  -28.3076515,   14.2308731,   7.68656683
  16884,  -28.3191814,   14.2020483,   7.22388029
  16885,  -28.3307114,   14.1732225,   6.76119328
  16886,  -28.3422413,   14.1443977,   6.29850674
  16887,  -28.3537712,    14.115572,    5.8358202
  16888,  -28.3653011,   14.0867462,   5.37313366
  16889,   -21.113636,       10.625,          10.
  16890,   -21.318182,        11.25,          10.
  16891,   -21.522728,       11.875,          10.
  16892,   -21.727272,         12.5,          10.
  16893,   -21.931818,       13.125,          10.
  16894,   -22.136364,        13.75,          10.
  16895,    -22.34091,       14.375,          10.
  16896,   -21.977272,       10.625,          10.
  16897,   -22.136364,        11.25,          10.
  16898,   -22.295454,       11.875,          10.
  16899,   -22.454546,         12.5,          10.
  16900,   -22.613636,       13.125,          10.
  16901,   -22.772728,        13.75,          10.
  16902,   -22.931818,       14.375,          10.
  16903,    -22.84091,       10.625,          10.
  16904,   -22.954546,        11.25,          10.
  16905,   -23.068182,       11.875,          10.
  16906,   -23.181818,         12.5,          10.
  16907,   -23.295454,       13.125,          10.
  16908,    -23.40909,        13.75,          10.
  16909,   -23.522728,       14.375,          10.
  16910,   -23.704546,       10.625,          10.
  16911,   -23.772728,        11.25,          10.
  16912,    -23.84091,       11.875,          10.
  16913,    -23.90909,         12.5,          10.
  16914,   -23.977272,       13.125,          10.
  16915,   -24.045454,        13.75,          10.
  16916,   -24.113636,       14.375,          10.
  16917,   -24.568182,       10.625,          10.
  16918,    -24.59091,        11.25,          10.
  16919,   -24.613636,       11.875,          10.
  16920,   -24.636364,         12.5,          10.
  16921,    -24.65909,       13.125,          10.
  16922,   -24.681818,        13.75,          10.
  16923,   -24.704546,       14.375,          10.
  16924,   -25.431818,       10.625,          10.
  16925,    -25.40909,        11.25,          10.
  16926,   -25.386364,       11.875,          10.
  16927,   -25.363636,         12.5,          10.
  16928,    -25.34091,       13.125,          10.
  16929,   -25.318182,        13.75,          10.
  16930,   -25.295454,       14.375,          10.
  16931,   -26.295454,       10.625,          10.
  16932,   -26.227272,        11.25,          10.
  16933,    -26.15909,       11.875,          10.
  16934,    -26.09091,         12.5,          10.
  16935,   -26.022728,       13.125,          10.
  16936,   -25.954546,        13.75,          10.
  16937,   -25.886364,       14.375,          10.
  16938,    -27.15909,       10.625,          10.
  16939,   -27.045454,        11.25,          10.
  16940,   -26.931818,       11.875,          10.
  16941,   -26.818182,         12.5,          10.
  16942,   -26.704546,       13.125,          10.
  16943,    -26.59091,        13.75,          10.
  16944,   -26.477272,       14.375,          10.
  16945,   -28.022728,       10.625,          10.
  16946,   -27.863636,        11.25,          10.
  16947,   -27.704546,       11.875,          10.
  16948,   -27.545454,         12.5,          10.
  16949,   -27.386364,       13.125,          10.
  16950,   -27.227272,        13.75,          10.
  16951,   -27.068182,       14.375,          10.
  16952,   -28.886364,       10.625,          10.
  16953,   -28.681818,        11.25,          10.
  16954,   -28.477272,       11.875,          10.
  16955,   -28.272728,         12.5,          10.
  16956,   -28.068182,       13.125,          10.
  16957,   -27.863636,        13.75,          10.
  16958,    -27.65909,       14.375,          10.
  16959,  -20.9429417,   10.1034355,   1.01175714
  16960,  -21.0422707,   10.4069366,   1.97579575
  16961,  -21.2009068,   10.8916578,    2.8498292
  16962,  -21.4099903,   11.5305252,   3.60038137
  16963,  -21.6593399,   12.2924242,   4.20345497
  16964,  -21.9384708,   13.1453285,   4.64329576
  16965,  -22.2371387,   14.0579224,   4.91044712
  16966,   -21.844511,   10.1034355,   1.01175725
  16967,  -21.9217663,   10.4069366,   1.97579587
  16968,  -22.0451488,   10.8916578,    2.8498292
  16969,  -22.2077694,   11.5305252,   3.60038137
  16970,  -22.4017086,   12.2924242,   4.20345497
  16971,  -22.6188107,   13.1453285,   4.64329576
  16972,  -22.8511086,   14.0579224,   4.91044712
  16973,  -22.7460785,   10.1034355,   1.01175749
  16974,  -22.8012619,   10.4069366,   1.97579598
  16975,  -22.8893929,   10.8916578,    2.8498292
  16976,  -23.0055504,   11.5305252,   3.60038137
  16977,  -23.1440773,   12.2924242,   4.20345497
  16978,  -23.2991505,   13.1453285,   4.64329576
  16979,  -23.4650764,   14.0579224,   4.91044712
  16980,  -23.6476479,   10.1034355,   1.01175761
  16981,  -23.6807575,   10.4069366,    1.9757961
  16982,  -23.7336349,   10.8916578,    2.8498292
  16983,  -23.8033295,   11.5305252,   3.60038137
  16984,   -23.886446,   12.2924242,   4.20345497
  16985,  -23.9794903,   13.1453276,   4.64329529
  16986,  -24.0790462,   14.0579224,   4.91044712
  16987,  -24.5492153,   10.1034355,   1.01175773
  16988,  -24.5602512,   10.4069366,    1.9757961
  16989,   -24.577879,   10.8916578,    2.8498292
  16990,  -24.6011105,   11.5305252,   3.60038114
  16991,  -24.6288147,   12.2924242,   4.20345497
  16992,  -24.6598301,   13.1453276,   4.64329529
  16993,  -24.6930161,   14.0579224,   4.91044712
  16994,  -25.4507847,   10.1034355,   1.01175797
  16995,  -25.4397469,   10.4069366,   1.97579622
  16996,   -25.422121,   10.8916578,    2.8498292
  16997,  -25.3988895,   11.5305252,   3.60038114
  16998,  -25.3711853,   12.2924242,   4.20345497
  16999,  -25.3401699,   13.1453276,   4.64329529
  17000,  -25.3069859,   14.0579224,   4.91044712
  17001,  -26.3523521,   10.1034355,   1.01175809
  17002,  -26.3192425,   10.4069366,   1.97579634
  17003,  -26.2663651,   10.8916578,    2.8498292
  17004,  -26.1966705,   11.5305252,   3.60038114
  17005,   -26.113554,   12.2924242,   4.20345497
  17006,  -26.0205097,   13.1453276,   4.64329529
  17007,  -25.9209538,   14.0579224,   4.91044712
  17008,  -27.2539215,   10.1034355,   1.01175833
  17009,  -27.1987381,   10.4069366,   1.97579646
  17010,  -27.1106071,   10.8916578,    2.8498292
  17011,  -26.9944496,   11.5305252,   3.60038114
  17012,  -26.8559227,   12.2924242,   4.20345497
  17013,  -26.7008495,   13.1453276,   4.64329529
  17014,  -26.5349236,   14.0579214,   4.91044664
  17015,   -28.155489,   10.1034355,   1.01175857
  17016,  -28.0782337,   10.4069366,   1.97579658
  17017,  -27.9548512,   10.8916578,    2.8498292
  17018,  -27.7922306,   11.5305252,   3.60038114
  17019,  -27.5982914,   12.2924242,   4.20345497
  17020,  -27.3811893,   13.1453276,   4.64329529
  17021,  -27.1488934,   14.0579214,   4.91044664
  17022,  -29.0570583,   10.1034355,   1.01175869
  17023,  -28.9577293,   10.4069366,   1.97579682
  17024,  -28.7990932,   10.8916578,    2.8498292
  17025,  -28.5900097,   11.5305252,   3.60038114
  17026,   -28.340662,   12.2924242,   4.20345497
  17027,  -28.0615292,   13.1453266,   4.64329481
  17028,  -27.7628613,   14.0579214,   4.91044664
  17029,    -20.90909,          10.,     9.090909
  17030,    -20.90909,          10.,   8.18181801
  17031,    -20.90909,          10.,   7.27272749
  17032,    -20.90909,          10.,   6.36363649
  17033,    -20.90909,          10.,    5.4545455
  17034,    -20.90909,          10.,    4.5454545
  17035,    -20.90909,          10.,   3.63636374
  17036,    -20.90909,          10.,   2.72727275
  17037,    -20.90909,          10.,   1.81818187
  17038,    -20.90909,          10.,  0.909090936
  17039,   -21.818182,          10.,     9.090909
  17040,   -21.818182,          10.,   8.18181801
  17041,   -21.818182,          10.,   7.27272749
  17042,   -21.818182,          10.,   6.36363649
  17043,   -21.818182,          10.,    5.4545455
  17044,   -21.818182,          10.,    4.5454545
  17045,   -21.818182,          10.,   3.63636374
  17046,   -21.818182,          10.,   2.72727275
  17047,   -21.818182,          10.,   1.81818187
  17048,   -21.818182,          10.,  0.909090936
  17049,   -22.727272,          10.,     9.090909
  17050,   -22.727272,          10.,   8.18181801
  17051,   -22.727272,          10.,   7.27272749
  17052,   -22.727272,          10.,   6.36363649
  17053,   -22.727272,          10.,    5.4545455
  17054,   -22.727272,          10.,    4.5454545
  17055,   -22.727272,          10.,   3.63636374
  17056,   -22.727272,          10.,   2.72727275
  17057,   -22.727272,          10.,   1.81818187
  17058,   -22.727272,          10.,  0.909090936
  17059,   -23.636364,          10.,     9.090909
  17060,   -23.636364,          10.,   8.18181801
  17061,   -23.636364,          10.,   7.27272749
  17062,   -23.636364,          10.,   6.36363649
  17063,   -23.636364,          10.,    5.4545455
  17064,   -23.636364,          10.,    4.5454545
  17065,   -23.636364,          10.,   3.63636374
  17066,   -23.636364,          10.,   2.72727275
  17067,   -23.636364,          10.,   1.81818187
  17068,   -23.636364,          10.,  0.909090936
  17069,   -24.545454,          10.,     9.090909
  17070,   -24.545454,          10.,   8.18181801
  17071,   -24.545454,          10.,   7.27272749
  17072,   -24.545454,          10.,   6.36363649
  17073,   -24.545454,          10.,    5.4545455
  17074,   -24.545454,          10.,    4.5454545
  17075,   -24.545454,          10.,   3.63636374
  17076,   -24.545454,          10.,   2.72727275
  17077,   -24.545454,          10.,   1.81818187
  17078,   -24.545454,          10.,  0.909090936
  17079,   -25.454546,          10.,     9.090909
  17080,   -25.454546,          10.,   8.18181801
  17081,   -25.454546,          10.,   7.27272749
  17082,   -25.454546,          10.,   6.36363649
  17083,   -25.454546,          10.,    5.4545455
  17084,   -25.454546,          10.,    4.5454545
  17085,   -25.454546,          10.,   3.63636374
  17086,   -25.454546,          10.,   2.72727275
  17087,   -25.454546,          10.,   1.81818187
  17088,   -25.454546,          10.,  0.909090936
  17089,   -26.363636,          10.,     9.090909
  17090,   -26.363636,          10.,   8.18181801
  17091,   -26.363636,          10.,   7.27272749
  17092,   -26.363636,          10.,   6.36363649
  17093,   -26.363636,          10.,    5.4545455
  17094,   -26.363636,          10.,    4.5454545
  17095,   -26.363636,          10.,   3.63636374
  17096,   -26.363636,          10.,   2.72727275
  17097,   -26.363636,          10.,   1.81818187
  17098,   -26.363636,          10.,  0.909090936
  17099,   -27.272728,          10.,     9.090909
  17100,   -27.272728,          10.,   8.18181801
  17101,   -27.272728,          10.,   7.27272749
  17102,   -27.272728,          10.,   6.36363649
  17103,   -27.272728,          10.,    5.4545455
  17104,   -27.272728,          10.,    4.5454545
  17105,   -27.272728,          10.,   3.63636374
  17106,   -27.272728,          10.,   2.72727275
  17107,   -27.272728,          10.,   1.81818187
  17108,   -27.272728,          10.,  0.909090936
  17109,   -28.181818,          10.,     9.090909
  17110,   -28.181818,          10.,   8.18181801
  17111,   -28.181818,          10.,   7.27272749
  17112,   -28.181818,          10.,   6.36363649
  17113,   -28.181818,          10.,    5.4545455
  17114,   -28.181818,          10.,    4.5454545
  17115,   -28.181818,          10.,   3.63636374
  17116,   -28.181818,          10.,   2.72727275
  17117,   -28.181818,          10.,   1.81818187
  17118,   -28.181818,          10.,  0.909090936
  17119,    -29.09091,          10.,     9.090909
  17120,    -29.09091,          10.,   8.18181801
  17121,    -29.09091,          10.,   7.27272749
  17122,    -29.09091,          10.,   6.36363649
  17123,    -29.09091,          10.,    5.4545455
  17124,    -29.09091,          10.,    4.5454545
  17125,    -29.09091,          10.,   3.63636374
  17126,    -29.09091,          10.,   2.72727275
  17127,    -29.09091,          10.,   1.81818187
  17128,    -29.09091,          10.,  0.909090936
  17129,    -20.90909,           0.,  0.909090936
  17130,   -21.818182,           0.,  0.909090936
  17131,   -22.727272,           0.,  0.909090936
  17132,   -23.636364,           0.,  0.909090936
  17133,   -24.545454,           0.,  0.909090936
  17134,   -25.454546,           0.,  0.909090936
  17135,   -26.363636,           0.,  0.909090936
  17136,   -27.272728,           0.,  0.909090936
  17137,   -28.181818,           0.,  0.909090936
  17138,    -29.09091,           0.,  0.909090936
  17139,    -20.90909,           0.,   1.81818187
  17140,   -21.818182,           0.,   1.81818187
  17141,   -22.727272,           0.,   1.81818187
  17142,   -23.636364,           0.,   1.81818187
  17143,   -24.545454,           0.,   1.81818187
  17144,   -25.454546,           0.,   1.81818187
  17145,   -26.363636,           0.,   1.81818187
  17146,   -27.272728,           0.,   1.81818187
  17147,   -28.181818,           0.,   1.81818187
  17148,    -29.09091,           0.,   1.81818187
  17149,    -20.90909,           0.,   2.72727275
  17150,   -21.818182,           0.,   2.72727275
  17151,   -22.727272,           0.,   2.72727275
  17152,   -23.636364,           0.,   2.72727275
  17153,   -24.545454,           0.,   2.72727275
  17154,   -25.454546,           0.,   2.72727275
  17155,   -26.363636,           0.,   2.72727275
  17156,   -27.272728,           0.,   2.72727275
  17157,   -28.181818,           0.,   2.72727275
  17158,    -29.09091,           0.,   2.72727275
  17159,    -20.90909,           0.,   3.63636374
  17160,   -21.818182,           0.,   3.63636374
  17161,   -22.727272,           0.,   3.63636374
  17162,   -23.636364,           0.,   3.63636374
  17163,   -24.545454,           0.,   3.63636374
  17164,   -25.454546,           0.,   3.63636374
  17165,   -26.363636,           0.,   3.63636374
  17166,   -27.272728,           0.,   3.63636374
  17167,   -28.181818,           0.,   3.63636374
  17168,    -29.09091,           0.,   3.63636374
  17169,    -20.90909,           0.,    4.5454545
  17170,   -21.818182,           0.,    4.5454545
  17171,   -22.727272,           0.,    4.5454545
  17172,   -23.636364,           0.,    4.5454545
  17173,   -24.545454,           0.,    4.5454545
  17174,   -25.454546,           0.,    4.5454545
  17175,   -26.363636,           0.,    4.5454545
  17176,   -27.272728,           0.,    4.5454545
  17177,   -28.181818,           0.,    4.5454545
  17178,    -29.09091,           0.,    4.5454545
  17179,    -20.90909,           0.,    5.4545455
  17180,   -21.818182,           0.,    5.4545455
  17181,   -22.727272,           0.,    5.4545455
  17182,   -23.636364,           0.,    5.4545455
  17183,   -24.545454,           0.,    5.4545455
  17184,   -25.454546,           0.,    5.4545455
  17185,   -26.363636,           0.,    5.4545455
  17186,   -27.272728,           0.,    5.4545455
  17187,   -28.181818,           0.,    5.4545455
  17188,    -29.09091,           0.,    5.4545455
  17189,    -20.90909,           0.,   6.36363649
  17190,   -21.818182,           0.,   6.36363649
  17191,   -22.727272,           0.,   6.36363649
  17192,   -23.636364,           0.,   6.36363649
  17193,   -24.545454,           0.,   6.36363649
  17194,   -25.454546,           0.,   6.36363649
  17195,   -26.363636,           0.,   6.36363649
  17196,   -27.272728,           0.,   6.36363649
  17197,   -28.181818,           0.,   6.36363649
  17198,    -29.09091,           0.,   6.36363649
  17199,    -20.90909,           0.,   7.27272749
  17200,   -21.818182,           0.,   7.27272749
  17201,   -22.727272,           0.,   7.27272749
  17202,   -23.636364,           0.,   7.27272749
  17203,   -24.545454,           0.,   7.27272749
  17204,   -25.454546,           0.,   7.27272749
  17205,   -26.363636,           0.,   7.27272749
  17206,   -27.272728,           0.,   7.27272749
  17207,   -28.181818,           0.,   7.27272749
  17208,    -29.09091,           0.,   7.27272749
  17209,    -20.90909,           0.,   8.18181801
  17210,   -21.818182,           0.,   8.18181801
  17211,   -22.727272,           0.,   8.18181801
  17212,   -23.636364,           0.,   8.18181801
  17213,   -24.545454,           0.,   8.18181801
  17214,   -25.454546,           0.,   8.18181801
  17215,   -26.363636,           0.,   8.18181801
  17216,   -27.272728,           0.,   8.18181801
  17217,   -28.181818,           0.,   8.18181801
  17218,    -29.09091,           0.,   8.18181801
  17219,    -20.90909,           0.,     9.090909
  17220,   -21.818182,           0.,     9.090909
  17221,   -22.727272,           0.,     9.090909
  17222,   -23.636364,           0.,     9.090909
  17223,   -24.545454,           0.,     9.090909
  17224,   -25.454546,           0.,     9.090909
  17225,   -26.363636,           0.,     9.090909
  17226,   -27.272728,           0.,     9.090909
  17227,   -28.181818,           0.,     9.090909
  17228,    -29.09091,           0.,     9.090909
  17229,         -20.,   9.16666698,  0.909090936
  17230,         -20.,   9.16666698,   1.81818187
  17231,         -20.,   9.16666698,   2.72727275
  17232,         -20.,   9.16666698,   3.63636374
  17233,         -20.,   9.16666698,    4.5454545
  17234,         -20.,   9.16666698,    5.4545455
  17235,         -20.,   9.16666698,   6.36363649
  17236,         -20.,   9.16666698,   7.27272749
  17237,         -20.,   9.16666698,   8.18181801
  17238,         -20.,   9.16666698,     9.090909
  17239,         -20.,   8.33333302,  0.909090936
  17240,         -20.,   8.33333302,   1.81818187
  17241,         -20.,   8.33333302,   2.72727275
  17242,         -20.,   8.33333302,   3.63636374
  17243,         -20.,   8.33333302,    4.5454545
  17244,         -20.,   8.33333302,    5.4545455
  17245,         -20.,   8.33333302,   6.36363649
  17246,         -20.,   8.33333302,   7.27272749
  17247,         -20.,   8.33333302,   8.18181801
  17248,         -20.,   8.33333302,     9.090909
  17249,         -20.,          7.5,  0.909090936
  17250,         -20.,          7.5,   1.81818187
  17251,         -20.,          7.5,   2.72727275
  17252,         -20.,          7.5,   3.63636374
  17253,         -20.,          7.5,    4.5454545
  17254,         -20.,          7.5,    5.4545455
  17255,         -20.,          7.5,   6.36363649
  17256,         -20.,          7.5,   7.27272749
  17257,         -20.,          7.5,   8.18181801
  17258,         -20.,          7.5,     9.090909
  17259,         -20.,   6.66666651,  0.909090936
  17260,         -20.,   6.66666651,   1.81818187
  17261,         -20.,   6.66666651,   2.72727275
  17262,         -20.,   6.66666651,   3.63636374
  17263,         -20.,   6.66666651,    4.5454545
  17264,         -20.,   6.66666651,    5.4545455
  17265,         -20.,   6.66666651,   6.36363649
  17266,         -20.,   6.66666651,   7.27272749
  17267,         -20.,   6.66666651,   8.18181801
  17268,         -20.,   6.66666651,     9.090909
  17269,         -20.,   5.83333349,  0.909090936
  17270,         -20.,   5.83333349,   1.81818187
  17271,         -20.,   5.83333349,   2.72727275
  17272,         -20.,   5.83333349,   3.63636374
  17273,         -20.,   5.83333349,    4.5454545
  17274,         -20.,   5.83333349,    5.4545455
  17275,         -20.,   5.83333349,   6.36363649
  17276,         -20.,   5.83333349,   7.27272749
  17277,         -20.,   5.83333349,   8.18181801
  17278,         -20.,   5.83333349,     9.090909
  17279,         -20.,           5.,  0.909090936
  17280,         -20.,           5.,   1.81818187
  17281,         -20.,           5.,   2.72727275
  17282,         -20.,           5.,   3.63636374
  17283,         -20.,           5.,    4.5454545
  17284,         -20.,           5.,    5.4545455
  17285,         -20.,           5.,   6.36363649
  17286,         -20.,           5.,   7.27272749
  17287,         -20.,           5.,   8.18181801
  17288,         -20.,           5.,     9.090909
  17289,         -20.,   4.16666651,  0.909090936
  17290,         -20.,   4.16666651,   1.81818187
  17291,         -20.,   4.16666651,   2.72727275
  17292,         -20.,   4.16666651,   3.63636374
  17293,         -20.,   4.16666651,    4.5454545
  17294,         -20.,   4.16666651,    5.4545455
  17295,         -20.,   4.16666651,   6.36363649
  17296,         -20.,   4.16666651,   7.27272749
  17297,         -20.,   4.16666651,   8.18181801
  17298,         -20.,   4.16666651,     9.090909
  17299,         -20.,   3.33333325,  0.909090936
  17300,         -20.,   3.33333325,   1.81818187
  17301,         -20.,   3.33333325,   2.72727275
  17302,         -20.,   3.33333325,   3.63636374
  17303,         -20.,   3.33333325,    4.5454545
  17304,         -20.,   3.33333325,    5.4545455
  17305,         -20.,   3.33333325,   6.36363649
  17306,         -20.,   3.33333325,   7.27272749
  17307,         -20.,   3.33333325,   8.18181801
  17308,         -20.,   3.33333325,     9.090909
  17309,         -20.,          2.5,  0.909090936
  17310,         -20.,          2.5,   1.81818187
  17311,         -20.,          2.5,   2.72727275
  17312,         -20.,          2.5,   3.63636374
  17313,         -20.,          2.5,    4.5454545
  17314,         -20.,          2.5,    5.4545455
  17315,         -20.,          2.5,   6.36363649
  17316,         -20.,          2.5,   7.27272749
  17317,         -20.,          2.5,   8.18181801
  17318,         -20.,          2.5,     9.090909
  17319,         -20.,   1.66666663,  0.909090936
  17320,         -20.,   1.66666663,   1.81818187
  17321,         -20.,   1.66666663,   2.72727275
  17322,         -20.,   1.66666663,   3.63636374
  17323,         -20.,   1.66666663,    4.5454545
  17324,         -20.,   1.66666663,    5.4545455
  17325,         -20.,   1.66666663,   6.36363649
  17326,         -20.,   1.66666663,   7.27272749
  17327,         -20.,   1.66666663,   8.18181801
  17328,         -20.,   1.66666663,     9.090909
  17329,         -20.,  0.833333313,  0.909090936
  17330,         -20.,  0.833333313,   1.81818187
  17331,         -20.,  0.833333313,   2.72727275
  17332,         -20.,  0.833333313,   3.63636374
  17333,         -20.,  0.833333313,    4.5454545
  17334,         -20.,  0.833333313,    5.4545455
  17335,         -20.,  0.833333313,   6.36363649
  17336,         -20.,  0.833333313,   7.27272749
  17337,         -20.,  0.833333313,   8.18181801
  17338,         -20.,  0.833333313,     9.090909
  17339,         -30.,   9.16666698,  0.909090936
  17340,         -30.,   9.16666698,   1.81818187
  17341,         -30.,   9.16666698,   2.72727275
  17342,         -30.,   9.16666698,   3.63636374
  17343,         -30.,   9.16666698,    4.5454545
  17344,         -30.,   9.16666698,    5.4545455
  17345,         -30.,   9.16666698,   6.36363649
  17346,         -30.,   9.16666698,   7.27272749
  17347,         -30.,   9.16666698,   8.18181801
  17348,         -30.,   9.16666698,     9.090909
  17349,         -30.,   8.33333302,  0.909090936
  17350,         -30.,   8.33333302,   1.81818187
  17351,         -30.,   8.33333302,   2.72727275
  17352,         -30.,   8.33333302,   3.63636374
  17353,         -30.,   8.33333302,    4.5454545
  17354,         -30.,   8.33333302,    5.4545455
  17355,         -30.,   8.33333302,   6.36363649
  17356,         -30.,   8.33333302,   7.27272749
  17357,         -30.,   8.33333302,   8.18181801
  17358,         -30.,   8.33333302,     9.090909
  17359,         -30.,          7.5,  0.909090936
  17360,         -30.,          7.5,   1.81818187
  17361,         -30.,          7.5,   2.72727275
  17362,         -30.,          7.5,   3.63636374
  17363,         -30.,          7.5,    4.5454545
  17364,         -30.,          7.5,    5.4545455
  17365,         -30.,          7.5,   6.36363649
  17366,         -30.,          7.5,   7.27272749
  17367,         -30.,          7.5,   8.18181801
  17368,         -30.,          7.5,     9.090909
  17369,         -30.,   6.66666651,  0.909090936
  17370,         -30.,   6.66666651,   1.81818187
  17371,         -30.,   6.66666651,   2.72727275
  17372,         -30.,   6.66666651,   3.63636374
  17373,         -30.,   6.66666651,    4.5454545
  17374,         -30.,   6.66666651,    5.4545455
  17375,         -30.,   6.66666651,   6.36363649
  17376,         -30.,   6.66666651,   7.27272749
  17377,         -30.,   6.66666651,   8.18181801
  17378,         -30.,   6.66666651,     9.090909
  17379,         -30.,   5.83333349,  0.909090936
  17380,         -30.,   5.83333349,   1.81818187
  17381,         -30.,   5.83333349,   2.72727275
  17382,         -30.,   5.83333349,   3.63636374
  17383,         -30.,   5.83333349,    4.5454545
  17384,         -30.,   5.83333349,    5.4545455
  17385,         -30.,   5.83333349,   6.36363649
  17386,         -30.,   5.83333349,   7.27272749
  17387,         -30.,   5.83333349,   8.18181801
  17388,         -30.,   5.83333349,     9.090909
  17389,         -30.,           5.,  0.909090936
  17390,         -30.,           5.,   1.81818187
  17391,         -30.,           5.,   2.72727275
  17392,         -30.,           5.,   3.63636374
  17393,         -30.,           5.,    4.5454545
  17394,         -30.,           5.,    5.4545455
  17395,         -30.,           5.,   6.36363649
  17396,         -30.,           5.,   7.27272749
  17397,         -30.,           5.,   8.18181801
  17398,         -30.,           5.,     9.090909
  17399,         -30.,   4.16666651,  0.909090936
  17400,         -30.,   4.16666651,   1.81818187
  17401,         -30.,   4.16666651,   2.72727275
  17402,         -30.,   4.16666651,   3.63636374
  17403,         -30.,   4.16666651,    4.5454545
  17404,         -30.,   4.16666651,    5.4545455
  17405,         -30.,   4.16666651,   6.36363649
  17406,         -30.,   4.16666651,   7.27272749
  17407,         -30.,   4.16666651,   8.18181801
  17408,         -30.,   4.16666651,     9.090909
  17409,         -30.,   3.33333325,  0.909090936
  17410,         -30.,   3.33333325,   1.81818187
  17411,         -30.,   3.33333325,   2.72727275
  17412,         -30.,   3.33333325,   3.63636374
  17413,         -30.,   3.33333325,    4.5454545
  17414,         -30.,   3.33333325,    5.4545455
  17415,         -30.,   3.33333325,   6.36363649
  17416,         -30.,   3.33333325,   7.27272749
  17417,         -30.,   3.33333325,   8.18181801
  17418,         -30.,   3.33333325,     9.090909
  17419,         -30.,          2.5,  0.909090936
  17420,         -30.,          2.5,   1.81818187
  17421,         -30.,          2.5,   2.72727275
  17422,         -30.,          2.5,   3.63636374
  17423,         -30.,          2.5,    4.5454545
  17424,         -30.,          2.5,    5.4545455
  17425,         -30.,          2.5,   6.36363649
  17426,         -30.,          2.5,   7.27272749
  17427,         -30.,          2.5,   8.18181801
  17428,         -30.,          2.5,     9.090909
  17429,         -30.,   1.66666663,  0.909090936
  17430,         -30.,   1.66666663,   1.81818187
  17431,         -30.,   1.66666663,   2.72727275
  17432,         -30.,   1.66666663,   3.63636374
  17433,         -30.,   1.66666663,    4.5454545
  17434,         -30.,   1.66666663,    5.4545455
  17435,         -30.,   1.66666663,   6.36363649
  17436,         -30.,   1.66666663,   7.27272749
  17437,         -30.,   1.66666663,   8.18181801
  17438,         -30.,   1.66666663,     9.090909
  17439,         -30.,  0.833333313,  0.909090936
  17440,         -30.,  0.833333313,   1.81818187
  17441,         -30.,  0.833333313,   2.72727275
  17442,         -30.,  0.833333313,   3.63636374
  17443,         -30.,  0.833333313,    4.5454545
  17444,         -30.,  0.833333313,    5.4545455
  17445,         -30.,  0.833333313,   6.36363649
  17446,         -30.,  0.833333313,   7.27272749
  17447,         -30.,  0.833333313,   8.18181801
  17448,         -30.,  0.833333313,     9.090909
  17449,    -20.90909,   9.16666698,           0.
  17450,   -21.818182,   9.16666698,           0.
  17451,   -22.727272,   9.16666698,           0.
  17452,   -23.636364,   9.16666698,           0.
  17453,   -24.545454,   9.16666698,           0.
  17454,   -25.454546,   9.16666698,           0.
  17455,   -26.363636,   9.16666698,           0.
  17456,   -27.272728,   9.16666698,           0.
  17457,   -28.181818,   9.16666698,           0.
  17458,    -29.09091,   9.16666698,           0.
  17459,    -20.90909,   8.33333302,           0.
  17460,   -21.818182,   8.33333302,           0.
  17461,   -22.727272,   8.33333302,           0.
  17462,   -23.636364,   8.33333302,           0.
  17463,   -24.545454,   8.33333302,           0.
  17464,   -25.454546,   8.33333302,           0.
  17465,   -26.363636,   8.33333302,           0.
  17466,   -27.272728,   8.33333302,           0.
  17467,   -28.181818,   8.33333302,           0.
  17468,    -29.09091,   8.33333302,           0.
  17469,    -20.90909,          7.5,           0.
  17470,   -21.818182,          7.5,           0.
  17471,   -22.727272,          7.5,           0.
  17472,   -23.636364,          7.5,           0.
  17473,   -24.545454,          7.5,           0.
  17474,   -25.454546,          7.5,           0.
  17475,   -26.363636,          7.5,           0.
  17476,   -27.272728,          7.5,           0.
  17477,   -28.181818,          7.5,           0.
  17478,    -29.09091,          7.5,           0.
  17479,    -20.90909,   6.66666651,           0.
  17480,   -21.818182,   6.66666651,           0.
  17481,   -22.727272,   6.66666651,           0.
  17482,   -23.636364,   6.66666651,           0.
  17483,   -24.545454,   6.66666651,           0.
  17484,   -25.454546,   6.66666651,           0.
  17485,   -26.363636,   6.66666651,           0.
  17486,   -27.272728,   6.66666651,           0.
  17487,   -28.181818,   6.66666651,           0.
  17488,    -29.09091,   6.66666651,           0.
  17489,    -20.90909,   5.83333349,           0.
  17490,   -21.818182,   5.83333349,           0.
  17491,   -22.727272,   5.83333349,           0.
  17492,   -23.636364,   5.83333349,           0.
  17493,   -24.545454,   5.83333349,           0.
  17494,   -25.454546,   5.83333349,           0.
  17495,   -26.363636,   5.83333349,           0.
  17496,   -27.272728,   5.83333349,           0.
  17497,   -28.181818,   5.83333349,           0.
  17498,    -29.09091,   5.83333349,           0.
  17499,    -20.90909,           5.,           0.
  17500,   -21.818182,           5.,           0.
  17501,   -22.727272,           5.,           0.
  17502,   -23.636364,           5.,           0.
  17503,   -24.545454,           5.,           0.
  17504,   -25.454546,           5.,           0.
  17505,   -26.363636,           5.,           0.
  17506,   -27.272728,           5.,           0.
  17507,   -28.181818,           5.,           0.
  17508,    -29.09091,           5.,           0.
  17509,    -20.90909,   4.16666651,           0.
  17510,   -21.818182,   4.16666651,           0.
  17511,   -22.727272,   4.16666651,           0.
  17512,   -23.636364,   4.16666651,           0.
  17513,   -24.545454,   4.16666651,           0.
  17514,   -25.454546,   4.16666651,           0.
  17515,   -26.363636,   4.16666651,           0.
  17516,   -27.272728,   4.16666651,           0.
  17517,   -28.181818,   4.16666651,           0.
  17518,    -29.09091,   4.16666651,           0.
  17519,    -20.90909,   3.33333325,           0.
  17520,   -21.818182,   3.33333325,           0.
  17521,   -22.727272,   3.33333325,           0.
  17522,   -23.636364,   3.33333325,           0.
  17523,   -24.545454,   3.33333325,           0.
  17524,   -25.454546,   3.33333325,           0.
  17525,   -26.363636,   3.33333325,           0.
  17526,   -27.272728,   3.33333325,           0.
  17527,   -28.181818,   3.33333325,           0.
  17528,    -29.09091,   3.33333325,           0.
  17529,    -20.90909,          2.5,           0.
  17530,   -21.818182,          2.5,           0.
  17531,   -22.727272,          2.5,           0.
  17532,   -23.636364,          2.5,           0.
  17533,   -24.545454,          2.5,           0.
  17534,   -25.454546,          2.5,           0.
  17535,   -26.363636,          2.5,           0.
  17536,   -27.272728,          2.5,           0.
  17537,   -28.181818,          2.5,           0.
  17538,    -29.09091,          2.5,           0.
  17539,    -20.90909,   1.66666663,           0.
  17540,   -21.818182,   1.66666663,           0.
  17541,   -22.727272,   1.66666663,           0.
  17542,   -23.636364,   1.66666663,           0.
  17543,   -24.545454,   1.66666663,           0.
  17544,   -25.454546,   1.66666663,           0.
  17545,   -26.363636,   1.66666663,           0.
  17546,   -27.272728,   1.66666663,           0.
  17547,   -28.181818,   1.66666663,           0.
  17548,    -29.09091,   1.66666663,           0.
  17549,    -20.90909,  0.833333313,           0.
  17550,   -21.818182,  0.833333313,           0.
  17551,   -22.727272,  0.833333313,           0.
  17552,   -23.636364,  0.833333313,           0.
  17553,   -24.545454,  0.833333313,           0.
  17554,   -25.454546,  0.833333313,           0.
  17555,   -26.363636,  0.833333313,           0.
  17556,   -27.272728,  0.833333313,           0.
  17557,   -28.181818,  0.833333313,           0.
  17558,    -29.09091,  0.833333313,           0.
  17559,    -20.90909,   9.16666698,          10.
  17560,   -21.818182,   9.16666698,          10.
  17561,   -22.727272,   9.16666698,          10.
  17562,   -23.636364,   9.16666698,          10.
  17563,   -24.545454,   9.16666698,          10.
  17564,   -25.454546,   9.16666698,          10.
  17565,   -26.363636,   9.16666698,          10.
  17566,   -27.272728,   9.16666698,          10.
  17567,   -28.181818,   9.16666698,          10.
  17568,    -29.09091,   9.16666698,          10.
  17569,    -20.90909,   8.33333302,          10.
  17570,   -21.818182,   8.33333302,          10.
  17571,   -22.727272,   8.33333302,          10.
  17572,   -23.636364,   8.33333302,          10.
  17573,   -24.545454,   8.33333302,          10.
  17574,   -25.454546,   8.33333302,          10.
  17575,   -26.363636,   8.33333302,          10.
  17576,   -27.272728,   8.33333302,          10.
  17577,   -28.181818,   8.33333302,          10.
  17578,    -29.09091,   8.33333302,          10.
  17579,    -20.90909,          7.5,          10.
  17580,   -21.818182,          7.5,          10.
  17581,   -22.727272,          7.5,          10.
  17582,   -23.636364,          7.5,          10.
  17583,   -24.545454,          7.5,          10.
  17584,   -25.454546,          7.5,          10.
  17585,   -26.363636,          7.5,          10.
  17586,   -27.272728,          7.5,          10.
  17587,   -28.181818,          7.5,          10.
  17588,    -29.09091,          7.5,          10.
  17589,    -20.90909,   6.66666651,          10.
  17590,   -21.818182,   6.66666651,          10.
  17591,   -22.727272,   6.66666651,          10.
  17592,   -23.636364,   6.66666651,          10.
  17593,   -24.545454,   6.66666651,          10.
  17594,   -25.454546,   6.66666651,          10.
  17595,   -26.363636,   6.66666651,          10.
  17596,   -27.272728,   6.66666651,          10.
  17597,   -28.181818,   6.66666651,          10.
  17598,    -29.09091,   6.66666651,          10.
  17599,    -20.90909,   5.83333349,          10.
  17600,   -21.818182,   5.83333349,          10.
  17601,   -22.727272,   5.83333349,          10.
  17602,   -23.636364,   5.83333349,          10.
  17603,   -24.545454,   5.83333349,          10.
  17604,   -25.454546,   5.83333349,          10.
  17605,   -26.363636,   5.83333349,          10.
  17606,   -27.272728,   5.83333349,          10.
  17607,   -28.181818,   5.83333349,          10.
  17608,    -29.09091,   5.83333349,          10.
  17609,    -20.90909,           5.,          10.
  17610,   -21.818182,           5.,          10.
  17611,   -22.727272,           5.,          10.
  17612,   -23.636364,           5.,          10.
  17613,   -24.545454,           5.,          10.
  17614,   -25.454546,           5.,          10.
  17615,   -26.363636,           5.,          10.
  17616,   -27.272728,           5.,          10.
  17617,   -28.181818,           5.,          10.
  17618,    -29.09091,           5.,          10.
  17619,    -20.90909,   4.16666651,          10.
  17620,   -21.818182,   4.16666651,          10.
  17621,   -22.727272,   4.16666651,          10.
  17622,   -23.636364,   4.16666651,          10.
  17623,   -24.545454,   4.16666651,          10.
  17624,   -25.454546,   4.16666651,          10.
  17625,   -26.363636,   4.16666651,          10.
  17626,   -27.272728,   4.16666651,          10.
  17627,   -28.181818,   4.16666651,          10.
  17628,    -29.09091,   4.16666651,          10.
  17629,    -20.90909,   3.33333325,          10.
  17630,   -21.818182,   3.33333325,          10.
  17631,   -22.727272,   3.33333325,          10.
  17632,   -23.636364,   3.33333325,          10.
  17633,   -24.545454,   3.33333325,          10.
  17634,   -25.454546,   3.33333325,          10.
  17635,   -26.363636,   3.33333325,          10.
  17636,   -27.272728,   3.33333325,          10.
  17637,   -28.181818,   3.33333325,          10.
  17638,    -29.09091,   3.33333325,          10.
  17639,    -20.90909,          2.5,          10.
  17640,   -21.818182,          2.5,          10.
  17641,   -22.727272,          2.5,          10.
  17642,   -23.636364,          2.5,          10.
  17643,   -24.545454,          2.5,          10.
  17644,   -25.454546,          2.5,          10.
  17645,   -26.363636,          2.5,          10.
  17646,   -27.272728,          2.5,          10.
  17647,   -28.181818,          2.5,          10.
  17648,    -29.09091,          2.5,          10.
  17649,    -20.90909,   1.66666663,          10.
  17650,   -21.818182,   1.66666663,          10.
  17651,   -22.727272,   1.66666663,          10.
  17652,   -23.636364,   1.66666663,          10.
  17653,   -24.545454,   1.66666663,          10.
  17654,   -25.454546,   1.66666663,          10.
  17655,   -26.363636,   1.66666663,          10.
  17656,   -27.272728,   1.66666663,          10.
  17657,   -28.181818,   1.66666663,          10.
  17658,    -29.09091,   1.66666663,          10.
  17659,    -20.90909,  0.833333313,          10.
  17660,   -21.818182,  0.833333313,          10.
  17661,   -22.727272,  0.833333313,          10.
  17662,   -23.636364,  0.833333313,          10.
  17663,   -24.545454,  0.833333313,          10.
  17664,   -25.454546,  0.833333313,          10.
  17665,   -26.363636,  0.833333313,          10.
  17666,   -27.272728,  0.833333313,          10.
  17667,   -28.181818,  0.833333313,          10.
  17668,    -29.09091,  0.833333313,          10.
  17669,     29.09091,          10.,  0.909090936
  17670,    28.181818,          10.,  0.909090936
  17671,    27.272728,          10.,  0.909090936
  17672,    26.363636,          10.,  0.909090936
  17673,    25.454546,          10.,  0.909090936
  17674,    24.545454,          10.,  0.909090936
  17675,    23.636364,          10.,  0.909090936
  17676,    22.727272,          10.,  0.909090936
  17677,    21.818182,          10.,  0.909090936
  17678,     20.90909,          10.,  0.909090936
  17679,     29.09091,          10.,   1.81818187
  17680,    28.181818,          10.,   1.81818187
  17681,    27.272728,          10.,   1.81818187
  17682,    26.363636,          10.,   1.81818187
  17683,    25.454546,          10.,   1.81818187
  17684,    24.545454,          10.,   1.81818187
  17685,    23.636364,          10.,   1.81818187
  17686,    22.727272,          10.,   1.81818187
  17687,    21.818182,          10.,   1.81818187
  17688,     20.90909,          10.,   1.81818187
  17689,     29.09091,          10.,   2.72727275
  17690,    28.181818,          10.,   2.72727275
  17691,    27.272728,          10.,   2.72727275
  17692,    26.363636,          10.,   2.72727275
  17693,    25.454546,          10.,   2.72727275
  17694,    24.545454,          10.,   2.72727275
  17695,    23.636364,          10.,   2.72727275
  17696,    22.727272,          10.,   2.72727275
  17697,    21.818182,          10.,   2.72727275
  17698,     20.90909,          10.,   2.72727275
  17699,     29.09091,          10.,   3.63636374
  17700,    28.181818,          10.,   3.63636374
  17701,    27.272728,          10.,   3.63636374
  17702,    26.363636,          10.,   3.63636374
  17703,    25.454546,          10.,   3.63636374
  17704,    24.545454,          10.,   3.63636374
  17705,    23.636364,          10.,   3.63636374
  17706,    22.727272,          10.,   3.63636374
  17707,    21.818182,          10.,   3.63636374
  17708,     20.90909,          10.,   3.63636374
  17709,     29.09091,          10.,    4.5454545
  17710,    28.181818,          10.,    4.5454545
  17711,    27.272728,          10.,    4.5454545
  17712,    26.363636,          10.,    4.5454545
  17713,    25.454546,          10.,    4.5454545
  17714,    24.545454,          10.,    4.5454545
  17715,    23.636364,          10.,    4.5454545
  17716,    22.727272,          10.,    4.5454545
  17717,    21.818182,          10.,    4.5454545
  17718,     20.90909,          10.,    4.5454545
  17719,     29.09091,          10.,    5.4545455
  17720,    28.181818,          10.,    5.4545455
  17721,    27.272728,          10.,    5.4545455
  17722,    26.363636,          10.,    5.4545455
  17723,    25.454546,          10.,    5.4545455
  17724,    24.545454,          10.,    5.4545455
  17725,    23.636364,          10.,    5.4545455
  17726,    22.727272,          10.,    5.4545455
  17727,    21.818182,          10.,    5.4545455
  17728,     20.90909,          10.,    5.4545455
  17729,     29.09091,          10.,   6.36363649
  17730,    28.181818,          10.,   6.36363649
  17731,    27.272728,          10.,   6.36363649
  17732,    26.363636,          10.,   6.36363649
  17733,    25.454546,          10.,   6.36363649
  17734,    24.545454,          10.,   6.36363649
  17735,    23.636364,          10.,   6.36363649
  17736,    22.727272,          10.,   6.36363649
  17737,    21.818182,          10.,   6.36363649
  17738,     20.90909,          10.,   6.36363649
  17739,     29.09091,          10.,   7.27272749
  17740,    28.181818,          10.,   7.27272749
  17741,    27.272728,          10.,   7.27272749
  17742,    26.363636,          10.,   7.27272749
  17743,    25.454546,          10.,   7.27272749
  17744,    24.545454,          10.,   7.27272749
  17745,    23.636364,          10.,   7.27272749
  17746,    22.727272,          10.,   7.27272749
  17747,    21.818182,          10.,   7.27272749
  17748,     20.90909,          10.,   7.27272749
  17749,     29.09091,          10.,   8.18181801
  17750,    28.181818,          10.,   8.18181801
  17751,    27.272728,          10.,   8.18181801
  17752,    26.363636,          10.,   8.18181801
  17753,    25.454546,          10.,   8.18181801
  17754,    24.545454,          10.,   8.18181801
  17755,    23.636364,          10.,   8.18181801
  17756,    22.727272,          10.,   8.18181801
  17757,    21.818182,          10.,   8.18181801
  17758,     20.90909,          10.,   8.18181801
  17759,     29.09091,          10.,     9.090909
  17760,    28.181818,          10.,     9.090909
  17761,    27.272728,          10.,     9.090909
  17762,    26.363636,          10.,     9.090909
  17763,    25.454546,          10.,     9.090909
  17764,    24.545454,          10.,     9.090909
  17765,    23.636364,          10.,     9.090909
  17766,    22.727272,          10.,     9.090909
  17767,    21.818182,          10.,     9.090909
  17768,     20.90909,          10.,     9.090909
  17769,     29.09091,           0.,  0.909090936
  17770,    28.181818,           0.,  0.909090936
  17771,    27.272728,           0.,  0.909090936
  17772,    26.363636,           0.,  0.909090936
  17773,    25.454546,           0.,  0.909090936
  17774,    24.545454,           0.,  0.909090936
  17775,    23.636364,           0.,  0.909090936
  17776,    22.727272,           0.,  0.909090936
  17777,    21.818182,           0.,  0.909090936
  17778,     20.90909,           0.,  0.909090936
  17779,     29.09091,           0.,   1.81818187
  17780,    28.181818,           0.,   1.81818187
  17781,    27.272728,           0.,   1.81818187
  17782,    26.363636,           0.,   1.81818187
  17783,    25.454546,           0.,   1.81818187
  17784,    24.545454,           0.,   1.81818187
  17785,    23.636364,           0.,   1.81818187
  17786,    22.727272,           0.,   1.81818187
  17787,    21.818182,           0.,   1.81818187
  17788,     20.90909,           0.,   1.81818187
  17789,     29.09091,           0.,   2.72727275
  17790,    28.181818,           0.,   2.72727275
  17791,    27.272728,           0.,   2.72727275
  17792,    26.363636,           0.,   2.72727275
  17793,    25.454546,           0.,   2.72727275
  17794,    24.545454,           0.,   2.72727275
  17795,    23.636364,           0.,   2.72727275
  17796,    22.727272,           0.,   2.72727275
  17797,    21.818182,           0.,   2.72727275
  17798,     20.90909,           0.,   2.72727275
  17799,     29.09091,           0.,   3.63636374
  17800,    28.181818,           0.,   3.63636374
  17801,    27.272728,           0.,   3.63636374
  17802,    26.363636,           0.,   3.63636374
  17803,    25.454546,           0.,   3.63636374
  17804,    24.545454,           0.,   3.63636374
  17805,    23.636364,           0.,   3.63636374
  17806,    22.727272,           0.,   3.63636374
  17807,    21.818182,           0.,   3.63636374
  17808,     20.90909,           0.,   3.63636374
  17809,     29.09091,           0.,    4.5454545
  17810,    28.181818,           0.,    4.5454545
  17811,    27.272728,           0.,    4.5454545
  17812,    26.363636,           0.,    4.5454545
  17813,    25.454546,           0.,    4.5454545
  17814,    24.545454,           0.,    4.5454545
  17815,    23.636364,           0.,    4.5454545
  17816,    22.727272,           0.,    4.5454545
  17817,    21.818182,           0.,    4.5454545
  17818,     20.90909,           0.,    4.5454545
  17819,     29.09091,           0.,    5.4545455
  17820,    28.181818,           0.,    5.4545455
  17821,    27.272728,           0.,    5.4545455
  17822,    26.363636,           0.,    5.4545455
  17823,    25.454546,           0.,    5.4545455
  17824,    24.545454,           0.,    5.4545455
  17825,    23.636364,           0.,    5.4545455
  17826,    22.727272,           0.,    5.4545455
  17827,    21.818182,           0.,    5.4545455
  17828,     20.90909,           0.,    5.4545455
  17829,     29.09091,           0.,   6.36363649
  17830,    28.181818,           0.,   6.36363649
  17831,    27.272728,           0.,   6.36363649
  17832,    26.363636,           0.,   6.36363649
  17833,    25.454546,           0.,   6.36363649
  17834,    24.545454,           0.,   6.36363649
  17835,    23.636364,           0.,   6.36363649
  17836,    22.727272,           0.,   6.36363649
  17837,    21.818182,           0.,   6.36363649
  17838,     20.90909,           0.,   6.36363649
  17839,     29.09091,           0.,   7.27272749
  17840,    28.181818,           0.,   7.27272749
  17841,    27.272728,           0.,   7.27272749
  17842,    26.363636,           0.,   7.27272749
  17843,    25.454546,           0.,   7.27272749
  17844,    24.545454,           0.,   7.27272749
  17845,    23.636364,           0.,   7.27272749
  17846,    22.727272,           0.,   7.27272749
  17847,    21.818182,           0.,   7.27272749
  17848,     20.90909,           0.,   7.27272749
  17849,     29.09091,           0.,   8.18181801
  17850,    28.181818,           0.,   8.18181801
  17851,    27.272728,           0.,   8.18181801
  17852,    26.363636,           0.,   8.18181801
  17853,    25.454546,           0.,   8.18181801
  17854,    24.545454,           0.,   8.18181801
  17855,    23.636364,           0.,   8.18181801
  17856,    22.727272,           0.,   8.18181801
  17857,    21.818182,           0.,   8.18181801
  17858,     20.90909,           0.,   8.18181801
  17859,     29.09091,           0.,     9.090909
  17860,    28.181818,           0.,     9.090909
  17861,    27.272728,           0.,     9.090909
  17862,    26.363636,           0.,     9.090909
  17863,    25.454546,           0.,     9.090909
  17864,    24.545454,           0.,     9.090909
  17865,    23.636364,           0.,     9.090909
  17866,    22.727272,           0.,     9.090909
  17867,    21.818182,           0.,     9.090909
  17868,     20.90909,           0.,     9.090909
  17869,          30.,   9.16666698,  0.909090936
  17870,          30.,   9.16666698,   1.81818187
  17871,          30.,   9.16666698,   2.72727275
  17872,          30.,   9.16666698,   3.63636374
  17873,          30.,   9.16666698,    4.5454545
  17874,          30.,   9.16666698,    5.4545455
  17875,          30.,   9.16666698,   6.36363649
  17876,          30.,   9.16666698,   7.27272749
  17877,          30.,   9.16666698,   8.18181801
  17878,          30.,   9.16666698,     9.090909
  17879,          30.,   8.33333302,  0.909090936
  17880,          30.,   8.33333302,   1.81818187
  17881,          30.,   8.33333302,   2.72727275
  17882,          30.,   8.33333302,   3.63636374
  17883,          30.,   8.33333302,    4.5454545
  17884,          30.,   8.33333302,    5.4545455
  17885,          30.,   8.33333302,   6.36363649
  17886,          30.,   8.33333302,   7.27272749
  17887,          30.,   8.33333302,   8.18181801
  17888,          30.,   8.33333302,     9.090909
  17889,          30.,          7.5,  0.909090936
  17890,          30.,          7.5,   1.81818187
  17891,          30.,          7.5,   2.72727275
  17892,          30.,          7.5,   3.63636374
  17893,          30.,          7.5,    4.5454545
  17894,          30.,          7.5,    5.4545455
  17895,          30.,          7.5,   6.36363649
  17896,          30.,          7.5,   7.27272749
  17897,          30.,          7.5,   8.18181801
  17898,          30.,          7.5,     9.090909
  17899,          30.,   6.66666651,  0.909090936
  17900,          30.,   6.66666651,   1.81818187
  17901,          30.,   6.66666651,   2.72727275
  17902,          30.,   6.66666651,   3.63636374
  17903,          30.,   6.66666651,    4.5454545
  17904,          30.,   6.66666651,    5.4545455
  17905,          30.,   6.66666651,   6.36363649
  17906,          30.,   6.66666651,   7.27272749
  17907,          30.,   6.66666651,   8.18181801
  17908,          30.,   6.66666651,     9.090909
  17909,          30.,   5.83333349,  0.909090936
  17910,          30.,   5.83333349,   1.81818187
  17911,          30.,   5.83333349,   2.72727275
  17912,          30.,   5.83333349,   3.63636374
  17913,          30.,   5.83333349,    4.5454545
  17914,          30.,   5.83333349,    5.4545455
  17915,          30.,   5.83333349,   6.36363649
  17916,          30.,   5.83333349,   7.27272749
  17917,          30.,   5.83333349,   8.18181801
  17918,          30.,   5.83333349,     9.090909
  17919,          30.,           5.,  0.909090936
  17920,          30.,           5.,   1.81818187
  17921,          30.,           5.,   2.72727275
  17922,          30.,           5.,   3.63636374
  17923,          30.,           5.,    4.5454545
  17924,          30.,           5.,    5.4545455
  17925,          30.,           5.,   6.36363649
  17926,          30.,           5.,   7.27272749
  17927,          30.,           5.,   8.18181801
  17928,          30.,           5.,     9.090909
  17929,          30.,   4.16666651,  0.909090936
  17930,          30.,   4.16666651,   1.81818187
  17931,          30.,   4.16666651,   2.72727275
  17932,          30.,   4.16666651,   3.63636374
  17933,          30.,   4.16666651,    4.5454545
  17934,          30.,   4.16666651,    5.4545455
  17935,          30.,   4.16666651,   6.36363649
  17936,          30.,   4.16666651,   7.27272749
  17937,          30.,   4.16666651,   8.18181801
  17938,          30.,   4.16666651,     9.090909
  17939,          30.,   3.33333325,  0.909090936
  17940,          30.,   3.33333325,   1.81818187
  17941,          30.,   3.33333325,   2.72727275
  17942,          30.,   3.33333325,   3.63636374
  17943,          30.,   3.33333325,    4.5454545
  17944,          30.,   3.33333325,    5.4545455
  17945,          30.,   3.33333325,   6.36363649
  17946,          30.,   3.33333325,   7.27272749
  17947,          30.,   3.33333325,   8.18181801
  17948,          30.,   3.33333325,     9.090909
  17949,          30.,          2.5,  0.909090936
  17950,          30.,          2.5,   1.81818187
  17951,          30.,          2.5,   2.72727275
  17952,          30.,          2.5,   3.63636374
  17953,          30.,          2.5,    4.5454545
  17954,          30.,          2.5,    5.4545455
  17955,          30.,          2.5,   6.36363649
  17956,          30.,          2.5,   7.27272749
  17957,          30.,          2.5,   8.18181801
  17958,          30.,          2.5,     9.090909
  17959,          30.,   1.66666663,  0.909090936
  17960,          30.,   1.66666663,   1.81818187
  17961,          30.,   1.66666663,   2.72727275
  17962,          30.,   1.66666663,   3.63636374
  17963,          30.,   1.66666663,    4.5454545
  17964,          30.,   1.66666663,    5.4545455
  17965,          30.,   1.66666663,   6.36363649
  17966,          30.,   1.66666663,   7.27272749
  17967,          30.,   1.66666663,   8.18181801
  17968,          30.,   1.66666663,     9.090909
  17969,          30.,  0.833333313,  0.909090936
  17970,          30.,  0.833333313,   1.81818187
  17971,          30.,  0.833333313,   2.72727275
  17972,          30.,  0.833333313,   3.63636374
  17973,          30.,  0.833333313,    4.5454545
  17974,          30.,  0.833333313,    5.4545455
  17975,          30.,  0.833333313,   6.36363649
  17976,          30.,  0.833333313,   7.27272749
  17977,          30.,  0.833333313,   8.18181801
  17978,          30.,  0.833333313,     9.090909
  17979,          20.,   9.16666698,  0.909090936
  17980,          20.,   9.16666698,   1.81818187
  17981,          20.,   9.16666698,   2.72727275
  17982,          20.,   9.16666698,   3.63636374
  17983,          20.,   9.16666698,    4.5454545
  17984,          20.,   9.16666698,    5.4545455
  17985,          20.,   9.16666698,   6.36363649
  17986,          20.,   9.16666698,   7.27272749
  17987,          20.,   9.16666698,   8.18181801
  17988,          20.,   9.16666698,     9.090909
  17989,          20.,   8.33333302,  0.909090936
  17990,          20.,   8.33333302,   1.81818187
  17991,          20.,   8.33333302,   2.72727275
  17992,          20.,   8.33333302,   3.63636374
  17993,          20.,   8.33333302,    4.5454545
  17994,          20.,   8.33333302,    5.4545455
