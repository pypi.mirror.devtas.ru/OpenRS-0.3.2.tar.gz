  39995,   -9.1050787,   74.7414398,   1.81818187
  39996,  -9.89340305,   74.4368973,   1.81818187
  39997,  -10.6715603,   74.1072388,   1.81818187
  39998,  -11.4387522,   73.7528152,   1.81818187
  39999,  -12.1941919,   73.3739853,   1.81818187
  40000,  -12.9370985,   72.9711304,   1.81818187
  40001,  -13.6667137,   72.5446701,   1.81818187
  40002,  -14.3822823,    72.095047,   1.81818187
  40003,  -15.0830746,   71.6227264,   1.81818187
  40004,  -15.7683668,   71.1281738,   1.81818187
  40005,  -16.4374599,   70.6119232,   1.81818187
  40006,  -17.0896568,   70.0744858,   1.81818187
  40007,  -17.7242966,   69.5164185,   1.81818187
  40008,  -18.3407192,   68.9383011,   1.81818187
  40009,  -18.9383011,   68.3407211,   1.81818187
  40010,  -19.5164185,   67.7242966,   1.81818187
  40011,  -20.0744839,   67.0896606,   1.81818187
  40012,  -20.6119194,   66.4374619,   1.81818187
  40013,  -21.1281796,   65.7683716,   1.81818187
  40014,  -21.6227245,   65.0830765,   1.81818187
  40015,  -22.0950489,   64.3822861,   1.81818187
  40016,  -22.5446701,   63.6667137,   1.81818187
  40017,  -22.9711304,   62.9370995,   1.81818187
  40018,  -23.3739815,    62.194191,   1.81818187
  40019,  -23.7528152,   61.4387512,   1.81818187
  40020,  -24.1072426,   60.6715622,   1.81818187
  40021,  -24.4368973,   59.8934021,   1.81818187
  40022,  -24.7414398,   59.1050797,   1.81818187
  40023,  -25.0205612,   58.3073997,   1.81818187
  40024,  -25.2739716,   57.5011826,   1.81818187
  40025,  -25.5014095,   56.6872559,   1.81818187
  40026,  -25.7026443,   55.8664627,   1.81818187
  40027,  -25.8774662,   55.0396347,   1.81818187
  40028,  -26.0257015,    54.207634,   1.81818187
  40029,   -26.147192,   53.3713074,   1.81818187
  40030,  -26.2418137,    52.531517,   1.81818187
  40031,  -26.3094692,   51.6891251,   1.81818187
  40032,  -26.3500919,   50.8449974,   1.81818187
  40033,   26.3500919,   50.8449974,   2.72727275
  40034,   26.3094692,   51.6891251,   2.72727275
  40035,   26.2418137,    52.531517,   2.72727275
  40036,    26.147192,   53.3713074,   2.72727275
  40037,   26.0257015,    54.207634,   2.72727275
  40038,   25.8774662,   55.0396347,   2.72727275
  40039,   25.7026443,   55.8664627,   2.72727275
  40040,   25.5014095,   56.6872559,   2.72727275
  40041,   25.2739716,   57.5011826,   2.72727275
  40042,   25.0205612,   58.3073997,   2.72727275
  40043,   24.7414398,   59.1050797,   2.72727275
  40044,   24.4368973,   59.8934021,   2.72727275
  40045,   24.1072426,   60.6715622,   2.72727275
  40046,   23.7528152,   61.4387512,   2.72727275
  40047,   23.3739815,    62.194191,   2.72727275
  40048,   22.9711304,   62.9370995,   2.72727275
  40049,   22.5446701,   63.6667137,   2.72727275
  40050,   22.0950489,   64.3822861,   2.72727275
  40051,   21.6227245,   65.0830765,   2.72727275
  40052,   21.1281796,   65.7683716,   2.72727275
  40053,   20.6119194,   66.4374619,   2.72727275
  40054,   20.0744839,   67.0896606,   2.72727275
  40055,   19.5164185,   67.7242966,   2.72727275
  40056,   18.9383011,   68.3407211,   2.72727275
  40057,   18.3407192,   68.9383011,   2.72727275
  40058,   17.7242966,   69.5164185,   2.72727275
  40059,   17.0896568,   70.0744858,   2.72727275
  40060,   16.4374599,   70.6119232,   2.72727275
  40061,   15.7683668,   71.1281738,   2.72727275
  40062,   15.0830746,   71.6227264,   2.72727275
  40063,   14.3822823,    72.095047,   2.72727275
  40064,   13.6667137,   72.5446701,   2.72727275
  40065,   12.9370985,   72.9711304,   2.72727275
  40066,   12.1941919,   73.3739853,   2.72727275
  40067,   11.4387522,   73.7528152,   2.72727275
  40068,   10.6715603,   74.1072388,   2.72727275
  40069,   9.89340305,   74.4368973,   2.72727275
  40070,    9.1050787,   74.7414398,   2.72727275
  40071,    8.3073988,   75.0205612,   2.72727275
  40072,   7.50118256,   75.2739716,   2.72727275
  40073,   6.68725777,   75.5014114,   2.72727275
  40074,   5.86646032,   75.7026443,   2.72727275
  40075,   5.03963661,   75.8774719,   2.72727275
  40076,   4.20763302,   76.0257034,   2.72727275
  40077,    3.3713069,   76.1471939,   2.72727275
  40078,   2.53151608,   76.2418137,   2.72727275
  40079,   1.68912399,   76.3094711,   2.72727275
  40080,  0.844996154,     76.35009,   2.72727275
  40081,           0.,   76.3636398,   2.72727275
  40082, -0.844996154,     76.35009,   2.72727275
  40083,  -1.68912399,   76.3094711,   2.72727275
  40084,  -2.53151608,   76.2418137,   2.72727275
  40085,   -3.3713069,   76.1471939,   2.72727275
  40086,  -4.20763302,   76.0257034,   2.72727275
  40087,  -5.03963661,   75.8774719,   2.72727275
  40088,  -5.86646032,   75.7026443,   2.72727275
  40089,  -6.68725777,   75.5014114,   2.72727275
  40090,  -7.50118256,   75.2739716,   2.72727275
  40091,   -8.3073988,   75.0205612,   2.72727275
  40092,   -9.1050787,   74.7414398,   2.72727275
  40093,  -9.89340305,   74.4368973,   2.72727275
  40094,  -10.6715603,   74.1072388,   2.72727275
  40095,  -11.4387522,   73.7528152,   2.72727275
  40096,  -12.1941919,   73.3739853,   2.72727275
  40097,  -12.9370985,   72.9711304,   2.72727275
  40098,  -13.6667137,   72.5446701,   2.72727275
  40099,  -14.3822823,    72.095047,   2.72727275
  40100,  -15.0830746,   71.6227264,   2.72727275
  40101,  -15.7683668,   71.1281738,   2.72727275
  40102,  -16.4374599,   70.6119232,   2.72727275
  40103,  -17.0896568,   70.0744858,   2.72727275
  40104,  -17.7242966,   69.5164185,   2.72727275
  40105,  -18.3407192,   68.9383011,   2.72727275
  40106,  -18.9383011,   68.3407211,   2.72727275
  40107,  -19.5164185,   67.7242966,   2.72727275
  40108,  -20.0744839,   67.0896606,   2.72727275
  40109,  -20.6119194,   66.4374619,   2.72727275
  40110,  -21.1281796,   65.7683716,   2.72727275
  40111,  -21.6227245,   65.0830765,   2.72727275
  40112,  -22.0950489,   64.3822861,   2.72727275
  40113,  -22.5446701,   63.6667137,   2.72727275
  40114,  -22.9711304,   62.9370995,   2.72727275
  40115,  -23.3739815,    62.194191,   2.72727275
  40116,  -23.7528152,   61.4387512,   2.72727275
  40117,  -24.1072426,   60.6715622,   2.72727275
  40118,  -24.4368973,   59.8934021,   2.72727275
  40119,  -24.7414398,   59.1050797,   2.72727275
  40120,  -25.0205612,   58.3073997,   2.72727275
  40121,  -25.2739716,   57.5011826,   2.72727275
  40122,  -25.5014095,   56.6872559,   2.72727275
  40123,  -25.7026443,   55.8664627,   2.72727275
  40124,  -25.8774662,   55.0396347,   2.72727275
  40125,  -26.0257015,    54.207634,   2.72727275
  40126,   -26.147192,   53.3713074,   2.72727275
  40127,  -26.2418137,    52.531517,   2.72727275
  40128,  -26.3094692,   51.6891251,   2.72727275
  40129,  -26.3500919,   50.8449974,   2.72727275
  40130,   26.3500919,   50.8449974,   3.63636374
  40131,   26.3094692,   51.6891251,   3.63636374
  40132,   26.2418137,    52.531517,   3.63636374
  40133,    26.147192,   53.3713074,   3.63636374
  40134,   26.0257015,    54.207634,   3.63636374
  40135,   25.8774662,   55.0396347,   3.63636374
  40136,   25.7026443,   55.8664627,   3.63636374
  40137,   25.5014095,   56.6872559,   3.63636374
  40138,   25.2739716,   57.5011826,   3.63636374
  40139,   25.0205612,   58.3073997,   3.63636374
  40140,   24.7414398,   59.1050797,   3.63636374
  40141,   24.4368973,   59.8934021,   3.63636374
  40142,   24.1072426,   60.6715622,   3.63636374
  40143,   23.7528152,   61.4387512,   3.63636374
  40144,   23.3739815,    62.194191,   3.63636374
  40145,   22.9711304,   62.9370995,   3.63636374
  40146,   22.5446701,   63.6667137,   3.63636374
  40147,   22.0950489,   64.3822861,   3.63636374
  40148,   21.6227245,   65.0830765,   3.63636374
  40149,   21.1281796,   65.7683716,   3.63636374
  40150,   20.6119194,   66.4374619,   3.63636374
  40151,   20.0744839,   67.0896606,   3.63636374
  40152,   19.5164185,   67.7242966,   3.63636374
  40153,   18.9383011,   68.3407211,   3.63636374
  40154,   18.3407192,   68.9383011,   3.63636374
  40155,   17.7242966,   69.5164185,   3.63636374
  40156,   17.0896568,   70.0744858,   3.63636374
  40157,   16.4374599,   70.6119232,   3.63636374
  40158,   15.7683668,   71.1281738,   3.63636374
  40159,   15.0830746,   71.6227264,   3.63636374
  40160,   14.3822823,    72.095047,   3.63636374
  40161,   13.6667137,   72.5446701,   3.63636374
  40162,   12.9370985,   72.9711304,   3.63636374
  40163,   12.1941919,   73.3739853,   3.63636374
  40164,   11.4387522,   73.7528152,   3.63636374
  40165,   10.6715603,   74.1072388,   3.63636374
  40166,   9.89340305,   74.4368973,   3.63636374
  40167,    9.1050787,   74.7414398,   3.63636374
  40168,    8.3073988,   75.0205612,   3.63636374
  40169,   7.50118256,   75.2739716,   3.63636374
  40170,   6.68725777,   75.5014114,   3.63636374
  40171,   5.86646032,   75.7026443,   3.63636374
  40172,   5.03963661,   75.8774719,   3.63636374
  40173,   4.20763302,   76.0257034,   3.63636374
  40174,    3.3713069,   76.1471939,   3.63636374
  40175,   2.53151608,   76.2418137,   3.63636374
  40176,   1.68912399,   76.3094711,   3.63636374
  40177,  0.844996154,     76.35009,   3.63636374
  40178,           0.,   76.3636398,   3.63636374
  40179, -0.844996154,     76.35009,   3.63636374
  40180,  -1.68912399,   76.3094711,   3.63636374
  40181,  -2.53151608,   76.2418137,   3.63636374
  40182,   -3.3713069,   76.1471939,   3.63636374
  40183,  -4.20763302,   76.0257034,   3.63636374
  40184,  -5.03963661,   75.8774719,   3.63636374
  40185,  -5.86646032,   75.7026443,   3.63636374
  40186,  -6.68725777,   75.5014114,   3.63636374
  40187,  -7.50118256,   75.2739716,   3.63636374
  40188,   -8.3073988,   75.0205612,   3.63636374
  40189,   -9.1050787,   74.7414398,   3.63636374
  40190,  -9.89340305,   74.4368973,   3.63636374
  40191,  -10.6715603,   74.1072388,   3.63636374
  40192,  -11.4387522,   73.7528152,   3.63636374
  40193,  -12.1941919,   73.3739853,   3.63636374
  40194,  -12.9370985,   72.9711304,   3.63636374
  40195,  -13.6667137,   72.5446701,   3.63636374
  40196,  -14.3822823,    72.095047,   3.63636374
  40197,  -15.0830746,   71.6227264,   3.63636374
  40198,  -15.7683668,   71.1281738,   3.63636374
  40199,  -16.4374599,   70.6119232,   3.63636374
  40200,  -17.0896568,   70.0744858,   3.63636374
  40201,  -17.7242966,   69.5164185,   3.63636374
  40202,  -18.3407192,   68.9383011,   3.63636374
  40203,  -18.9383011,   68.3407211,   3.63636374
  40204,  -19.5164185,   67.7242966,   3.63636374
  40205,  -20.0744839,   67.0896606,   3.63636374
  40206,  -20.6119194,   66.4374619,   3.63636374
  40207,  -21.1281796,   65.7683716,   3.63636374
  40208,  -21.6227245,   65.0830765,   3.63636374
  40209,  -22.0950489,   64.3822861,   3.63636374
  40210,  -22.5446701,   63.6667137,   3.63636374
  40211,  -22.9711304,   62.9370995,   3.63636374
  40212,  -23.3739815,    62.194191,   3.63636374
  40213,  -23.7528152,   61.4387512,   3.63636374
  40214,  -24.1072426,   60.6715622,   3.63636374
  40215,  -24.4368973,   59.8934021,   3.63636374
  40216,  -24.7414398,   59.1050797,   3.63636374
  40217,  -25.0205612,   58.3073997,   3.63636374
  40218,  -25.2739716,   57.5011826,   3.63636374
  40219,  -25.5014095,   56.6872559,   3.63636374
  40220,  -25.7026443,   55.8664627,   3.63636374
  40221,  -25.8774662,   55.0396347,   3.63636374
  40222,  -26.0257015,    54.207634,   3.63636374
  40223,   -26.147192,   53.3713074,   3.63636374
  40224,  -26.2418137,    52.531517,   3.63636374
  40225,  -26.3094692,   51.6891251,   3.63636374
  40226,  -26.3500919,   50.8449974,   3.63636374
  40227,   26.3500919,   50.8449974,    4.5454545
  40228,   26.3094692,   51.6891251,    4.5454545
  40229,   26.2418137,    52.531517,    4.5454545
  40230,    26.147192,   53.3713074,    4.5454545
  40231,   26.0257015,    54.207634,    4.5454545
  40232,   25.8774662,   55.0396347,    4.5454545
  40233,   25.7026443,   55.8664627,    4.5454545
  40234,   25.5014095,   56.6872559,    4.5454545
  40235,   25.2739716,   57.5011826,    4.5454545
  40236,   25.0205612,   58.3073997,    4.5454545
  40237,   24.7414398,   59.1050797,    4.5454545
  40238,   24.4368973,   59.8934021,    4.5454545
  40239,   24.1072426,   60.6715622,    4.5454545
  40240,   23.7528152,   61.4387512,    4.5454545
  40241,   23.3739815,    62.194191,    4.5454545
  40242,   22.9711304,   62.9370995,    4.5454545
  40243,   22.5446701,   63.6667137,    4.5454545
  40244,   22.0950489,   64.3822861,    4.5454545
  40245,   21.6227245,   65.0830765,    4.5454545
  40246,   21.1281796,   65.7683716,    4.5454545
  40247,   20.6119194,   66.4374619,    4.5454545
  40248,   20.0744839,   67.0896606,    4.5454545
  40249,   19.5164185,   67.7242966,    4.5454545
  40250,   18.9383011,   68.3407211,    4.5454545
  40251,   18.3407192,   68.9383011,    4.5454545
  40252,   17.7242966,   69.5164185,    4.5454545
  40253,   17.0896568,   70.0744858,    4.5454545
  40254,   16.4374599,   70.6119232,    4.5454545
  40255,   15.7683668,   71.1281738,    4.5454545
  40256,   15.0830746,   71.6227264,    4.5454545
  40257,   14.3822823,    72.095047,    4.5454545
  40258,   13.6667137,   72.5446701,    4.5454545
  40259,   12.9370985,   72.9711304,    4.5454545
  40260,   12.1941919,   73.3739853,    4.5454545
  40261,   11.4387522,   73.7528152,    4.5454545
  40262,   10.6715603,   74.1072388,    4.5454545
  40263,   9.89340305,   74.4368973,    4.5454545
  40264,    9.1050787,   74.7414398,    4.5454545
  40265,    8.3073988,   75.0205612,    4.5454545
  40266,   7.50118256,   75.2739716,    4.5454545
  40267,   6.68725777,   75.5014114,    4.5454545
  40268,   5.86646032,   75.7026443,    4.5454545
  40269,   5.03963661,   75.8774719,    4.5454545
  40270,   4.20763302,   76.0257034,    4.5454545
  40271,    3.3713069,   76.1471939,    4.5454545
  40272,   2.53151608,   76.2418137,    4.5454545
  40273,   1.68912399,   76.3094711,    4.5454545
  40274,  0.844996154,     76.35009,    4.5454545
  40275,           0.,   76.3636398,    4.5454545
  40276, -0.844996154,     76.35009,    4.5454545
  40277,  -1.68912399,   76.3094711,    4.5454545
  40278,  -2.53151608,   76.2418137,    4.5454545
  40279,   -3.3713069,   76.1471939,    4.5454545
  40280,  -4.20763302,   76.0257034,    4.5454545
  40281,  -5.03963661,   75.8774719,    4.5454545
  40282,  -5.86646032,   75.7026443,    4.5454545
  40283,  -6.68725777,   75.5014114,    4.5454545
  40284,  -7.50118256,   75.2739716,    4.5454545
  40285,   -8.3073988,   75.0205612,    4.5454545
  40286,   -9.1050787,   74.7414398,    4.5454545
  40287,  -9.89340305,   74.4368973,    4.5454545
  40288,  -10.6715603,   74.1072388,    4.5454545
  40289,  -11.4387522,   73.7528152,    4.5454545
  40290,  -12.1941919,   73.3739853,    4.5454545
  40291,  -12.9370985,   72.9711304,    4.5454545
  40292,  -13.6667137,   72.5446701,    4.5454545
  40293,  -14.3822823,    72.095047,    4.5454545
  40294,  -15.0830746,   71.6227264,    4.5454545
  40295,  -15.7683668,   71.1281738,    4.5454545
  40296,  -16.4374599,   70.6119232,    4.5454545
  40297,  -17.0896568,   70.0744858,    4.5454545
  40298,  -17.7242966,   69.5164185,    4.5454545
  40299,  -18.3407192,   68.9383011,    4.5454545
  40300,  -18.9383011,   68.3407211,    4.5454545
  40301,  -19.5164185,   67.7242966,    4.5454545
  40302,  -20.0744839,   67.0896606,    4.5454545
  40303,  -20.6119194,   66.4374619,    4.5454545
  40304,  -21.1281796,   65.7683716,    4.5454545
  40305,  -21.6227245,   65.0830765,    4.5454545
  40306,  -22.0950489,   64.3822861,    4.5454545
  40307,  -22.5446701,   63.6667137,    4.5454545
  40308,  -22.9711304,   62.9370995,    4.5454545
  40309,  -23.3739815,    62.194191,    4.5454545
  40310,  -23.7528152,   61.4387512,    4.5454545
  40311,  -24.1072426,   60.6715622,    4.5454545
  40312,  -24.4368973,   59.8934021,    4.5454545
  40313,  -24.7414398,   59.1050797,    4.5454545
  40314,  -25.0205612,   58.3073997,    4.5454545
  40315,  -25.2739716,   57.5011826,    4.5454545
  40316,  -25.5014095,   56.6872559,    4.5454545
  40317,  -25.7026443,   55.8664627,    4.5454545
  40318,  -25.8774662,   55.0396347,    4.5454545
  40319,  -26.0257015,    54.207634,    4.5454545
  40320,   -26.147192,   53.3713074,    4.5454545
  40321,  -26.2418137,    52.531517,    4.5454545
  40322,  -26.3094692,   51.6891251,    4.5454545
  40323,  -26.3500919,   50.8449974,    4.5454545
  40324,   26.3500919,   50.8449974,    5.4545455
  40325,   26.3094692,   51.6891251,    5.4545455
  40326,   26.2418137,    52.531517,    5.4545455
  40327,    26.147192,   53.3713074,    5.4545455
  40328,   26.0257015,    54.207634,    5.4545455
  40329,   25.8774662,   55.0396347,    5.4545455
  40330,   25.7026443,   55.8664627,    5.4545455
  40331,   25.5014095,   56.6872559,    5.4545455
  40332,   25.2739716,   57.5011826,    5.4545455
  40333,   25.0205612,   58.3073997,    5.4545455
  40334,   24.7414398,   59.1050797,    5.4545455
  40335,   24.4368973,   59.8934021,    5.4545455
  40336,   24.1072426,   60.6715622,    5.4545455
  40337,   23.7528152,   61.4387512,    5.4545455
  40338,   23.3739815,    62.194191,    5.4545455
  40339,   22.9711304,   62.9370995,    5.4545455
  40340,   22.5446701,   63.6667137,    5.4545455
  40341,   22.0950489,   64.3822861,    5.4545455
  40342,   21.6227245,   65.0830765,    5.4545455
  40343,   21.1281796,   65.7683716,    5.4545455
  40344,   20.6119194,   66.4374619,    5.4545455
  40345,   20.0744839,   67.0896606,    5.4545455
  40346,   19.5164185,   67.7242966,    5.4545455
  40347,   18.9383011,   68.3407211,    5.4545455
  40348,   18.3407192,   68.9383011,    5.4545455
  40349,   17.7242966,   69.5164185,    5.4545455
  40350,   17.0896568,   70.0744858,    5.4545455
  40351,   16.4374599,   70.6119232,    5.4545455
  40352,   15.7683668,   71.1281738,    5.4545455
  40353,   15.0830746,   71.6227264,    5.4545455
  40354,   14.3822823,    72.095047,    5.4545455
  40355,   13.6667137,   72.5446701,    5.4545455
  40356,   12.9370985,   72.9711304,    5.4545455
  40357,   12.1941919,   73.3739853,    5.4545455
  40358,   11.4387522,   73.7528152,    5.4545455
  40359,   10.6715603,   74.1072388,    5.4545455
  40360,   9.89340305,   74.4368973,    5.4545455
  40361,    9.1050787,   74.7414398,    5.4545455
  40362,    8.3073988,   75.0205612,    5.4545455
  40363,   7.50118256,   75.2739716,    5.4545455
  40364,   6.68725777,   75.5014114,    5.4545455
  40365,   5.86646032,   75.7026443,    5.4545455
  40366,   5.03963661,   75.8774719,    5.4545455
  40367,   4.20763302,   76.0257034,    5.4545455
  40368,    3.3713069,   76.1471939,    5.4545455
  40369,   2.53151608,   76.2418137,    5.4545455
  40370,   1.68912399,   76.3094711,    5.4545455
  40371,  0.844996154,     76.35009,    5.4545455
  40372,           0.,   76.3636398,    5.4545455
  40373, -0.844996154,     76.35009,    5.4545455
  40374,  -1.68912399,   76.3094711,    5.4545455
  40375,  -2.53151608,   76.2418137,    5.4545455
  40376,   -3.3713069,   76.1471939,    5.4545455
  40377,  -4.20763302,   76.0257034,    5.4545455
  40378,  -5.03963661,   75.8774719,    5.4545455
  40379,  -5.86646032,   75.7026443,    5.4545455
  40380,  -6.68725777,   75.5014114,    5.4545455
  40381,  -7.50118256,   75.2739716,    5.4545455
  40382,   -8.3073988,   75.0205612,    5.4545455
  40383,   -9.1050787,   74.7414398,    5.4545455
  40384,  -9.89340305,   74.4368973,    5.4545455
  40385,  -10.6715603,   74.1072388,    5.4545455
  40386,  -11.4387522,   73.7528152,    5.4545455
  40387,  -12.1941919,   73.3739853,    5.4545455
  40388,  -12.9370985,   72.9711304,    5.4545455
  40389,  -13.6667137,   72.5446701,    5.4545455
  40390,  -14.3822823,    72.095047,    5.4545455
  40391,  -15.0830746,   71.6227264,    5.4545455
  40392,  -15.7683668,   71.1281738,    5.4545455
  40393,  -16.4374599,   70.6119232,    5.4545455
  40394,  -17.0896568,   70.0744858,    5.4545455
  40395,  -17.7242966,   69.5164185,    5.4545455
  40396,  -18.3407192,   68.9383011,    5.4545455
  40397,  -18.9383011,   68.3407211,    5.4545455
  40398,  -19.5164185,   67.7242966,    5.4545455
  40399,  -20.0744839,   67.0896606,    5.4545455
  40400,  -20.6119194,   66.4374619,    5.4545455
  40401,  -21.1281796,   65.7683716,    5.4545455
  40402,  -21.6227245,   65.0830765,    5.4545455
  40403,  -22.0950489,   64.3822861,    5.4545455
  40404,  -22.5446701,   63.6667137,    5.4545455
  40405,  -22.9711304,   62.9370995,    5.4545455
  40406,  -23.3739815,    62.194191,    5.4545455
  40407,  -23.7528152,   61.4387512,    5.4545455
  40408,  -24.1072426,   60.6715622,    5.4545455
  40409,  -24.4368973,   59.8934021,    5.4545455
  40410,  -24.7414398,   59.1050797,    5.4545455
  40411,  -25.0205612,   58.3073997,    5.4545455
  40412,  -25.2739716,   57.5011826,    5.4545455
  40413,  -25.5014095,   56.6872559,    5.4545455
  40414,  -25.7026443,   55.8664627,    5.4545455
  40415,  -25.8774662,   55.0396347,    5.4545455
  40416,  -26.0257015,    54.207634,    5.4545455
  40417,   -26.147192,   53.3713074,    5.4545455
  40418,  -26.2418137,    52.531517,    5.4545455
  40419,  -26.3094692,   51.6891251,    5.4545455
  40420,  -26.3500919,   50.8449974,    5.4545455
  40421,   26.3500919,   50.8449974,   6.36363649
  40422,   26.3094692,   51.6891251,   6.36363649
  40423,   26.2418137,    52.531517,   6.36363649
  40424,    26.147192,   53.3713074,   6.36363649
  40425,   26.0257015,    54.207634,   6.36363649
  40426,   25.8774662,   55.0396347,   6.36363649
  40427,   25.7026443,   55.8664627,   6.36363649
  40428,   25.5014095,   56.6872559,   6.36363649
  40429,   25.2739716,   57.5011826,   6.36363649
  40430,   25.0205612,   58.3073997,   6.36363649
  40431,   24.7414398,   59.1050797,   6.36363649
  40432,   24.4368973,   59.8934021,   6.36363649
  40433,   24.1072426,   60.6715622,   6.36363649
  40434,   23.7528152,   61.4387512,   6.36363649
  40435,   23.3739815,    62.194191,   6.36363649
  40436,   22.9711304,   62.9370995,   6.36363649
  40437,   22.5446701,   63.6667137,   6.36363649
  40438,   22.0950489,   64.3822861,   6.36363649
  40439,   21.6227245,   65.0830765,   6.36363649
  40440,   21.1281796,   65.7683716,   6.36363649
  40441,   20.6119194,   66.4374619,   6.36363649
  40442,   20.0744839,   67.0896606,   6.36363649
  40443,   19.5164185,   67.7242966,   6.36363649
  40444,   18.9383011,   68.3407211,   6.36363649
  40445,   18.3407192,   68.9383011,   6.36363649
  40446,   17.7242966,   69.5164185,   6.36363649
  40447,   17.0896568,   70.0744858,   6.36363649
  40448,   16.4374599,   70.6119232,   6.36363649
  40449,   15.7683668,   71.1281738,   6.36363649
  40450,   15.0830746,   71.6227264,   6.36363649
  40451,   14.3822823,    72.095047,   6.36363649
  40452,   13.6667137,   72.5446701,   6.36363649
  40453,   12.9370985,   72.9711304,   6.36363649
  40454,   12.1941919,   73.3739853,   6.36363649
  40455,   11.4387522,   73.7528152,   6.36363649
  40456,   10.6715603,   74.1072388,   6.36363649
  40457,   9.89340305,   74.4368973,   6.36363649
  40458,    9.1050787,   74.7414398,   6.36363649
  40459,    8.3073988,   75.0205612,   6.36363649
  40460,   7.50118256,   75.2739716,   6.36363649
  40461,   6.68725777,   75.5014114,   6.36363649
  40462,   5.86646032,   75.7026443,   6.36363649
  40463,   5.03963661,   75.8774719,   6.36363649
  40464,   4.20763302,   76.0257034,   6.36363649
  40465,    3.3713069,   76.1471939,   6.36363649
  40466,   2.53151608,   76.2418137,   6.36363649
  40467,   1.68912399,   76.3094711,   6.36363649
  40468,  0.844996154,     76.35009,   6.36363649
  40469,           0.,   76.3636398,   6.36363649
  40470, -0.844996154,     76.35009,   6.36363649
  40471,  -1.68912399,   76.3094711,   6.36363649
  40472,  -2.53151608,   76.2418137,   6.36363649
  40473,   -3.3713069,   76.1471939,   6.36363649
  40474,  -4.20763302,   76.0257034,   6.36363649
  40475,  -5.03963661,   75.8774719,   6.36363649
  40476,  -5.86646032,   75.7026443,   6.36363649
  40477,  -6.68725777,   75.5014114,   6.36363649
  40478,  -7.50118256,   75.2739716,   6.36363649
  40479,   -8.3073988,   75.0205612,   6.36363649
  40480,   -9.1050787,   74.7414398,   6.36363649
  40481,  -9.89340305,   74.4368973,   6.36363649
  40482,  -10.6715603,   74.1072388,   6.36363649
  40483,  -11.4387522,   73.7528152,   6.36363649
  40484,  -12.1941919,   73.3739853,   6.36363649
  40485,  -12.9370985,   72.9711304,   6.36363649
  40486,  -13.6667137,   72.5446701,   6.36363649
  40487,  -14.3822823,    72.095047,   6.36363649
  40488,  -15.0830746,   71.6227264,   6.36363649
  40489,  -15.7683668,   71.1281738,   6.36363649
  40490,  -16.4374599,   70.6119232,   6.36363649
  40491,  -17.0896568,   70.0744858,   6.36363649
  40492,  -17.7242966,   69.5164185,   6.36363649
  40493,  -18.3407192,   68.9383011,   6.36363649
  40494,  -18.9383011,   68.3407211,   6.36363649
  40495,  -19.5164185,   67.7242966,   6.36363649
  40496,  -20.0744839,   67.0896606,   6.36363649
  40497,  -20.6119194,   66.4374619,   6.36363649
  40498,  -21.1281796,   65.7683716,   6.36363649
  40499,  -21.6227245,   65.0830765,   6.36363649
  40500,  -22.0950489,   64.3822861,   6.36363649
  40501,  -22.5446701,   63.6667137,   6.36363649
  40502,  -22.9711304,   62.9370995,   6.36363649
  40503,  -23.3739815,    62.194191,   6.36363649
  40504,  -23.7528152,   61.4387512,   6.36363649
  40505,  -24.1072426,   60.6715622,   6.36363649
  40506,  -24.4368973,   59.8934021,   6.36363649
  40507,  -24.7414398,   59.1050797,   6.36363649
  40508,  -25.0205612,   58.3073997,   6.36363649
  40509,  -25.2739716,   57.5011826,   6.36363649
  40510,  -25.5014095,   56.6872559,   6.36363649
  40511,  -25.7026443,   55.8664627,   6.36363649
  40512,  -25.8774662,   55.0396347,   6.36363649
  40513,  -26.0257015,    54.207634,   6.36363649
  40514,   -26.147192,   53.3713074,   6.36363649
  40515,  -26.2418137,    52.531517,   6.36363649
  40516,  -26.3094692,   51.6891251,   6.36363649
  40517,  -26.3500919,   50.8449974,   6.36363649
  40518,   26.3500919,   50.8449974,   7.27272749
  40519,   26.3094692,   51.6891251,   7.27272749
  40520,   26.2418137,    52.531517,   7.27272749
  40521,    26.147192,   53.3713074,   7.27272749
  40522,   26.0257015,    54.207634,   7.27272749
  40523,   25.8774662,   55.0396347,   7.27272749
  40524,   25.7026443,   55.8664627,   7.27272749
  40525,   25.5014095,   56.6872559,   7.27272749
  40526,   25.2739716,   57.5011826,   7.27272749
  40527,   25.0205612,   58.3073997,   7.27272749
  40528,   24.7414398,   59.1050797,   7.27272749
  40529,   24.4368973,   59.8934021,   7.27272749
  40530,   24.1072426,   60.6715622,   7.27272749
  40531,   23.7528152,   61.4387512,   7.27272749
  40532,   23.3739815,    62.194191,   7.27272749
  40533,   22.9711304,   62.9370995,   7.27272749
  40534,   22.5446701,   63.6667137,   7.27272749
  40535,   22.0950489,   64.3822861,   7.27272749
  40536,   21.6227245,   65.0830765,   7.27272749
  40537,   21.1281796,   65.7683716,   7.27272749
  40538,   20.6119194,   66.4374619,   7.27272749
  40539,   20.0744839,   67.0896606,   7.27272749
  40540,   19.5164185,   67.7242966,   7.27272749
  40541,   18.9383011,   68.3407211,   7.27272749
  40542,   18.3407192,   68.9383011,   7.27272749
  40543,   17.7242966,   69.5164185,   7.27272749
  40544,   17.0896568,   70.0744858,   7.27272749
  40545,   16.4374599,   70.6119232,   7.27272749
  40546,   15.7683668,   71.1281738,   7.27272749
  40547,   15.0830746,   71.6227264,   7.27272749
  40548,   14.3822823,    72.095047,   7.27272749
  40549,   13.6667137,   72.5446701,   7.27272749
  40550,   12.9370985,   72.9711304,   7.27272749
  40551,   12.1941919,   73.3739853,   7.27272749
  40552,   11.4387522,   73.7528152,   7.27272749
  40553,   10.6715603,   74.1072388,   7.27272749
  40554,   9.89340305,   74.4368973,   7.27272749
  40555,    9.1050787,   74.7414398,   7.27272749
  40556,    8.3073988,   75.0205612,   7.27272749
  40557,   7.50118256,   75.2739716,   7.27272749
  40558,   6.68725777,   75.5014114,   7.27272749
  40559,   5.86646032,   75.7026443,   7.27272749
  40560,   5.03963661,   75.8774719,   7.27272749
  40561,   4.20763302,   76.0257034,   7.27272749
  40562,    3.3713069,   76.1471939,   7.27272749
  40563,   2.53151608,   76.2418137,   7.27272749
  40564,   1.68912399,   76.3094711,   7.27272749
  40565,  0.844996154,     76.35009,   7.27272749
  40566,           0.,   76.3636398,   7.27272749
  40567, -0.844996154,     76.35009,   7.27272749
  40568,  -1.68912399,   76.3094711,   7.27272749
  40569,  -2.53151608,   76.2418137,   7.27272749
  40570,   -3.3713069,   76.1471939,   7.27272749
  40571,  -4.20763302,   76.0257034,   7.27272749
  40572,  -5.03963661,   75.8774719,   7.27272749
  40573,  -5.86646032,   75.7026443,   7.27272749
  40574,  -6.68725777,   75.5014114,   7.27272749
  40575,  -7.50118256,   75.2739716,   7.27272749
  40576,   -8.3073988,   75.0205612,   7.27272749
  40577,   -9.1050787,   74.7414398,   7.27272749
  40578,  -9.89340305,   74.4368973,   7.27272749
  40579,  -10.6715603,   74.1072388,   7.27272749
  40580,  -11.4387522,   73.7528152,   7.27272749
  40581,  -12.1941919,   73.3739853,   7.27272749
  40582,  -12.9370985,   72.9711304,   7.27272749
  40583,  -13.6667137,   72.5446701,   7.27272749
  40584,  -14.3822823,    72.095047,   7.27272749
  40585,  -15.0830746,   71.6227264,   7.27272749
  40586,  -15.7683668,   71.1281738,   7.27272749
  40587,  -16.4374599,   70.6119232,   7.27272749
  40588,  -17.0896568,   70.0744858,   7.27272749
  40589,  -17.7242966,   69.5164185,   7.27272749
  40590,  -18.3407192,   68.9383011,   7.27272749
  40591,  -18.9383011,   68.3407211,   7.27272749
  40592,  -19.5164185,   67.7242966,   7.27272749
  40593,  -20.0744839,   67.0896606,   7.27272749
  40594,  -20.6119194,   66.4374619,   7.27272749
  40595,  -21.1281796,   65.7683716,   7.27272749
  40596,  -21.6227245,   65.0830765,   7.27272749
  40597,  -22.0950489,   64.3822861,   7.27272749
  40598,  -22.5446701,   63.6667137,   7.27272749
  40599,  -22.9711304,   62.9370995,   7.27272749
  40600,  -23.3739815,    62.194191,   7.27272749
  40601,  -23.7528152,   61.4387512,   7.27272749
  40602,  -24.1072426,   60.6715622,   7.27272749
  40603,  -24.4368973,   59.8934021,   7.27272749
  40604,  -24.7414398,   59.1050797,   7.27272749
  40605,  -25.0205612,   58.3073997,   7.27272749
  40606,  -25.2739716,   57.5011826,   7.27272749
  40607,  -25.5014095,   56.6872559,   7.27272749
  40608,  -25.7026443,   55.8664627,   7.27272749
  40609,  -25.8774662,   55.0396347,   7.27272749
  40610,  -26.0257015,    54.207634,   7.27272749
  40611,   -26.147192,   53.3713074,   7.27272749
  40612,  -26.2418137,    52.531517,   7.27272749
  40613,  -26.3094692,   51.6891251,   7.27272749
  40614,  -26.3500919,   50.8449974,   7.27272749
  40615,   26.3500919,   50.8449974,   8.18181801
  40616,   26.3094692,   51.6891251,   8.18181801
  40617,   26.2418137,    52.531517,   8.18181801
  40618,    26.147192,   53.3713074,   8.18181801
  40619,   26.0257015,    54.207634,   8.18181801
  40620,   25.8774662,   55.0396347,   8.18181801
  40621,   25.7026443,   55.8664627,   8.18181801
  40622,   25.5014095,   56.6872559,   8.18181801
  40623,   25.2739716,   57.5011826,   8.18181801
  40624,   25.0205612,   58.3073997,   8.18181801
  40625,   24.7414398,   59.1050797,   8.18181801
  40626,   24.4368973,   59.8934021,   8.18181801
  40627,   24.1072426,   60.6715622,   8.18181801
  40628,   23.7528152,   61.4387512,   8.18181801
  40629,   23.3739815,    62.194191,   8.18181801
  40630,   22.9711304,   62.9370995,   8.18181801
  40631,   22.5446701,   63.6667137,   8.18181801
  40632,   22.0950489,   64.3822861,   8.18181801
  40633,   21.6227245,   65.0830765,   8.18181801
  40634,   21.1281796,   65.7683716,   8.18181801
  40635,   20.6119194,   66.4374619,   8.18181801
  40636,   20.0744839,   67.0896606,   8.18181801
  40637,   19.5164185,   67.7242966,   8.18181801
  40638,   18.9383011,   68.3407211,   8.18181801
  40639,   18.3407192,   68.9383011,   8.18181801
  40640,   17.7242966,   69.5164185,   8.18181801
  40641,   17.0896568,   70.0744858,   8.18181801
  40642,   16.4374599,   70.6119232,   8.18181801
  40643,   15.7683668,   71.1281738,   8.18181801
  40644,   15.0830746,   71.6227264,   8.18181801
  40645,   14.3822823,    72.095047,   8.18181801
  40646,   13.6667137,   72.5446701,   8.18181801
  40647,   12.9370985,   72.9711304,   8.18181801
  40648,   12.1941919,   73.3739853,   8.18181801
  40649,   11.4387522,   73.7528152,   8.18181801
  40650,   10.6715603,   74.1072388,   8.18181801
  40651,   9.89340305,   74.4368973,   8.18181801
  40652,    9.1050787,   74.7414398,   8.18181801
  40653,    8.3073988,   75.0205612,   8.18181801
  40654,   7.50118256,   75.2739716,   8.18181801
  40655,   6.68725777,   75.5014114,   8.18181801
  40656,   5.86646032,   75.7026443,   8.18181801
  40657,   5.03963661,   75.8774719,   8.18181801
  40658,   4.20763302,   76.0257034,   8.18181801
  40659,    3.3713069,   76.1471939,   8.18181801
  40660,   2.53151608,   76.2418137,   8.18181801
  40661,   1.68912399,   76.3094711,   8.18181801
  40662,  0.844996154,     76.35009,   8.18181801
  40663,           0.,   76.3636398,   8.18181801
  40664, -0.844996154,     76.35009,   8.18181801
  40665,  -1.68912399,   76.3094711,   8.18181801
  40666,  -2.53151608,   76.2418137,   8.18181801
  40667,   -3.3713069,   76.1471939,   8.18181801
  40668,  -4.20763302,   76.0257034,   8.18181801
  40669,  -5.03963661,   75.8774719,   8.18181801
  40670,  -5.86646032,   75.7026443,   8.18181801
  40671,  -6.68725777,   75.5014114,   8.18181801
  40672,  -7.50118256,   75.2739716,   8.18181801
  40673,   -8.3073988,   75.0205612,   8.18181801
  40674,   -9.1050787,   74.7414398,   8.18181801
  40675,  -9.89340305,   74.4368973,   8.18181801
  40676,  -10.6715603,   74.1072388,   8.18181801
  40677,  -11.4387522,   73.7528152,   8.18181801
  40678,  -12.1941919,   73.3739853,   8.18181801
  40679,  -12.9370985,   72.9711304,   8.18181801
  40680,  -13.6667137,   72.5446701,   8.18181801
  40681,  -14.3822823,    72.095047,   8.18181801
  40682,  -15.0830746,   71.6227264,   8.18181801
  40683,  -15.7683668,   71.1281738,   8.18181801
  40684,  -16.4374599,   70.6119232,   8.18181801
  40685,  -17.0896568,   70.0744858,   8.18181801
  40686,  -17.7242966,   69.5164185,   8.18181801
  40687,  -18.3407192,   68.9383011,   8.18181801
  40688,  -18.9383011,   68.3407211,   8.18181801
  40689,  -19.5164185,   67.7242966,   8.18181801
  40690,  -20.0744839,   67.0896606,   8.18181801
  40691,  -20.6119194,   66.4374619,   8.18181801
  40692,  -21.1281796,   65.7683716,   8.18181801
  40693,  -21.6227245,   65.0830765,   8.18181801
  40694,  -22.0950489,   64.3822861,   8.18181801
  40695,  -22.5446701,   63.6667137,   8.18181801
  40696,  -22.9711304,   62.9370995,   8.18181801
  40697,  -23.3739815,    62.194191,   8.18181801
  40698,  -23.7528152,   61.4387512,   8.18181801
  40699,  -24.1072426,   60.6715622,   8.18181801
  40700,  -24.4368973,   59.8934021,   8.18181801
  40701,  -24.7414398,   59.1050797,   8.18181801
  40702,  -25.0205612,   58.3073997,   8.18181801
  40703,  -25.2739716,   57.5011826,   8.18181801
  40704,  -25.5014095,   56.6872559,   8.18181801
  40705,  -25.7026443,   55.8664627,   8.18181801
  40706,  -25.8774662,   55.0396347,   8.18181801
  40707,  -26.0257015,    54.207634,   8.18181801
  40708,   -26.147192,   53.3713074,   8.18181801
  40709,  -26.2418137,    52.531517,   8.18181801
  40710,  -26.3094692,   51.6891251,   8.18181801
  40711,  -26.3500919,   50.8449974,   8.18181801
  40712,   26.3500919,   50.8449974,     9.090909
  40713,   26.3094692,   51.6891251,     9.090909
  40714,   26.2418137,    52.531517,     9.090909
  40715,    26.147192,   53.3713074,     9.090909
  40716,   26.0257015,    54.207634,     9.090909
  40717,   25.8774662,   55.0396347,     9.090909
  40718,   25.7026443,   55.8664627,     9.090909
  40719,   25.5014095,   56.6872559,     9.090909
  40720,   25.2739716,   57.5011826,     9.090909
  40721,   25.0205612,   58.3073997,     9.090909
  40722,   24.7414398,   59.1050797,     9.090909
  40723,   24.4368973,   59.8934021,     9.090909
  40724,   24.1072426,   60.6715622,     9.090909
  40725,   23.7528152,   61.4387512,     9.090909
  40726,   23.3739815,    62.194191,     9.090909
  40727,   22.9711304,   62.9370995,     9.090909
  40728,   22.5446701,   63.6667137,     9.090909
  40729,   22.0950489,   64.3822861,     9.090909
  40730,   21.6227245,   65.0830765,     9.090909
  40731,   21.1281796,   65.7683716,     9.090909
  40732,   20.6119194,   66.4374619,     9.090909
  40733,   20.0744839,   67.0896606,     9.090909
  40734,   19.5164185,   67.7242966,     9.090909
  40735,   18.9383011,   68.3407211,     9.090909
  40736,   18.3407192,   68.9383011,     9.090909
  40737,   17.7242966,   69.5164185,     9.090909
  40738,   17.0896568,   70.0744858,     9.090909
  40739,   16.4374599,   70.6119232,     9.090909
  40740,   15.7683668,   71.1281738,     9.090909
  40741,   15.0830746,   71.6227264,     9.090909
  40742,   14.3822823,    72.095047,     9.090909
  40743,   13.6667137,   72.5446701,     9.090909
  40744,   12.9370985,   72.9711304,     9.090909
  40745,   12.1941919,   73.3739853,     9.090909
  40746,   11.4387522,   73.7528152,     9.090909
  40747,   10.6715603,   74.1072388,     9.090909
  40748,   9.89340305,   74.4368973,     9.090909
  40749,    9.1050787,   74.7414398,     9.090909
  40750,    8.3073988,   75.0205612,     9.090909
  40751,   7.50118256,   75.2739716,     9.090909
  40752,   6.68725777,   75.5014114,     9.090909
  40753,   5.86646032,   75.7026443,     9.090909
  40754,   5.03963661,   75.8774719,     9.090909
  40755,   4.20763302,   76.0257034,     9.090909
  40756,    3.3713069,   76.1471939,     9.090909
  40757,   2.53151608,   76.2418137,     9.090909
  40758,   1.68912399,   76.3094711,     9.090909
  40759,  0.844996154,     76.35009,     9.090909
  40760,           0.,   76.3636398,     9.090909
  40761, -0.844996154,     76.35009,     9.090909
  40762,  -1.68912399,   76.3094711,     9.090909
  40763,  -2.53151608,   76.2418137,     9.090909
  40764,   -3.3713069,   76.1471939,     9.090909
  40765,  -4.20763302,   76.0257034,     9.090909
  40766,  -5.03963661,   75.8774719,     9.090909
  40767,  -5.86646032,   75.7026443,     9.090909
  40768,  -6.68725777,   75.5014114,     9.090909
  40769,  -7.50118256,   75.2739716,     9.090909
  40770,   -8.3073988,   75.0205612,     9.090909
  40771,   -9.1050787,   74.7414398,     9.090909
  40772,  -9.89340305,   74.4368973,     9.090909
  40773,  -10.6715603,   74.1072388,     9.090909
  40774,  -11.4387522,   73.7528152,     9.090909
  40775,  -12.1941919,   73.3739853,     9.090909
  40776,  -12.9370985,   72.9711304,     9.090909
  40777,  -13.6667137,   72.5446701,     9.090909
  40778,  -14.3822823,    72.095047,     9.090909
  40779,  -15.0830746,   71.6227264,     9.090909
  40780,  -15.7683668,   71.1281738,     9.090909
  40781,  -16.4374599,   70.6119232,     9.090909
  40782,  -17.0896568,   70.0744858,     9.090909
  40783,  -17.7242966,   69.5164185,     9.090909
  40784,  -18.3407192,   68.9383011,     9.090909
  40785,  -18.9383011,   68.3407211,     9.090909
  40786,  -19.5164185,   67.7242966,     9.090909
  40787,  -20.0744839,   67.0896606,     9.090909
  40788,  -20.6119194,   66.4374619,     9.090909
  40789,  -21.1281796,   65.7683716,     9.090909
  40790,  -21.6227245,   65.0830765,     9.090909
  40791,  -22.0950489,   64.3822861,     9.090909
  40792,  -22.5446701,   63.6667137,     9.090909
  40793,  -22.9711304,   62.9370995,     9.090909
  40794,  -23.3739815,    62.194191,     9.090909
  40795,  -23.7528152,   61.4387512,     9.090909
  40796,  -24.1072426,   60.6715622,     9.090909
  40797,  -24.4368973,   59.8934021,     9.090909
  40798,  -24.7414398,   59.1050797,     9.090909
  40799,  -25.0205612,   58.3073997,     9.090909
  40800,  -25.2739716,   57.5011826,     9.090909
  40801,  -25.5014095,   56.6872559,     9.090909
  40802,  -25.7026443,   55.8664627,     9.090909
  40803,  -25.8774662,   55.0396347,     9.090909
  40804,  -26.0257015,    54.207634,     9.090909
  40805,   -26.147192,   53.3713074,     9.090909
  40806,  -26.2418137,    52.531517,     9.090909
  40807,  -26.3094692,   51.6891251,     9.090909
  40808,  -26.3500919,   50.8449974,     9.090909
  40809,   25.4414673,   50.8158569,  0.909090936
  40810,   25.4022465,   51.6308784,  0.909090936
  40811,   25.3369236,   52.4442215,  0.909090936
  40812,   25.2455635,   53.2550545,  0.909090936
  40813,   25.1282635,    54.062542,  0.909090936
  40814,   24.9851398,   54.8658562,  0.909090936
  40815,   24.8163471,   55.6641693,  0.909090936
  40816,   24.6220512,   56.4566612,  0.909090936
  40817,   24.4024544,   57.2425194,  0.909090936
  40818,   24.1577835,   58.0209351,  0.909090936
  40819,   23.8882866,    58.791111,  0.909090936
  40820,    23.594244,   59.5522499,  0.909090936
  40821,   23.2759571,   60.3035774,  0.909090936
  40822,   22.9337521,   61.0443115,  0.909090936
  40823,   22.5679817,   61.7737007,  0.909090936
  40824,   22.1790218,   62.4909935,  0.909090936
  40825,   21.7672691,    63.195446,  0.909090936
  40826,    21.333149,   63.8863411,  0.909090936
  40827,   20.8771133,    64.562973,  0.909090936
  40828,    20.399622,   65.2246323,  0.909090936
  40829,   19.9011631,   65.8706512,  0.909090936
  40830,   19.3822613,   66.5003586,  0.909090936
  40831,   18.8434372,   67.1131134,  0.909090936
  40832,   18.2852554,   67.7082825,  0.909090936
  40833,   17.7082806,   68.2852554,  0.909090936
  40834,   17.1131134,   68.8434372,  0.909090936
  40835,   16.5003586,   69.3822632,  0.909090936
  40836,   15.8706512,   69.9011612,  0.909090936
  40837,   15.2246294,   70.3996201,  0.909090936
  40838,   14.5629683,   70.8771133,  0.909090936
  40839,   13.8863411,   71.3331528,  0.909090936
  40840,   13.1954479,   71.7672729,  0.909090936
  40841,   12.4909916,   72.1790237,  0.909090936
  40842,   11.7737026,   72.5679855,  0.909090936
  40843,   11.0443125,    72.933754,  0.909090936
  40844,   10.3035755,   73.2759552,  0.909090936
  40845,   9.55225086,   73.5942459,  0.909090936
  40846,   8.79111004,   73.8882904,  0.909090936
  40847,   8.02093601,   74.1577835,  0.909090936
  40848,   7.24252129,   74.4024582,  0.909090936
  40849,   6.45666265,   74.6220474,  0.909090936
  40850,   5.66416883,   74.8163452,  0.909090936
  40851,   4.86585617,   74.9851456,  0.909090936
  40852,   4.06254244,   75.1282654,  0.909090936
  40853,   3.25505495,   75.2455673,  0.909090936
  40854,   2.44422245,   75.3369217,  0.909090936
  40855,   1.63087833,   75.4022446,  0.909090936
  40856,  0.815858364,   75.4414673,  0.909090936
  40857,           0.,   75.4545441,  0.909090936
  40858, -0.815858364,   75.4414673,  0.909090936
  40859,  -1.63087833,   75.4022446,  0.909090936
  40860,  -2.44422245,   75.3369217,  0.909090936
  40861,  -3.25505495,   75.2455673,  0.909090936
  40862,  -4.06254244,   75.1282654,  0.909090936
  40863,  -4.86585617,   74.9851456,  0.909090936
  40864,  -5.66416883,   74.8163452,  0.909090936
  40865,  -6.45666265,   74.6220474,  0.909090936
  40866,  -7.24252129,   74.4024582,  0.909090936
  40867,  -8.02093601,   74.1577835,  0.909090936
  40868,  -8.79111004,   73.8882904,  0.909090936
  40869,  -9.55225086,   73.5942459,  0.909090936
  40870,  -10.3035755,   73.2759552,  0.909090936
  40871,  -11.0443125,    72.933754,  0.909090936
  40872,  -11.7737026,   72.5679855,  0.909090936
  40873,  -12.4909916,   72.1790237,  0.909090936
  40874,  -13.1954479,   71.7672729,  0.909090936
  40875,  -13.8863411,   71.3331528,  0.909090936
  40876,  -14.5629683,   70.8771133,  0.909090936
  40877,  -15.2246294,   70.3996201,  0.909090936
  40878,  -15.8706512,   69.9011612,  0.909090936
  40879,  -16.5003586,   69.3822632,  0.909090936
  40880,  -17.1131134,   68.8434372,  0.909090936
  40881,  -17.7082806,   68.2852554,  0.909090936
  40882,  -18.2852554,   67.7082825,  0.909090936
  40883,  -18.8434372,   67.1131134,  0.909090936
  40884,  -19.3822613,   66.5003586,  0.909090936
  40885,  -19.9011631,   65.8706512,  0.909090936
  40886,   -20.399622,   65.2246323,  0.909090936
  40887,  -20.8771133,    64.562973,  0.909090936
  40888,   -21.333149,   63.8863411,  0.909090936
  40889,  -21.7672691,    63.195446,  0.909090936
  40890,  -22.1790218,   62.4909935,  0.909090936
  40891,  -22.5679817,   61.7737007,  0.909090936
  40892,  -22.9337521,   61.0443115,  0.909090936
  40893,  -23.2759571,   60.3035774,  0.909090936
  40894,   -23.594244,   59.5522499,  0.909090936
  40895,  -23.8882866,    58.791111,  0.909090936
  40896,  -24.1577835,   58.0209351,  0.909090936
  40897,  -24.4024544,   57.2425194,  0.909090936
  40898,  -24.6220512,   56.4566612,  0.909090936
  40899,  -24.8163471,   55.6641693,  0.909090936
  40900,  -24.9851398,   54.8658562,  0.909090936
  40901,  -25.1282635,    54.062542,  0.909090936
  40902,  -25.2455635,   53.2550545,  0.909090936
  40903,  -25.3369236,   52.4442215,  0.909090936
  40904,  -25.4022465,   51.6308784,  0.909090936
  40905,  -25.4414673,   50.8158569,  0.909090936
  40906,   25.4414673,   50.8158569,   1.81818187
  40907,   25.4022465,   51.6308784,   1.81818187
  40908,   25.3369236,   52.4442215,   1.81818187
  40909,   25.2455635,   53.2550545,   1.81818187
  40910,   25.1282635,    54.062542,   1.81818187
  40911,   24.9851398,   54.8658562,   1.81818187
  40912,   24.8163471,   55.6641693,   1.81818187
  40913,   24.6220512,   56.4566612,   1.81818187
  40914,   24.4024544,   57.2425194,   1.81818187
  40915,   24.1577835,   58.0209351,   1.81818187
  40916,   23.8882866,    58.791111,   1.81818187
  40917,    23.594244,   59.5522499,   1.81818187
  40918,   23.2759571,   60.3035774,   1.81818187
  40919,   22.9337521,   61.0443115,   1.81818187
  40920,   22.5679817,   61.7737007,   1.81818187
  40921,   22.1790218,   62.4909935,   1.81818187
  40922,   21.7672691,    63.195446,   1.81818187
  40923,    21.333149,   63.8863411,   1.81818187
  40924,   20.8771133,    64.562973,   1.81818187
  40925,    20.399622,   65.2246323,   1.81818187
  40926,   19.9011631,   65.8706512,   1.81818187
  40927,   19.3822613,   66.5003586,   1.81818187
  40928,   18.8434372,   67.1131134,   1.81818187
  40929,   18.2852554,   67.7082825,   1.81818187
  40930,   17.7082806,   68.2852554,   1.81818187
  40931,   17.1131134,   68.8434372,   1.81818187
  40932,   16.5003586,   69.3822632,   1.81818187
  40933,   15.8706512,   69.9011612,   1.81818187
  40934,   15.2246294,   70.3996201,   1.81818187
  40935,   14.5629683,   70.8771133,   1.81818187
  40936,   13.8863411,   71.3331528,   1.81818187
  40937,   13.1954479,   71.7672729,   1.81818187
  40938,   12.4909916,   72.1790237,   1.81818187
  40939,   11.7737026,   72.5679855,   1.81818187
  40940,   11.0443125,    72.933754,   1.81818187
  40941,   10.3035755,   73.2759552,   1.81818187
  40942,   9.55225086,   73.5942459,   1.81818187
  40943,   8.79111004,   73.8882904,   1.81818187
  40944,   8.02093601,   74.1577835,   1.81818187
  40945,   7.24252129,   74.4024582,   1.81818187
  40946,   6.45666265,   74.6220474,   1.81818187
  40947,   5.66416883,   74.8163452,   1.81818187
  40948,   4.86585617,   74.9851456,   1.81818187
  40949,   4.06254244,   75.1282654,   1.81818187
  40950,   3.25505495,   75.2455673,   1.81818187
  40951,   2.44422245,   75.3369217,   1.81818187
  40952,   1.63087833,   75.4022446,   1.81818187
  40953,  0.815858364,   75.4414673,   1.81818187
  40954,           0.,   75.4545441,   1.81818187
  40955, -0.815858364,   75.4414673,   1.81818187
  40956,  -1.63087833,   75.4022446,   1.81818187
  40957,  -2.44422245,   75.3369217,   1.81818187
  40958,  -3.25505495,   75.2455673,   1.81818187
  40959,  -4.06254244,   75.1282654,   1.81818187
  40960,  -4.86585617,   74.9851456,   1.81818187
  40961,  -5.66416883,   74.8163452,   1.81818187
  40962,  -6.45666265,   74.6220474,   1.81818187
  40963,  -7.24252129,   74.4024582,   1.81818187
  40964,  -8.02093601,   74.1577835,   1.81818187
  40965,  -8.79111004,   73.8882904,   1.81818187
  40966,  -9.55225086,   73.5942459,   1.81818187
  40967,  -10.3035755,   73.2759552,   1.81818187
  40968,  -11.0443125,    72.933754,   1.81818187
  40969,  -11.7737026,   72.5679855,   1.81818187
  40970,  -12.4909916,   72.1790237,   1.81818187
  40971,  -13.1954479,   71.7672729,   1.81818187
  40972,  -13.8863411,   71.3331528,   1.81818187
  40973,  -14.5629683,   70.8771133,   1.81818187
  40974,  -15.2246294,   70.3996201,   1.81818187
  40975,  -15.8706512,   69.9011612,   1.81818187
  40976,  -16.5003586,   69.3822632,   1.81818187
  40977,  -17.1131134,   68.8434372,   1.81818187
  40978,  -17.7082806,   68.2852554,   1.81818187
  40979,  -18.2852554,   67.7082825,   1.81818187
  40980,  -18.8434372,   67.1131134,   1.81818187
  40981,  -19.3822613,   66.5003586,   1.81818187
  40982,  -19.9011631,   65.8706512,   1.81818187
  40983,   -20.399622,   65.2246323,   1.81818187
  40984,  -20.8771133,    64.562973,   1.81818187
  40985,   -21.333149,   63.8863411,   1.81818187
  40986,  -21.7672691,    63.195446,   1.81818187
  40987,  -22.1790218,   62.4909935,   1.81818187
  40988,  -22.5679817,   61.7737007,   1.81818187
  40989,  -22.9337521,   61.0443115,   1.81818187
  40990,  -23.2759571,   60.3035774,   1.81818187
  40991,   -23.594244,   59.5522499,   1.81818187
  40992,  -23.8882866,    58.791111,   1.81818187
  40993,  -24.1577835,   58.0209351,   1.81818187
  40994,  -24.4024544,   57.2425194,   1.81818187
  40995,  -24.6220512,   56.4566612,   1.81818187
  40996,  -24.8163471,   55.6641693,   1.81818187
  40997,  -24.9851398,   54.8658562,   1.81818187
  40998,  -25.1282635,    54.062542,   1.81818187
  40999,  -25.2455635,   53.2550545,   1.81818187
  41000,  -25.3369236,   52.4442215,   1.81818187
  41001,  -25.4022465,   51.6308784,   1.81818187
  41002,  -25.4414673,   50.8158569,   1.81818187
  41003,   25.4414673,   50.8158569,   2.72727275
  41004,   25.4022465,   51.6308784,   2.72727275
  41005,   25.3369236,   52.4442215,   2.72727275
  41006,   25.2455635,   53.2550545,   2.72727275
  41007,   25.1282635,    54.062542,   2.72727275
  41008,   24.9851398,   54.8658562,   2.72727275
  41009,   24.8163471,   55.6641693,   2.72727275
  41010,   24.6220512,   56.4566612,   2.72727275
  41011,   24.4024544,   57.2425194,   2.72727275
  41012,   24.1577835,   58.0209351,   2.72727275
  41013,   23.8882866,    58.791111,   2.72727275
  41014,    23.594244,   59.5522499,   2.72727275
  41015,   23.2759571,   60.3035774,   2.72727275
  41016,   22.9337521,   61.0443115,   2.72727275
  41017,   22.5679817,   61.7737007,   2.72727275
  41018,   22.1790218,   62.4909935,   2.72727275
  41019,   21.7672691,    63.195446,   2.72727275
  41020,    21.333149,   63.8863411,   2.72727275
  41021,   20.8771133,    64.562973,   2.72727275
  41022,    20.399622,   65.2246323,   2.72727275
  41023,   19.9011631,   65.8706512,   2.72727275
  41024,   19.3822613,   66.5003586,   2.72727275
  41025,   18.8434372,   67.1131134,   2.72727275
  41026,   18.2852554,   67.7082825,   2.72727275
  41027,   17.7082806,   68.2852554,   2.72727275
  41028,   17.1131134,   68.8434372,   2.72727275
  41029,   16.5003586,   69.3822632,   2.72727275
  41030,   15.8706512,   69.9011612,   2.72727275
  41031,   15.2246294,   70.3996201,   2.72727275
  41032,   14.5629683,   70.8771133,   2.72727275
  41033,   13.8863411,   71.3331528,   2.72727275
  41034,   13.1954479,   71.7672729,   2.72727275
  41035,   12.4909916,   72.1790237,   2.72727275
  41036,   11.7737026,   72.5679855,   2.72727275
  41037,   11.0443125,    72.933754,   2.72727275
  41038,   10.3035755,   73.2759552,   2.72727275
  41039,   9.55225086,   73.5942459,   2.72727275
  41040,   8.79111004,   73.8882904,   2.72727275
  41041,   8.02093601,   74.1577835,   2.72727275
  41042,   7.24252129,   74.4024582,   2.72727275
  41043,   6.45666265,   74.6220474,   2.72727275
  41044,   5.66416883,   74.8163452,   2.72727275
  41045,   4.86585617,   74.9851456,   2.72727275
  41046,   4.06254244,   75.1282654,   2.72727275
  41047,   3.25505495,   75.2455673,   2.72727275
  41048,   2.44422245,   75.3369217,   2.72727275
  41049,   1.63087833,   75.4022446,   2.72727275
  41050,  0.815858364,   75.4414673,   2.72727275
  41051,           0.,   75.4545441,   2.72727275
  41052, -0.815858364,   75.4414673,   2.72727275
  41053,  -1.63087833,   75.4022446,   2.72727275
  41054,  -2.44422245,   75.3369217,   2.72727275
  41055,  -3.25505495,   75.2455673,   2.72727275
  41056,  -4.06254244,   75.1282654,   2.72727275
  41057,  -4.86585617,   74.9851456,   2.72727275
  41058,  -5.66416883,   74.8163452,   2.72727275
  41059,  -6.45666265,   74.6220474,   2.72727275
  41060,  -7.24252129,   74.4024582,   2.72727275
  41061,  -8.02093601,   74.1577835,   2.72727275
  41062,  -8.79111004,   73.8882904,   2.72727275
  41063,  -9.55225086,   73.5942459,   2.72727275
  41064,  -10.3035755,   73.2759552,   2.72727275
  41065,  -11.0443125,    72.933754,   2.72727275
  41066,  -11.7737026,   72.5679855,   2.72727275
  41067,  -12.4909916,   72.1790237,   2.72727275
  41068,  -13.1954479,   71.7672729,   2.72727275
  41069,  -13.8863411,   71.3331528,   2.72727275
  41070,  -14.5629683,   70.8771133,   2.72727275
  41071,  -15.2246294,   70.3996201,   2.72727275
  41072,  -15.8706512,   69.9011612,   2.72727275
  41073,  -16.5003586,   69.3822632,   2.72727275
  41074,  -17.1131134,   68.8434372,   2.72727275
  41075,  -17.7082806,   68.2852554,   2.72727275
  41076,  -18.2852554,   67.7082825,   2.72727275
  41077,  -18.8434372,   67.1131134,   2.72727275
  41078,  -19.3822613,   66.5003586,   2.72727275
  41079,  -19.9011631,   65.8706512,   2.72727275
  41080,   -20.399622,   65.2246323,   2.72727275
  41081,  -20.8771133,    64.562973,   2.72727275
  41082,   -21.333149,   63.8863411,   2.72727275
  41083,  -21.7672691,    63.195446,   2.72727275
  41084,  -22.1790218,   62.4909935,   2.72727275
  41085,  -22.5679817,   61.7737007,   2.72727275
  41086,  -22.9337521,   61.0443115,   2.72727275
  41087,  -23.2759571,   60.3035774,   2.72727275
  41088,   -23.594244,   59.5522499,   2.72727275
  41089,  -23.8882866,    58.791111,   2.72727275
  41090,  -24.1577835,   58.0209351,   2.72727275
  41091,  -24.4024544,   57.2425194,   2.72727275
  41092,  -24.6220512,   56.4566612,   2.72727275
  41093,  -24.8163471,   55.6641693,   2.72727275
  41094,  -24.9851398,   54.8658562,   2.72727275
  41095,  -25.1282635,    54.062542,   2.72727275
  41096,  -25.2455635,   53.2550545,   2.72727275
  41097,  -25.3369236,   52.4442215,   2.72727275
  41098,  -25.4022465,   51.6308784,   2.72727275
  41099,  -25.4414673,   50.8158569,   2.72727275
  41100,   25.4414673,   50.8158569,   3.63636374
  41101,   25.4022465,   51.6308784,   3.63636374
  41102,   25.3369236,   52.4442215,   3.63636374
  41103,   25.2455635,   53.2550545,   3.63636374
  41104,   25.1282635,    54.062542,   3.63636374
  41105,   24.9851398,   54.8658562,   3.63636374
  41106,   24.8163471,   55.6641693,   3.63636374
  41107,   24.6220512,   56.4566612,   3.63636374
  41108,   24.4024544,   57.2425194,   3.63636374
  41109,   24.1577835,   58.0209351,   3.63636374
  41110,   23.8882866,    58.791111,   3.63636374
  41111,    23.594244,   59.5522499,   3.63636374
  41112,   23.2759571,   60.3035774,   3.63636374
  41113,   22.9337521,   61.0443115,   3.63636374
  41114,   22.5679817,   61.7737007,   3.63636374
  41115,   22.1790218,   62.4909935,   3.63636374
  41116,   21.7672691,    63.195446,   3.63636374
  41117,    21.333149,   63.8863411,   3.63636374
  41118,   20.8771133,    64.562973,   3.63636374
  41119,    20.399622,   65.2246323,   3.63636374
  41120,   19.9011631,   65.8706512,   3.63636374
  41121,   19.3822613,   66.5003586,   3.63636374
  41122,   18.8434372,   67.1131134,   3.63636374
  41123,   18.2852554,   67.7082825,   3.63636374
  41124,   17.7082806,   68.2852554,   3.63636374
  41125,   17.1131134,   68.8434372,   3.63636374
  41126,   16.5003586,   69.3822632,   3.63636374
  41127,   15.8706512,   69.9011612,   3.63636374
  41128,   15.2246294,   70.3996201,   3.63636374
  41129,   14.5629683,   70.8771133,   3.63636374
  41130,   13.8863411,   71.3331528,   3.63636374
  41131,   13.1954479,   71.7672729,   3.63636374
  41132,   12.4909916,   72.1790237,   3.63636374
  41133,   11.7737026,   72.5679855,   3.63636374
  41134,   11.0443125,    72.933754,   3.63636374
  41135,   10.3035755,   73.2759552,   3.63636374
  41136,   9.55225086,   73.5942459,   3.63636374
  41137,   8.79111004,   73.8882904,   3.63636374
  41138,   8.02093601,   74.1577835,   3.63636374
  41139,   7.24252129,   74.4024582,   3.63636374
  41140,   6.45666265,   74.6220474,   3.63636374
  41141,   5.66416883,   74.8163452,   3.63636374
  41142,   4.86585617,   74.9851456,   3.63636374
  41143,   4.06254244,   75.1282654,   3.63636374
  41144,   3.25505495,   75.2455673,   3.63636374
  41145,   2.44422245,   75.3369217,   3.63636374
  41146,   1.63087833,   75.4022446,   3.63636374
  41147,  0.815858364,   75.4414673,   3.63636374
  41148,           0.,   75.4545441,   3.63636374
  41149, -0.815858364,   75.4414673,   3.63636374
  41150,  -1.63087833,   75.4022446,   3.63636374
  41151,  -2.44422245,   75.3369217,   3.63636374
  41152,  -3.25505495,   75.2455673,   3.63636374
  41153,  -4.06254244,   75.1282654,   3.63636374
  41154,  -4.86585617,   74.9851456,   3.63636374
  41155,  -5.66416883,   74.8163452,   3.63636374
  41156,  -6.45666265,   74.6220474,   3.63636374
  41157,  -7.24252129,   74.4024582,   3.63636374
  41158,  -8.02093601,   74.1577835,   3.63636374
  41159,  -8.79111004,   73.8882904,   3.63636374
  41160,  -9.55225086,   73.5942459,   3.63636374
  41161,  -10.3035755,   73.2759552,   3.63636374
  41162,  -11.0443125,    72.933754,   3.63636374
  41163,  -11.7737026,   72.5679855,   3.63636374
  41164,  -12.4909916,   72.1790237,   3.63636374
  41165,  -13.1954479,   71.7672729,   3.63636374
  41166,  -13.8863411,   71.3331528,   3.63636374
  41167,  -14.5629683,   70.8771133,   3.63636374
  41168,  -15.2246294,   70.3996201,   3.63636374
  41169,  -15.8706512,   69.9011612,   3.63636374
  41170,  -16.5003586,   69.3822632,   3.63636374
  41171,  -17.1131134,   68.8434372,   3.63636374
  41172,  -17.7082806,   68.2852554,   3.63636374
  41173,  -18.2852554,   67.7082825,   3.63636374
  41174,  -18.8434372,   67.1131134,   3.63636374
  41175,  -19.3822613,   66.5003586,   3.63636374
  41176,  -19.9011631,   65.8706512,   3.63636374
  41177,   -20.399622,   65.2246323,   3.63636374
  41178,  -20.8771133,    64.562973,   3.63636374
  41179,   -21.333149,   63.8863411,   3.63636374
  41180,  -21.7672691,    63.195446,   3.63636374
  41181,  -22.1790218,   62.4909935,   3.63636374
  41182,  -22.5679817,   61.7737007,   3.63636374
  41183,  -22.9337521,   61.0443115,   3.63636374
  41184,  -23.2759571,   60.3035774,   3.63636374
  41185,   -23.594244,   59.5522499,   3.63636374
  41186,  -23.8882866,    58.791111,   3.63636374
  41187,  -24.1577835,   58.0209351,   3.63636374
  41188,  -24.4024544,   57.2425194,   3.63636374
  41189,  -24.6220512,   56.4566612,   3.63636374
  41190,  -24.8163471,   55.6641693,   3.63636374
  41191,  -24.9851398,   54.8658562,   3.63636374
  41192,  -25.1282635,    54.062542,   3.63636374
  41193,  -25.2455635,   53.2550545,   3.63636374
  41194,  -25.3369236,   52.4442215,   3.63636374
  41195,  -25.4022465,   51.6308784,   3.63636374
  41196,  -25.4414673,   50.8158569,   3.63636374
  41197,   25.4414673,   50.8158569,    4.5454545
  41198,   25.4022465,   51.6308784,    4.5454545
  41199,   25.3369236,   52.4442215,    4.5454545
  41200,   25.2455635,   53.2550545,    4.5454545
  41201,   25.1282635,    54.062542,    4.5454545
  41202,   24.9851398,   54.8658562,    4.5454545
  41203,   24.8163471,   55.6641693,    4.5454545
  41204,   24.6220512,   56.4566612,    4.5454545
  41205,   24.4024544,   57.2425194,    4.5454545
  41206,   24.1577835,   58.0209351,    4.5454545
  41207,   23.8882866,    58.791111,    4.5454545
  41208,    23.594244,   59.5522499,    4.5454545
  41209,   23.2759571,   60.3035774,    4.5454545
  41210,   22.9337521,   61.0443115,    4.5454545
  41211,   22.5679817,   61.7737007,    4.5454545
  41212,   22.1790218,   62.4909935,    4.5454545
  41213,   21.7672691,    63.195446,    4.5454545
  41214,    21.333149,   63.8863411,    4.5454545
  41215,   20.8771133,    64.562973,    4.5454545
  41216,    20.399622,   65.2246323,    4.5454545
  41217,   19.9011631,   65.8706512,    4.5454545
  41218,   19.3822613,   66.5003586,    4.5454545
  41219,   18.8434372,   67.1131134,    4.5454545
  41220,   18.2852554,   67.7082825,    4.5454545
  41221,   17.7082806,   68.2852554,    4.5454545
  41222,   17.1131134,   68.8434372,    4.5454545
  41223,   16.5003586,   69.3822632,    4.5454545
  41224,   15.8706512,   69.9011612,    4.5454545
  41225,   15.2246294,   70.3996201,    4.5454545
  41226,   14.5629683,   70.8771133,    4.5454545
  41227,   13.8863411,   71.3331528,    4.5454545
  41228,   13.1954479,   71.7672729,    4.5454545
  41229,   12.4909916,   72.1790237,    4.5454545
  41230,   11.7737026,   72.5679855,    4.5454545
  41231,   11.0443125,    72.933754,    4.5454545
  41232,   10.3035755,   73.2759552,    4.5454545
  41233,   9.55225086,   73.5942459,    4.5454545
  41234,   8.79111004,   73.8882904,    4.5454545
  41235,   8.02093601,   74.1577835,    4.5454545
  41236,   7.24252129,   74.4024582,    4.5454545
  41237,   6.45666265,   74.6220474,    4.5454545
  41238,   5.66416883,   74.8163452,    4.5454545
  41239,   4.86585617,   74.9851456,    4.5454545
  41240,   4.06254244,   75.1282654,    4.5454545
  41241,   3.25505495,   75.2455673,    4.5454545
  41242,   2.44422245,   75.3369217,    4.5454545
  41243,   1.63087833,   75.4022446,    4.5454545
  41244,  0.815858364,   75.4414673,    4.5454545
  41245,           0.,   75.4545441,    4.5454545
  41246, -0.815858364,   75.4414673,    4.5454545
  41247,  -1.63087833,   75.4022446,    4.5454545
  41248,  -2.44422245,   75.3369217,    4.5454545
  41249,  -3.25505495,   75.2455673,    4.5454545
  41250,  -4.06254244,   75.1282654,    4.5454545
  41251,  -4.86585617,   74.9851456,    4.5454545
  41252,  -5.66416883,   74.8163452,    4.5454545
  41253,  -6.45666265,   74.6220474,    4.5454545
  41254,  -7.24252129,   74.4024582,    4.5454545
  41255,  -8.02093601,   74.1577835,    4.5454545
  41256,  -8.79111004,   73.8882904,    4.5454545
  41257,  -9.55225086,   73.5942459,    4.5454545
  41258,  -10.3035755,   73.2759552,    4.5454545
  41259,  -11.0443125,    72.933754,    4.5454545
  41260,  -11.7737026,   72.5679855,    4.5454545
  41261,  -12.4909916,   72.1790237,    4.5454545
  41262,  -13.1954479,   71.7672729,    4.5454545
  41263,  -13.8863411,   71.3331528,    4.5454545
  41264,  -14.5629683,   70.8771133,    4.5454545
  41265,  -15.2246294,   70.3996201,    4.5454545
  41266,  -15.8706512,   69.9011612,    4.5454545
  41267,  -16.5003586,   69.3822632,    4.5454545
  41268,  -17.1131134,   68.8434372,    4.5454545
  41269,  -17.7082806,   68.2852554,    4.5454545
  41270,  -18.2852554,   67.7082825,    4.5454545
  41271,  -18.8434372,   67.1131134,    4.5454545
  41272,  -19.3822613,   66.5003586,    4.5454545
  41273,  -19.9011631,   65.8706512,    4.5454545
  41274,   -20.399622,   65.2246323,    4.5454545
  41275,  -20.8771133,    64.562973,    4.5454545
  41276,   -21.333149,   63.8863411,    4.5454545
  41277,  -21.7672691,    63.195446,    4.5454545
  41278,  -22.1790218,   62.4909935,    4.5454545
  41279,  -22.5679817,   61.7737007,    4.5454545
  41280,  -22.9337521,   61.0443115,    4.5454545
  41281,  -23.2759571,   60.3035774,    4.5454545
  41282,   -23.594244,   59.5522499,    4.5454545
  41283,  -23.8882866,    58.791111,    4.5454545
  41284,  -24.1577835,   58.0209351,    4.5454545
  41285,  -24.4024544,   57.2425194,    4.5454545
  41286,  -24.6220512,   56.4566612,    4.5454545
  41287,  -24.8163471,   55.6641693,    4.5454545
  41288,  -24.9851398,   54.8658562,    4.5454545
  41289,  -25.1282635,    54.062542,    4.5454545
  41290,  -25.2455635,   53.2550545,    4.5454545
  41291,  -25.3369236,   52.4442215,    4.5454545
  41292,  -25.4022465,   51.6308784,    4.5454545
  41293,  -25.4414673,   50.8158569,    4.5454545
  41294,   25.4414673,   50.8158569,    5.4545455
  41295,   25.4022465,   51.6308784,    5.4545455
  41296,   25.3369236,   52.4442215,    5.4545455
  41297,   25.2455635,   53.2550545,    5.4545455
  41298,   25.1282635,    54.062542,    5.4545455
  41299,   24.9851398,   54.8658562,    5.4545455
  41300,   24.8163471,   55.6641693,    5.4545455
  41301,   24.6220512,   56.4566612,    5.4545455
  41302,   24.4024544,   57.2425194,    5.4545455
  41303,   24.1577835,   58.0209351,    5.4545455
  41304,   23.8882866,    58.791111,    5.4545455
  41305,    23.594244,   59.5522499,    5.4545455
  41306,   23.2759571,   60.3035774,    5.4545455
  41307,   22.9337521,   61.0443115,    5.4545455
  41308,   22.5679817,   61.7737007,    5.4545455
  41309,   22.1790218,   62.4909935,    5.4545455
  41310,   21.7672691,    63.195446,    5.4545455
  41311,    21.333149,   63.8863411,    5.4545455
  41312,   20.8771133,    64.562973,    5.4545455
  41313,    20.399622,   65.2246323,    5.4545455
  41314,   19.9011631,   65.8706512,    5.4545455
  41315,   19.3822613,   66.5003586,    5.4545455
  41316,   18.8434372,   67.1131134,    5.4545455
  41317,   18.2852554,   67.7082825,    5.4545455
  41318,   17.7082806,   68.2852554,    5.4545455
  41319,   17.1131134,   68.8434372,    5.4545455
  41320,   16.5003586,   69.3822632,    5.4545455
  41321,   15.8706512,   69.9011612,    5.4545455
  41322,   15.2246294,   70.3996201,    5.4545455
  41323,   14.5629683,   70.8771133,    5.4545455
  41324,   13.8863411,   71.3331528,    5.4545455
  41325,   13.1954479,   71.7672729,    5.4545455
  41326,   12.4909916,   72.1790237,    5.4545455
  41327,   11.7737026,   72.5679855,    5.4545455
  41328,   11.0443125,    72.933754,    5.4545455
  41329,   10.3035755,   73.2759552,    5.4545455
  41330,   9.55225086,   73.5942459,    5.4545455
  41331,   8.79111004,   73.8882904,    5.4545455
  41332,   8.02093601,   74.1577835,    5.4545455
  41333,   7.24252129,   74.4024582,    5.4545455
  41334,   6.45666265,   74.6220474,    5.4545455
  41335,   5.66416883,   74.8163452,    5.4545455
  41336,   4.86585617,   74.9851456,    5.4545455
  41337,   4.06254244,   75.1282654,    5.4545455
  41338,   3.25505495,   75.2455673,    5.4545455
  41339,   2.44422245,   75.3369217,    5.4545455
  41340,   1.63087833,   75.4022446,    5.4545455
  41341,  0.815858364,   75.4414673,    5.4545455
  41342,           0.,   75.4545441,    5.4545455
  41343, -0.815858364,   75.4414673,    5.4545455
  41344,  -1.63087833,   75.4022446,    5.4545455
  41345,  -2.44422245,   75.3369217,    5.4545455
  41346,  -3.25505495,   75.2455673,    5.4545455
  41347,  -4.06254244,   75.1282654,    5.4545455
  41348,  -4.86585617,   74.9851456,    5.4545455
  41349,  -5.66416883,   74.8163452,    5.4545455
  41350,  -6.45666265,   74.6220474,    5.4545455
  41351,  -7.24252129,   74.4024582,    5.4545455
  41352,  -8.02093601,   74.1577835,    5.4545455
  41353,  -8.79111004,   73.8882904,    5.4545455
  41354,  -9.55225086,   73.5942459,    5.4545455
  41355,  -10.3035755,   73.2759552,    5.4545455
  41356,  -11.0443125,    72.933754,    5.4545455
  41357,  -11.7737026,   72.5679855,    5.4545455
  41358,  -12.4909916,   72.1790237,    5.4545455
  41359,  -13.1954479,   71.7672729,    5.4545455
  41360,  -13.8863411,   71.3331528,    5.4545455
  41361,  -14.5629683,   70.8771133,    5.4545455
  41362,  -15.2246294,   70.3996201,    5.4545455
  41363,  -15.8706512,   69.9011612,    5.4545455
  41364,  -16.5003586,   69.3822632,    5.4545455
  41365,  -17.1131134,   68.8434372,    5.4545455
  41366,  -17.7082806,   68.2852554,    5.4545455
  41367,  -18.2852554,   67.7082825,    5.4545455
  41368,  -18.8434372,   67.1131134,    5.4545455
  41369,  -19.3822613,   66.5003586,    5.4545455
  41370,  -19.9011631,   65.8706512,    5.4545455
  41371,   -20.399622,   65.2246323,    5.4545455
  41372,  -20.8771133,    64.562973,    5.4545455
  41373,   -21.333149,   63.8863411,    5.4545455
  41374,  -21.7672691,    63.195446,    5.4545455
  41375,  -22.1790218,   62.4909935,    5.4545455
  41376,  -22.5679817,   61.7737007,    5.4545455
  41377,  -22.9337521,   61.0443115,    5.4545455
  41378,  -23.2759571,   60.3035774,    5.4545455
  41379,   -23.594244,   59.5522499,    5.4545455
  41380,  -23.8882866,    58.791111,    5.4545455
  41381,  -24.1577835,   58.0209351,    5.4545455
  41382,  -24.4024544,   57.2425194,    5.4545455
  41383,  -24.6220512,   56.4566612,    5.4545455
  41384,  -24.8163471,   55.6641693,    5.4545455
  41385,  -24.9851398,   54.8658562,    5.4545455
  41386,  -25.1282635,    54.062542,    5.4545455
  41387,  -25.2455635,   53.2550545,    5.4545455
  41388,  -25.3369236,   52.4442215,    5.4545455
  41389,  -25.4022465,   51.6308784,    5.4545455
  41390,  -25.4414673,   50.8158569,    5.4545455
  41391,   25.4414673,   50.8158569,   6.36363649
  41392,   25.4022465,   51.6308784,   6.36363649
  41393,   25.3369236,   52.4442215,   6.36363649
  41394,   25.2455635,   53.2550545,   6.36363649
  41395,   25.1282635,    54.062542,   6.36363649
  41396,   24.9851398,   54.8658562,   6.36363649
  41397,   24.8163471,   55.6641693,   6.36363649
  41398,   24.6220512,   56.4566612,   6.36363649
  41399,   24.4024544,   57.2425194,   6.36363649
  41400,   24.1577835,   58.0209351,   6.36363649
  41401,   23.8882866,    58.791111,   6.36363649
  41402,    23.594244,   59.5522499,   6.36363649
  41403,   23.2759571,   60.3035774,   6.36363649
  41404,   22.9337521,   61.0443115,   6.36363649
  41405,   22.5679817,   61.7737007,   6.36363649
  41406,   22.1790218,   62.4909935,   6.36363649
  41407,   21.7672691,    63.195446,   6.36363649
  41408,    21.333149,   63.8863411,   6.36363649
  41409,   20.8771133,    64.562973,   6.36363649
  41410,    20.399622,   65.2246323,   6.36363649
  41411,   19.9011631,   65.8706512,   6.36363649
  41412,   19.3822613,   66.5003586,   6.36363649
  41413,   18.8434372,   67.1131134,   6.36363649
  41414,   18.2852554,   67.7082825,   6.36363649
  41415,   17.7082806,   68.2852554,   6.36363649
  41416,   17.1131134,   68.8434372,   6.36363649
  41417,   16.5003586,   69.3822632,   6.36363649
  41418,   15.8706512,   69.9011612,   6.36363649
  41419,   15.2246294,   70.3996201,   6.36363649
  41420,   14.5629683,   70.8771133,   6.36363649
  41421,   13.8863411,   71.3331528,   6.36363649
  41422,   13.1954479,   71.7672729,   6.36363649
  41423,   12.4909916,   72.1790237,   6.36363649
  41424,   11.7737026,   72.5679855,   6.36363649
  41425,   11.0443125,    72.933754,   6.36363649
  41426,   10.3035755,   73.2759552,   6.36363649
  41427,   9.55225086,   73.5942459,   6.36363649
  41428,   8.79111004,   73.8882904,   6.36363649
  41429,   8.02093601,   74.1577835,   6.36363649
  41430,   7.24252129,   74.4024582,   6.36363649
  41431,   6.45666265,   74.6220474,   6.36363649
  41432,   5.66416883,   74.8163452,   6.36363649
  41433,   4.86585617,   74.9851456,   6.36363649
  41434,   4.06254244,   75.1282654,   6.36363649
  41435,   3.25505495,   75.2455673,   6.36363649
  41436,   2.44422245,   75.3369217,   6.36363649
  41437,   1.63087833,   75.4022446,   6.36363649
  41438,  0.815858364,   75.4414673,   6.36363649
  41439,           0.,   75.4545441,   6.36363649
  41440, -0.815858364,   75.4414673,   6.36363649
  41441,  -1.63087833,   75.4022446,   6.36363649
  41442,  -2.44422245,   75.3369217,   6.36363649
  41443,  -3.25505495,   75.2455673,   6.36363649
  41444,  -4.06254244,   75.1282654,   6.36363649
  41445,  -4.86585617,   74.9851456,   6.36363649
  41446,  -5.66416883,   74.8163452,   6.36363649
  41447,  -6.45666265,   74.6220474,   6.36363649
  41448,  -7.24252129,   74.4024582,   6.36363649
  41449,  -8.02093601,   74.1577835,   6.36363649
  41450,  -8.79111004,   73.8882904,   6.36363649
  41451,  -9.55225086,   73.5942459,   6.36363649
  41452,  -10.3035755,   73.2759552,   6.36363649
  41453,  -11.0443125,    72.933754,   6.36363649
  41454,  -11.7737026,   72.5679855,   6.36363649
  41455,  -12.4909916,   72.1790237,   6.36363649
  41456,  -13.1954479,   71.7672729,   6.36363649
  41457,  -13.8863411,   71.3331528,   6.36363649
  41458,  -14.5629683,   70.8771133,   6.36363649
  41459,  -15.2246294,   70.3996201,   6.36363649
  41460,  -15.8706512,   69.9011612,   6.36363649
  41461,  -16.5003586,   69.3822632,   6.36363649
  41462,  -17.1131134,   68.8434372,   6.36363649
  41463,  -17.7082806,   68.2852554,   6.36363649
  41464,  -18.2852554,   67.7082825,   6.36363649
  41465,  -18.8434372,   67.1131134,   6.36363649
  41466,  -19.3822613,   66.5003586,   6.36363649
  41467,  -19.9011631,   65.8706512,   6.36363649
  41468,   -20.399622,   65.2246323,   6.36363649
  41469,  -20.8771133,    64.562973,   6.36363649
  41470,   -21.333149,   63.8863411,   6.36363649
  41471,  -21.7672691,    63.195446,   6.36363649
  41472,  -22.1790218,   62.4909935,   6.36363649
  41473,  -22.5679817,   61.7737007,   6.36363649
  41474,  -22.9337521,   61.0443115,   6.36363649
  41475,  -23.2759571,   60.3035774,   6.36363649
  41476,   -23.594244,   59.5522499,   6.36363649
  41477,  -23.8882866,    58.791111,   6.36363649
  41478,  -24.1577835,   58.0209351,   6.36363649
  41479,  -24.4024544,   57.2425194,   6.36363649
  41480,  -24.6220512,   56.4566612,   6.36363649
  41481,  -24.8163471,   55.6641693,   6.36363649
  41482,  -24.9851398,   54.8658562,   6.36363649
  41483,  -25.1282635,    54.062542,   6.36363649
  41484,  -25.2455635,   53.2550545,   6.36363649
  41485,  -25.3369236,   52.4442215,   6.36363649
  41486,  -25.4022465,   51.6308784,   6.36363649
  41487,  -25.4414673,   50.8158569,   6.36363649
  41488,   25.4414673,   50.8158569,   7.27272749
  41489,   25.4022465,   51.6308784,   7.27272749
  41490,   25.3369236,   52.4442215,   7.27272749
  41491,   25.2455635,   53.2550545,   7.27272749
  41492,   25.1282635,    54.062542,   7.27272749
  41493,   24.9851398,   54.8658562,   7.27272749
  41494,   24.8163471,   55.6641693,   7.27272749
  41495,   24.6220512,   56.4566612,   7.27272749
  41496,   24.4024544,   57.2425194,   7.27272749
  41497,   24.1577835,   58.0209351,   7.27272749
  41498,   23.8882866,    58.791111,   7.27272749
  41499,    23.594244,   59.5522499,   7.27272749
  41500,   23.2759571,   60.3035774,   7.27272749
  41501,   22.9337521,   61.0443115,   7.27272749
  41502,   22.5679817,   61.7737007,   7.27272749
  41503,   22.1790218,   62.4909935,   7.27272749
  41504,   21.7672691,    63.195446,   7.27272749
  41505,    21.333149,   63.8863411,   7.27272749
  41506,   20.8771133,    64.562973,   7.27272749
  41507,    20.399622,   65.2246323,   7.27272749
  41508,   19.9011631,   65.8706512,   7.27272749
  41509,   19.3822613,   66.5003586,   7.27272749
  41510,   18.8434372,   67.1131134,   7.27272749
  41511,   18.2852554,   67.7082825,   7.27272749
  41512,   17.7082806,   68.2852554,   7.27272749
  41513,   17.1131134,   68.8434372,   7.27272749
  41514,   16.5003586,   69.3822632,   7.27272749
  41515,   15.8706512,   69.9011612,   7.27272749
  41516,   15.2246294,   70.3996201,   7.27272749
  41517,   14.5629683,   70.8771133,   7.27272749
  41518,   13.8863411,   71.3331528,   7.27272749
  41519,   13.1954479,   71.7672729,   7.27272749
  41520,   12.4909916,   72.1790237,   7.27272749
  41521,   11.7737026,   72.5679855,   7.27272749
  41522,   11.0443125,    72.933754,   7.27272749
  41523,   10.3035755,   73.2759552,   7.27272749
  41524,   9.55225086,   73.5942459,   7.27272749
  41525,   8.79111004,   73.8882904,   7.27272749
  41526,   8.02093601,   74.1577835,   7.27272749
  41527,   7.24252129,   74.4024582,   7.27272749
  41528,   6.45666265,   74.6220474,   7.27272749
  41529,   5.66416883,   74.8163452,   7.27272749
  41530,   4.86585617,   74.9851456,   7.27272749
  41531,   4.06254244,   75.1282654,   7.27272749
  41532,   3.25505495,   75.2455673,   7.27272749
  41533,   2.44422245,   75.3369217,   7.27272749
  41534,   1.63087833,   75.4022446,   7.27272749
  41535,  0.815858364,   75.4414673,   7.27272749
  41536,           0.,   75.4545441,   7.27272749
  41537, -0.815858364,   75.4414673,   7.27272749
  41538,  -1.63087833,   75.4022446,   7.27272749
  41539,  -2.44422245,   75.3369217,   7.27272749
  41540,  -3.25505495,   75.2455673,   7.27272749
  41541,  -4.06254244,   75.1282654,   7.27272749
  41542,  -4.86585617,   74.9851456,   7.27272749
  41543,  -5.66416883,   74.8163452,   7.27272749
  41544,  -6.45666265,   74.6220474,   7.27272749
  41545,  -7.24252129,   74.4024582,   7.27272749
  41546,  -8.02093601,   74.1577835,   7.27272749
  41547,  -8.79111004,   73.8882904,   7.27272749
  41548,  -9.55225086,   73.5942459,   7.27272749
  41549,  -10.3035755,   73.2759552,   7.27272749
  41550,  -11.0443125,    72.933754,   7.27272749
  41551,  -11.7737026,   72.5679855,   7.27272749
  41552,  -12.4909916,   72.1790237,   7.27272749
  41553,  -13.1954479,   71.7672729,   7.27272749
  41554,  -13.8863411,   71.3331528,   7.27272749
  41555,  -14.5629683,   70.8771133,   7.27272749
  41556,  -15.2246294,   70.3996201,   7.27272749
  41557,  -15.8706512,   69.9011612,   7.27272749
  41558,  -16.5003586,   69.3822632,   7.27272749
  41559,  -17.1131134,   68.8434372,   7.27272749
  41560,  -17.7082806,   68.2852554,   7.27272749
  41561,  -18.2852554,   67.7082825,   7.27272749
  41562,  -18.8434372,   67.1131134,   7.27272749
  41563,  -19.3822613,   66.5003586,   7.27272749
  41564,  -19.9011631,   65.8706512,   7.27272749
  41565,   -20.399622,   65.2246323,   7.27272749
  41566,  -20.8771133,    64.562973,   7.27272749
  41567,   -21.333149,   63.8863411,   7.27272749
  41568,  -21.7672691,    63.195446,   7.27272749
  41569,  -22.1790218,   62.4909935,   7.27272749
  41570,  -22.5679817,   61.7737007,   7.27272749
  41571,  -22.9337521,   61.0443115,   7.27272749
  41572,  -23.2759571,   60.3035774,   7.27272749
  41573,   -23.594244,   59.5522499,   7.27272749
  41574,  -23.8882866,    58.791111,   7.27272749
  41575,  -24.1577835,   58.0209351,   7.27272749
  41576,  -24.4024544,   57.2425194,   7.27272749
  41577,  -24.6220512,   56.4566612,   7.27272749
  41578,  -24.8163471,   55.6641693,   7.27272749
  41579,  -24.9851398,   54.8658562,   7.27272749
  41580,  -25.1282635,    54.062542,   7.27272749
  41581,  -25.2455635,   53.2550545,   7.27272749
  41582,  -25.3369236,   52.4442215,   7.27272749
  41583,  -25.4022465,   51.6308784,   7.27272749
  41584,  -25.4414673,   50.8158569,   7.27272749
  41585,   25.4414673,   50.8158569,   8.18181801
  41586,   25.4022465,   51.6308784,   8.18181801
  41587,   25.3369236,   52.4442215,   8.18181801
  41588,   25.2455635,   53.2550545,   8.18181801
  41589,   25.1282635,    54.062542,   8.18181801
  41590,   24.9851398,   54.8658562,   8.18181801
  41591,   24.8163471,   55.6641693,   8.18181801
  41592,   24.6220512,   56.4566612,   8.18181801
  41593,   24.4024544,   57.2425194,   8.18181801
  41594,   24.1577835,   58.0209351,   8.18181801
  41595,   23.8882866,    58.791111,   8.18181801
  41596,    23.594244,   59.5522499,   8.18181801
  41597,   23.2759571,   60.3035774,   8.18181801
  41598,   22.9337521,   61.0443115,   8.18181801
  41599,   22.5679817,   61.7737007,   8.18181801
  41600,   22.1790218,   62.4909935,   8.18181801
  41601,   21.7672691,    63.195446,   8.18181801
  41602,    21.333149,   63.8863411,   8.18181801
  41603,   20.8771133,    64.562973,   8.18181801
  41604,    20.399622,   65.2246323,   8.18181801
  41605,   19.9011631,   65.8706512,   8.18181801
  41606,   19.3822613,   66.5003586,   8.18181801
  41607,   18.8434372,   67.1131134,   8.18181801
  41608,   18.2852554,   67.7082825,   8.18181801
  41609,   17.7082806,   68.2852554,   8.18181801
  41610,   17.1131134,   68.8434372,   8.18181801
  41611,   16.5003586,   69.3822632,   8.18181801
  41612,   15.8706512,   69.9011612,   8.18181801
  41613,   15.2246294,   70.3996201,   8.18181801
  41614,   14.5629683,   70.8771133,   8.18181801
  41615,   13.8863411,   71.3331528,   8.18181801
  41616,   13.1954479,   71.7672729,   8.18181801
  41617,   12.4909916,   72.1790237,   8.18181801
  41618,   11.7737026,   72.5679855,   8.18181801
  41619,   11.0443125,    72.933754,   8.18181801
  41620,   10.3035755,   73.2759552,   8.18181801
  41621,   9.55225086,   73.5942459,   8.18181801
  41622,   8.79111004,   73.8882904,   8.18181801
  41623,   8.02093601,   74.1577835,   8.18181801
  41624,   7.24252129,   74.4024582,   8.18181801
  41625,   6.45666265,   74.6220474,   8.18181801
  41626,   5.66416883,   74.8163452,   8.18181801
  41627,   4.86585617,   74.9851456,   8.18181801
  41628,   4.06254244,   75.1282654,   8.18181801
  41629,   3.25505495,   75.2455673,   8.18181801
  41630,   2.44422245,   75.3369217,   8.18181801
  41631,   1.63087833,   75.4022446,   8.18181801
  41632,  0.815858364,   75.4414673,   8.18181801
  41633,           0.,   75.4545441,   8.18181801
  41634, -0.815858364,   75.4414673,   8.18181801
  41635,  -1.63087833,   75.4022446,   8.18181801
  41636,  -2.44422245,   75.3369217,   8.18181801
  41637,  -3.25505495,   75.2455673,   8.18181801
  41638,  -4.06254244,   75.1282654,   8.18181801
  41639,  -4.86585617,   74.9851456,   8.18181801
  41640,  -5.66416883,   74.8163452,   8.18181801
  41641,  -6.45666265,   74.6220474,   8.18181801
  41642,  -7.24252129,   74.4024582,   8.18181801
  41643,  -8.02093601,   74.1577835,   8.18181801
  41644,  -8.79111004,   73.8882904,   8.18181801
  41645,  -9.55225086,   73.5942459,   8.18181801
  41646,  -10.3035755,   73.2759552,   8.18181801
  41647,  -11.0443125,    72.933754,   8.18181801
  41648,  -11.7737026,   72.5679855,   8.18181801
  41649,  -12.4909916,   72.1790237,   8.18181801
  41650,  -13.1954479,   71.7672729,   8.18181801
  41651,  -13.8863411,   71.3331528,   8.18181801
  41652,  -14.5629683,   70.8771133,   8.18181801
  41653,  -15.2246294,   70.3996201,   8.18181801
  41654,  -15.8706512,   69.9011612,   8.18181801
  41655,  -16.5003586,   69.3822632,   8.18181801
  41656,  -17.1131134,   68.8434372,   8.18181801
  41657,  -17.7082806,   68.2852554,   8.18181801
  41658,  -18.2852554,   67.7082825,   8.18181801
  41659,  -18.8434372,   67.1131134,   8.18181801
  41660,  -19.3822613,   66.5003586,   8.18181801
  41661,  -19.9011631,   65.8706512,   8.18181801
  41662,   -20.399622,   65.2246323,   8.18181801
  41663,  -20.8771133,    64.562973,   8.18181801
  41664,   -21.333149,   63.8863411,   8.18181801
  41665,  -21.7672691,    63.195446,   8.18181801
  41666,  -22.1790218,   62.4909935,   8.18181801
  41667,  -22.5679817,   61.7737007,   8.18181801
  41668,  -22.9337521,   61.0443115,   8.18181801
  41669,  -23.2759571,   60.3035774,   8.18181801
  41670,   -23.594244,   59.5522499,   8.18181801
  41671,  -23.8882866,    58.791111,   8.18181801
  41672,  -24.1577835,   58.0209351,   8.18181801
  41673,  -24.4024544,   57.2425194,   8.18181801
  41674,  -24.6220512,   56.4566612,   8.18181801
  41675,  -24.8163471,   55.6641693,   8.18181801
  41676,  -24.9851398,   54.8658562,   8.18181801
  41677,  -25.1282635,    54.062542,   8.18181801
  41678,  -25.2455635,   53.2550545,   8.18181801
  41679,  -25.3369236,   52.4442215,   8.18181801
  41680,  -25.4022465,   51.6308784,   8.18181801
  41681,  -25.4414673,   50.8158569,   8.18181801
  41682,   25.4414673,   50.8158569,     9.090909
  41683,   25.4022465,   51.6308784,     9.090909
  41684,   25.3369236,   52.4442215,     9.090909
  41685,   25.2455635,   53.2550545,     9.090909
  41686,   25.1282635,    54.062542,     9.090909
  41687,   24.9851398,   54.8658562,     9.090909
  41688,   24.8163471,   55.6641693,     9.090909
  41689,   24.6220512,   56.4566612,     9.090909
  41690,   24.4024544,   57.2425194,     9.090909
  41691,   24.1577835,   58.0209351,     9.090909
  41692,   23.8882866,    58.791111,     9.090909
  41693,    23.594244,   59.5522499,     9.090909
  41694,   23.2759571,   60.3035774,     9.090909
  41695,   22.9337521,   61.0443115,     9.090909
  41696,   22.5679817,   61.7737007,     9.090909
  41697,   22.1790218,   62.4909935,     9.090909
  41698,   21.7672691,    63.195446,     9.090909
  41699,    21.333149,   63.8863411,     9.090909
  41700,   20.8771133,    64.562973,     9.090909
  41701,    20.399622,   65.2246323,     9.090909
  41702,   19.9011631,   65.8706512,     9.090909
  41703,   19.3822613,   66.5003586,     9.090909
  41704,   18.8434372,   67.1131134,     9.090909
  41705,   18.2852554,   67.7082825,     9.090909
  41706,   17.7082806,   68.2852554,     9.090909
  41707,   17.1131134,   68.8434372,     9.090909
  41708,   16.5003586,   69.3822632,     9.090909
  41709,   15.8706512,   69.9011612,     9.090909
  41710,   15.2246294,   70.3996201,     9.090909
  41711,   14.5629683,   70.8771133,     9.090909
  41712,   13.8863411,   71.3331528,     9.090909
  41713,   13.1954479,   71.7672729,     9.090909
  41714,   12.4909916,   72.1790237,     9.090909
  41715,   11.7737026,   72.5679855,     9.090909
  41716,   11.0443125,    72.933754,     9.090909
  41717,   10.3035755,   73.2759552,     9.090909
  41718,   9.55225086,   73.5942459,     9.090909
  41719,   8.79111004,   73.8882904,     9.090909
  41720,   8.02093601,   74.1577835,     9.090909
  41721,   7.24252129,   74.4024582,     9.090909
  41722,   6.45666265,   74.6220474,     9.090909
  41723,   5.66416883,   74.8163452,     9.090909
  41724,   4.86585617,   74.9851456,     9.090909
  41725,   4.06254244,   75.1282654,     9.090909
  41726,   3.25505495,   75.2455673,     9.090909
  41727,   2.44422245,   75.3369217,     9.090909
  41728,   1.63087833,   75.4022446,     9.090909
  41729,  0.815858364,   75.4414673,     9.090909
  41730,           0.,   75.4545441,     9.090909
  41731, -0.815858364,   75.4414673,     9.090909
  41732,  -1.63087833,   75.4022446,     9.090909
  41733,  -2.44422245,   75.3369217,     9.090909
  41734,  -3.25505495,   75.2455673,     9.090909
  41735,  -4.06254244,   75.1282654,     9.090909
  41736,  -4.86585617,   74.9851456,     9.090909
  41737,  -5.66416883,   74.8163452,     9.090909
  41738,  -6.45666265,   74.6220474,     9.090909
  41739,  -7.24252129,   74.4024582,     9.090909
  41740,  -8.02093601,   74.1577835,     9.090909
  41741,  -8.79111004,   73.8882904,     9.090909
  41742,  -9.55225086,   73.5942459,     9.090909
  41743,  -10.3035755,   73.2759552,     9.090909
  41744,  -11.0443125,    72.933754,     9.090909
  41745,  -11.7737026,   72.5679855,     9.090909
  41746,  -12.4909916,   72.1790237,     9.090909
  41747,  -13.1954479,   71.7672729,     9.090909
  41748,  -13.8863411,   71.3331528,     9.090909
  41749,  -14.5629683,   70.8771133,     9.090909
  41750,  -15.2246294,   70.3996201,     9.090909
  41751,  -15.8706512,   69.9011612,     9.090909
  41752,  -16.5003586,   69.3822632,     9.090909
  41753,  -17.1131134,   68.8434372,     9.090909
  41754,  -17.7082806,   68.2852554,     9.090909
  41755,  -18.2852554,   67.7082825,     9.090909
  41756,  -18.8434372,   67.1131134,     9.090909
  41757,  -19.3822613,   66.5003586,     9.090909
  41758,  -19.9011631,   65.8706512,     9.090909
  41759,   -20.399622,   65.2246323,     9.090909
  41760,  -20.8771133,    64.562973,     9.090909
  41761,   -21.333149,   63.8863411,     9.090909
  41762,  -21.7672691,    63.195446,     9.090909
  41763,  -22.1790218,   62.4909935,     9.090909
  41764,  -22.5679817,   61.7737007,     9.090909
  41765,  -22.9337521,   61.0443115,     9.090909
  41766,  -23.2759571,   60.3035774,     9.090909
  41767,   -23.594244,   59.5522499,     9.090909
  41768,  -23.8882866,    58.791111,     9.090909
  41769,  -24.1577835,   58.0209351,     9.090909
  41770,  -24.4024544,   57.2425194,     9.090909
  41771,  -24.6220512,   56.4566612,     9.090909
  41772,  -24.8163471,   55.6641693,     9.090909
  41773,  -24.9851398,   54.8658562,     9.090909
  41774,  -25.1282635,    54.062542,     9.090909
  41775,  -25.2455635,   53.2550545,     9.090909
  41776,  -25.3369236,   52.4442215,     9.090909
  41777,  -25.4022465,   51.6308784,     9.090909
  41778,  -25.4414673,   50.8158569,     9.090909
  41779,   24.5328426,   50.7867203,  0.909090936
  41780,   24.4950237,   51.5726318,  0.909090936
  41781,   24.4320354,   52.3569298,  0.909090936
  41782,   24.3439369,   53.1388016,  0.909090936
  41783,   24.2308254,   53.9174538,  0.909090936
  41784,   24.0928154,   54.6920738,  0.909090936
  41785,    23.930048,   55.4618759,  0.909090936
  41786,   23.7426929,   56.2260666,  0.909090936
  41787,   23.5309391,     56.98386,  0.909090936
  41788,   23.2950039,   57.7344742,  0.909090936
  41789,   23.0351315,   58.4771423,  0.909090936
  41790,   22.7515926,   59.2110977,  0.909090936
  41791,   22.4446754,   59.9355927,  0.909090936
  41792,   22.1146927,   60.6498718,  0.909090936
  41793,    21.761982,   61.3532143,  0.909090936
  41794,   21.3869133,   62.0448837,  0.909090936
  41795,   20.9898682,   62.7241821,  0.909090936
  41796,   20.5712528,   63.3904037,  0.909090936
  41797,   20.1315002,   64.0428619,  0.909090936
  41798,   19.6710625,   64.6808929,  0.909090936
  41799,   19.1904087,   65.3038406,  0.909090936
  41800,   18.6900368,   65.9110641,  0.909090936
  41801,   18.1704597,   66.5019302,  0.909090936
  41802,   17.6322117,   67.0758438,  0.909090936
  41803,   17.0758419,   67.6322098,  0.909090936
  41804,   16.5019302,   68.1704636,  0.909090936
  41805,   15.9110603,   68.6900406,  0.909090936
  41806,   15.3038416,   69.1904068,  0.909090936
  41807,   14.6808939,   69.6710587,  0.909090936
  41808,   14.0428638,   70.1315002,  0.909090936
  41809,   13.3904009,   70.5712509,  0.909090936
  41810,   12.7241831,   70.9898682,  0.909090936
  41811,   12.0448847,   71.3869171,  0.909090936
  41812,   11.3532124,   71.7619858,  0.909090936
  41813,   10.6498728,   72.1146927,  0.909090936
  41814,   9.93558979,   72.4446716,  0.909090936
  41815,   9.21109867,   72.7515945,  0.909090936
  41816,   8.47714138,   73.0351334,  0.909090936
  41817,   7.73447418,   73.2950058,  0.909090936
  41818,   6.98385954,   73.5309372,  0.909090936
  41819,   6.22606802,    73.742691,  0.909090936
  41820,   5.46187687,   73.9300461,  0.909090936
  41821,   4.69207525,   74.0928192,  0.909090936
  41822,   3.91745162,   74.2308273,  0.909090936
  41823,   3.13880301,   74.3439331,  0.909090936
  41824,   2.35692859,   74.4320297,  0.909090936
  41825,   1.57263267,   74.4950256,  0.909090936
  41826,  0.786720514,   74.5328445,  0.909090936
  41827,           0.,   74.5454559,  0.909090936
  41828, -0.786720514,   74.5328445,  0.909090936
  41829,  -1.57263267,   74.4950256,  0.909090936
  41830,  -2.35692859,   74.4320297,  0.909090936
  41831,  -3.13880301,   74.3439331,  0.909090936
  41832,  -3.91745162,   74.2308273,  0.909090936
  41833,  -4.69207525,   74.0928192,  0.909090936
  41834,  -5.46187687,   73.9300461,  0.909090936
  41835,  -6.22606802,    73.742691,  0.909090936
  41836,  -6.98385954,   73.5309372,  0.909090936
  41837,  -7.73447418,   73.2950058,  0.909090936
  41838,  -8.47714138,   73.0351334,  0.909090936
  41839,  -9.21109867,   72.7515945,  0.909090936
  41840,  -9.93558979,   72.4446716,  0.909090936
  41841,  -10.6498728,   72.1146927,  0.909090936
  41842,  -11.3532124,   71.7619858,  0.909090936
  41843,  -12.0448847,   71.3869171,  0.909090936
  41844,  -12.7241831,   70.9898682,  0.909090936
  41845,  -13.3904009,   70.5712509,  0.909090936
  41846,  -14.0428638,   70.1315002,  0.909090936
  41847,  -14.6808939,   69.6710587,  0.909090936
  41848,  -15.3038416,   69.1904068,  0.909090936
  41849,  -15.9110603,   68.6900406,  0.909090936
  41850,  -16.5019302,   68.1704636,  0.909090936
  41851,  -17.0758419,   67.6322098,  0.909090936
  41852,  -17.6322117,   67.0758438,  0.909090936
  41853,  -18.1704597,   66.5019302,  0.909090936
  41854,  -18.6900368,   65.9110641,  0.909090936
  41855,  -19.1904087,   65.3038406,  0.909090936
  41856,  -19.6710625,   64.6808929,  0.909090936
  41857,  -20.1315002,   64.0428619,  0.909090936
  41858,  -20.5712528,   63.3904037,  0.909090936
  41859,  -20.9898682,   62.7241821,  0.909090936
  41860,  -21.3869133,   62.0448837,  0.909090936
  41861,   -21.761982,   61.3532143,  0.909090936
  41862,  -22.1146927,   60.6498718,  0.909090936
  41863,  -22.4446754,   59.9355927,  0.909090936
  41864,  -22.7515926,   59.2110977,  0.909090936
  41865,  -23.0351315,   58.4771423,  0.909090936
  41866,  -23.2950039,   57.7344742,  0.909090936
  41867,  -23.5309391,     56.98386,  0.909090936
  41868,  -23.7426929,   56.2260666,  0.909090936
  41869,   -23.930048,   55.4618759,  0.909090936
  41870,  -24.0928154,   54.6920738,  0.909090936
  41871,  -24.2308254,   53.9174538,  0.909090936
  41872,  -24.3439369,   53.1388016,  0.909090936
  41873,  -24.4320354,   52.3569298,  0.909090936
  41874,  -24.4950237,   51.5726318,  0.909090936
  41875,  -24.5328426,   50.7867203,  0.909090936
  41876,   24.5328426,   50.7867203,   1.81818187
  41877,   24.4950237,   51.5726318,   1.81818187
  41878,   24.4320354,   52.3569298,   1.81818187
  41879,   24.3439369,   53.1388016,   1.81818187
  41880,   24.2308254,   53.9174538,   1.81818187
  41881,   24.0928154,   54.6920738,   1.81818187
  41882,    23.930048,   55.4618759,   1.81818187
  41883,   23.7426929,   56.2260666,   1.81818187
  41884,   23.5309391,     56.98386,   1.81818187
  41885,   23.2950039,   57.7344742,   1.81818187
  41886,   23.0351315,   58.4771423,   1.81818187
  41887,   22.7515926,   59.2110977,   1.81818187
  41888,   22.4446754,   59.9355927,   1.81818187
  41889,   22.1146927,   60.6498718,   1.81818187
  41890,    21.761982,   61.3532143,   1.81818187
  41891,   21.3869133,   62.0448837,   1.81818187
  41892,   20.9898682,   62.7241821,   1.81818187
  41893,   20.5712528,   63.3904037,   1.81818187
  41894,   20.1315002,   64.0428619,   1.81818187
  41895,   19.6710625,   64.6808929,   1.81818187
  41896,   19.1904087,   65.3038406,   1.81818187
  41897,   18.6900368,   65.9110641,   1.81818187
  41898,   18.1704597,   66.5019302,   1.81818187
  41899,   17.6322117,   67.0758438,   1.81818187
  41900,   17.0758419,   67.6322098,   1.81818187
  41901,   16.5019302,   68.1704636,   1.81818187
  41902,   15.9110603,   68.6900406,   1.81818187
  41903,   15.3038416,   69.1904068,   1.81818187
  41904,   14.6808939,   69.6710587,   1.81818187
  41905,   14.0428638,   70.1315002,   1.81818187
  41906,   13.3904009,   70.5712509,   1.81818187
  41907,   12.7241831,   70.9898682,   1.81818187
  41908,   12.0448847,   71.3869171,   1.81818187
  41909,   11.3532124,   71.7619858,   1.81818187
  41910,   10.6498728,   72.1146927,   1.81818187
  41911,   9.93558979,   72.4446716,   1.81818187
  41912,   9.21109867,   72.7515945,   1.81818187
  41913,   8.47714138,   73.0351334,   1.81818187
  41914,   7.73447418,   73.2950058,   1.81818187
  41915,   6.98385954,   73.5309372,   1.81818187
  41916,   6.22606802,    73.742691,   1.81818187
  41917,   5.46187687,   73.9300461,   1.81818187
  41918,   4.69207525,   74.0928192,   1.81818187
  41919,   3.91745162,   74.2308273,   1.81818187
  41920,   3.13880301,   74.3439331,   1.81818187
  41921,   2.35692859,   74.4320297,   1.81818187
  41922,   1.57263267,   74.4950256,   1.81818187
  41923,  0.786720514,   74.5328445,   1.81818187
  41924,           0.,   74.5454559,   1.81818187
  41925, -0.786720514,   74.5328445,   1.81818187
  41926,  -1.57263267,   74.4950256,   1.81818187
  41927,  -2.35692859,   74.4320297,   1.81818187
  41928,  -3.13880301,   74.3439331,   1.81818187
  41929,  -3.91745162,   74.2308273,   1.81818187
  41930,  -4.69207525,   74.0928192,   1.81818187
  41931,  -5.46187687,   73.9300461,   1.81818187
  41932,  -6.22606802,    73.742691,   1.81818187
  41933,  -6.98385954,   73.5309372,   1.81818187
  41934,  -7.73447418,   73.2950058,   1.81818187
  41935,  -8.47714138,   73.0351334,   1.81818187
  41936,  -9.21109867,   72.7515945,   1.81818187
  41937,  -9.93558979,   72.4446716,   1.81818187
  41938,  -10.6498728,   72.1146927,   1.81818187
  41939,  -11.3532124,   71.7619858,   1.81818187
  41940,  -12.0448847,   71.3869171,   1.81818187
  41941,  -12.7241831,   70.9898682,   1.81818187
  41942,  -13.3904009,   70.5712509,   1.81818187
  41943,  -14.0428638,   70.1315002,   1.81818187
  41944,  -14.6808939,   69.6710587,   1.81818187
  41945,  -15.3038416,   69.1904068,   1.81818187
  41946,  -15.9110603,   68.6900406,   1.81818187
  41947,  -16.5019302,   68.1704636,   1.81818187
  41948,  -17.0758419,   67.6322098,   1.81818187
  41949,  -17.6322117,   67.0758438,   1.81818187
  41950,  -18.1704597,   66.5019302,   1.81818187
  41951,  -18.6900368,   65.9110641,   1.81818187
  41952,  -19.1904087,   65.3038406,   1.81818187
  41953,  -19.6710625,   64.6808929,   1.81818187
  41954,  -20.1315002,   64.0428619,   1.81818187
  41955,  -20.5712528,   63.3904037,   1.81818187
  41956,  -20.9898682,   62.7241821,   1.81818187
  41957,  -21.3869133,   62.0448837,   1.81818187
  41958,   -21.761982,   61.3532143,   1.81818187
  41959,  -22.1146927,   60.6498718,   1.81818187
  41960,  -22.4446754,   59.9355927,   1.81818187
  41961,  -22.7515926,   59.2110977,   1.81818187
  41962,  -23.0351315,   58.4771423,   1.81818187
  41963,  -23.2950039,   57.7344742,   1.81818187
  41964,  -23.5309391,     56.98386,   1.81818187
  41965,  -23.7426929,   56.2260666,   1.81818187
  41966,   -23.930048,   55.4618759,   1.81818187
  41967,  -24.0928154,   54.6920738,   1.81818187
  41968,  -24.2308254,   53.9174538,   1.81818187
  41969,  -24.3439369,   53.1388016,   1.81818187
  41970,  -24.4320354,   52.3569298,   1.81818187
  41971,  -24.4950237,   51.5726318,   1.81818187
  41972,  -24.5328426,   50.7867203,   1.81818187
  41973,   24.5328426,   50.7867203,   2.72727275
  41974,   24.4950237,   51.5726318,   2.72727275
  41975,   24.4320354,   52.3569298,   2.72727275
  41976,   24.3439369,   53.1388016,   2.72727275
  41977,   24.2308254,   53.9174538,   2.72727275
  41978,   24.0928154,   54.6920738,   2.72727275
  41979,    23.930048,   55.4618759,   2.72727275
  41980,   23.7426929,   56.2260666,   2.72727275
  41981,   23.5309391,     56.98386,   2.72727275
  41982,   23.2950039,   57.7344742,   2.72727275
  41983,   23.0351315,   58.4771423,   2.72727275
  41984,   22.7515926,   59.2110977,   2.72727275
  41985,   22.4446754,   59.9355927,   2.72727275
  41986,   22.1146927,   60.6498718,   2.72727275
  41987,    21.761982,   61.3532143,   2.72727275
  41988,   21.3869133,   62.0448837,   2.72727275
  41989,   20.9898682,   62.7241821,   2.72727275
  41990,   20.5712528,   63.3904037,   2.72727275
  41991,   20.1315002,   64.0428619,   2.72727275
  41992,   19.6710625,   64.6808929,   2.72727275
  41993,   19.1904087,   65.3038406,   2.72727275
  41994,   18.6900368,   65.9110641,   2.72727275
