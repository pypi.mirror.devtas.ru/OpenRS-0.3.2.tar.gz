  57995,  -28.4746342,   11.8830614,   5.92751503
  57996,  -28.5034771,   11.7949276,   5.34573174
  57997,  -28.5323219,   11.7067928,   4.76394796
  57998,  -28.5611668,    11.618659,   4.18216467
  57999,  -28.0929527,   13.0493116,   9.47304153
  58000,  -28.1177235,   12.9736223,   8.94608307
  58001,  -28.1424942,    12.897934,   8.41912365
  58002,  -28.1672649,   12.8222446,   7.89216518
  58003,  -28.1920357,   12.7465563,   7.36520672
  58004,  -28.2168064,   12.6708679,   6.83824825
  58005,  -28.2415791,   12.5951796,   6.31128979
  58006,  -28.2663498,   12.5194912,   5.78433084
  58007,  -28.2911205,   12.4438019,   5.25737238
  58008,  -28.3158913,   12.3681135,   4.73041391
  58009,  -27.8816261,   13.6950293,   9.51302719
  58010,  -27.8996162,   13.6400595,   9.02605343
  58011,  -27.9176064,   13.5850887,   8.53908062
  58012,  -27.9355965,   13.5301189,   8.05210686
  58013,  -27.9535885,   13.4751482,   7.56513405
  58014,  -27.9715786,   13.4201784,   7.07816076
  58015,  -27.9895687,   13.3652077,   6.59118748
  58016,  -28.0075588,   13.3102379,   6.10421467
  58017,  -28.0255489,   13.2552671,   5.61724138
  58018,   -28.043539,   13.2002974,    5.1302681
  58019,  -27.6685238,   14.3461742,   9.53731346
  58020,  -27.6779575,   14.3173494,   9.07462692
  58021,  -27.6873913,   14.2885237,   8.61194038
  58022,   -27.696825,   14.2596989,   8.14925385
  58023,  -27.7062607,   14.2308731,   7.68656683
  58024,  -27.7156925,   14.2020483,   7.22388029
  58025,  -27.7251263,   14.1732225,   6.76119328
  58026,    -27.73456,   14.1443977,   6.29850674
  58027,  -27.7439938,    14.115572,    5.8358202
  58028,  -27.7534275,   14.0867462,   5.37313366
  58029,    -20.90909,   9.16666698,  0.909090936
  58030,   -21.818182,   9.16666698,  0.909090936
  58031,   -22.727272,   9.16666698,  0.909090936
  58032,   -23.636364,   9.16666698,  0.909090936
  58033,   -24.545454,   9.16666698,  0.909090936
  58034,   -25.454546,   9.16666698,  0.909090936
  58035,   -26.363636,   9.16666698,  0.909090936
  58036,   -27.272728,   9.16666698,  0.909090936
  58037,   -28.181818,   9.16666698,  0.909090936
  58038,    -29.09091,   9.16666698,  0.909090936
  58039,    -20.90909,   9.16666698,   1.81818187
  58040,   -21.818182,   9.16666698,   1.81818187
  58041,   -22.727272,   9.16666698,   1.81818187
  58042,   -23.636364,   9.16666698,   1.81818187
  58043,   -24.545454,   9.16666698,   1.81818187
  58044,   -25.454546,   9.16666698,   1.81818187
  58045,   -26.363636,   9.16666698,   1.81818187
  58046,   -27.272728,   9.16666698,   1.81818187
  58047,   -28.181818,   9.16666698,   1.81818187
  58048,    -29.09091,   9.16666698,   1.81818187
  58049,    -20.90909,   9.16666698,   2.72727275
  58050,   -21.818182,   9.16666698,   2.72727275
  58051,   -22.727272,   9.16666698,   2.72727275
  58052,   -23.636364,   9.16666698,   2.72727275
  58053,   -24.545454,   9.16666698,   2.72727275
  58054,   -25.454546,   9.16666698,   2.72727275
  58055,   -26.363636,   9.16666698,   2.72727275
  58056,   -27.272728,   9.16666698,   2.72727275
  58057,   -28.181818,   9.16666698,   2.72727275
  58058,    -29.09091,   9.16666698,   2.72727275
  58059,    -20.90909,   9.16666698,   3.63636374
  58060,   -21.818182,   9.16666698,   3.63636374
  58061,   -22.727272,   9.16666698,   3.63636374
  58062,   -23.636364,   9.16666698,   3.63636374
  58063,   -24.545454,   9.16666698,   3.63636374
  58064,   -25.454546,   9.16666698,   3.63636374
  58065,   -26.363636,   9.16666698,   3.63636374
  58066,   -27.272728,   9.16666698,   3.63636374
  58067,   -28.181818,   9.16666698,   3.63636374
  58068,    -29.09091,   9.16666698,   3.63636374
  58069,    -20.90909,   9.16666698,    4.5454545
  58070,   -21.818182,   9.16666698,    4.5454545
  58071,   -22.727272,   9.16666698,    4.5454545
  58072,   -23.636364,   9.16666698,    4.5454545
  58073,   -24.545454,   9.16666698,    4.5454545
  58074,   -25.454546,   9.16666698,    4.5454545
  58075,   -26.363636,   9.16666698,    4.5454545
  58076,   -27.272728,   9.16666698,    4.5454545
  58077,   -28.181818,   9.16666698,    4.5454545
  58078,    -29.09091,   9.16666698,    4.5454545
  58079,    -20.90909,   9.16666698,    5.4545455
  58080,   -21.818182,   9.16666698,    5.4545455
  58081,   -22.727272,   9.16666698,    5.4545455
  58082,   -23.636364,   9.16666698,    5.4545455
  58083,   -24.545454,   9.16666698,    5.4545455
  58084,   -25.454546,   9.16666698,    5.4545455
  58085,   -26.363636,   9.16666698,    5.4545455
  58086,   -27.272728,   9.16666698,    5.4545455
  58087,   -28.181818,   9.16666698,    5.4545455
  58088,    -29.09091,   9.16666698,    5.4545455
  58089,    -20.90909,   9.16666698,   6.36363649
  58090,   -21.818182,   9.16666698,   6.36363649
  58091,   -22.727272,   9.16666698,   6.36363649
  58092,   -23.636364,   9.16666698,   6.36363649
  58093,   -24.545454,   9.16666698,   6.36363649
  58094,   -25.454546,   9.16666698,   6.36363649
  58095,   -26.363636,   9.16666698,   6.36363649
  58096,   -27.272728,   9.16666698,   6.36363649
  58097,   -28.181818,   9.16666698,   6.36363649
  58098,    -29.09091,   9.16666698,   6.36363649
  58099,    -20.90909,   9.16666698,   7.27272749
  58100,   -21.818182,   9.16666698,   7.27272749
  58101,   -22.727272,   9.16666698,   7.27272749
  58102,   -23.636364,   9.16666698,   7.27272749
  58103,   -24.545454,   9.16666698,   7.27272749
  58104,   -25.454546,   9.16666698,   7.27272749
  58105,   -26.363636,   9.16666698,   7.27272749
  58106,   -27.272728,   9.16666698,   7.27272749
  58107,   -28.181818,   9.16666698,   7.27272749
  58108,    -29.09091,   9.16666698,   7.27272749
  58109,    -20.90909,   9.16666698,   8.18181801
  58110,   -21.818182,   9.16666698,   8.18181801
  58111,   -22.727272,   9.16666698,   8.18181801
  58112,   -23.636364,   9.16666698,   8.18181801
  58113,   -24.545454,   9.16666698,   8.18181801
  58114,   -25.454546,   9.16666698,   8.18181801
  58115,   -26.363636,   9.16666698,   8.18181801
  58116,   -27.272728,   9.16666698,   8.18181801
  58117,   -28.181818,   9.16666698,   8.18181801
  58118,    -29.09091,   9.16666698,   8.18181801
  58119,    -20.90909,   9.16666698,     9.090909
  58120,   -21.818182,   9.16666698,     9.090909
  58121,   -22.727272,   9.16666698,     9.090909
  58122,   -23.636364,   9.16666698,     9.090909
  58123,   -24.545454,   9.16666698,     9.090909
  58124,   -25.454546,   9.16666698,     9.090909
  58125,   -26.363636,   9.16666698,     9.090909
  58126,   -27.272728,   9.16666698,     9.090909
  58127,   -28.181818,   9.16666698,     9.090909
  58128,    -29.09091,   9.16666698,     9.090909
  58129,    -20.90909,   8.33333302,  0.909090936
  58130,   -21.818182,   8.33333302,  0.909090936
  58131,   -22.727272,   8.33333302,  0.909090936
  58132,   -23.636364,   8.33333302,  0.909090936
  58133,   -24.545454,   8.33333302,  0.909090936
  58134,   -25.454546,   8.33333302,  0.909090936
  58135,   -26.363636,   8.33333302,  0.909090936
  58136,   -27.272728,   8.33333302,  0.909090936
  58137,   -28.181818,   8.33333302,  0.909090936
  58138,    -29.09091,   8.33333302,  0.909090936
  58139,    -20.90909,   8.33333302,   1.81818187
  58140,   -21.818182,   8.33333302,   1.81818187
  58141,   -22.727272,   8.33333302,   1.81818187
  58142,   -23.636364,   8.33333302,   1.81818187
  58143,   -24.545454,   8.33333302,   1.81818187
  58144,   -25.454546,   8.33333302,   1.81818187
  58145,   -26.363636,   8.33333302,   1.81818187
  58146,   -27.272728,   8.33333302,   1.81818187
  58147,   -28.181818,   8.33333302,   1.81818187
  58148,    -29.09091,   8.33333302,   1.81818187
  58149,    -20.90909,   8.33333302,   2.72727275
  58150,   -21.818182,   8.33333302,   2.72727275
  58151,   -22.727272,   8.33333302,   2.72727275
  58152,   -23.636364,   8.33333302,   2.72727275
  58153,   -24.545454,   8.33333302,   2.72727275
  58154,   -25.454546,   8.33333302,   2.72727275
  58155,   -26.363636,   8.33333302,   2.72727275
  58156,   -27.272728,   8.33333302,   2.72727275
  58157,   -28.181818,   8.33333302,   2.72727275
  58158,    -29.09091,   8.33333302,   2.72727275
  58159,    -20.90909,   8.33333302,   3.63636374
  58160,   -21.818182,   8.33333302,   3.63636374
  58161,   -22.727272,   8.33333302,   3.63636374
  58162,   -23.636364,   8.33333302,   3.63636374
  58163,   -24.545454,   8.33333302,   3.63636374
  58164,   -25.454546,   8.33333302,   3.63636374
  58165,   -26.363636,   8.33333302,   3.63636374
  58166,   -27.272728,   8.33333302,   3.63636374
  58167,   -28.181818,   8.33333302,   3.63636374
  58168,    -29.09091,   8.33333302,   3.63636374
  58169,    -20.90909,   8.33333302,    4.5454545
  58170,   -21.818182,   8.33333302,    4.5454545
  58171,   -22.727272,   8.33333302,    4.5454545
  58172,   -23.636364,   8.33333302,    4.5454545
  58173,   -24.545454,   8.33333302,    4.5454545
  58174,   -25.454546,   8.33333302,    4.5454545
  58175,   -26.363636,   8.33333302,    4.5454545
  58176,   -27.272728,   8.33333302,    4.5454545
  58177,   -28.181818,   8.33333302,    4.5454545
  58178,    -29.09091,   8.33333302,    4.5454545
  58179,    -20.90909,   8.33333302,    5.4545455
  58180,   -21.818182,   8.33333302,    5.4545455
  58181,   -22.727272,   8.33333302,    5.4545455
  58182,   -23.636364,   8.33333302,    5.4545455
  58183,   -24.545454,   8.33333302,    5.4545455
  58184,   -25.454546,   8.33333302,    5.4545455
  58185,   -26.363636,   8.33333302,    5.4545455
  58186,   -27.272728,   8.33333302,    5.4545455
  58187,   -28.181818,   8.33333302,    5.4545455
  58188,    -29.09091,   8.33333302,    5.4545455
  58189,    -20.90909,   8.33333302,   6.36363649
  58190,   -21.818182,   8.33333302,   6.36363649
  58191,   -22.727272,   8.33333302,   6.36363649
  58192,   -23.636364,   8.33333302,   6.36363649
  58193,   -24.545454,   8.33333302,   6.36363649
  58194,   -25.454546,   8.33333302,   6.36363649
  58195,   -26.363636,   8.33333302,   6.36363649
  58196,   -27.272728,   8.33333302,   6.36363649
  58197,   -28.181818,   8.33333302,   6.36363649
  58198,    -29.09091,   8.33333302,   6.36363649
  58199,    -20.90909,   8.33333302,   7.27272749
  58200,   -21.818182,   8.33333302,   7.27272749
  58201,   -22.727272,   8.33333302,   7.27272749
  58202,   -23.636364,   8.33333302,   7.27272749
  58203,   -24.545454,   8.33333302,   7.27272749
  58204,   -25.454546,   8.33333302,   7.27272749
  58205,   -26.363636,   8.33333302,   7.27272749
  58206,   -27.272728,   8.33333302,   7.27272749
  58207,   -28.181818,   8.33333302,   7.27272749
  58208,    -29.09091,   8.33333302,   7.27272749
  58209,    -20.90909,   8.33333302,   8.18181801
  58210,   -21.818182,   8.33333302,   8.18181801
  58211,   -22.727272,   8.33333302,   8.18181801
  58212,   -23.636364,   8.33333302,   8.18181801
  58213,   -24.545454,   8.33333302,   8.18181801
  58214,   -25.454546,   8.33333302,   8.18181801
  58215,   -26.363636,   8.33333302,   8.18181801
  58216,   -27.272728,   8.33333302,   8.18181801
  58217,   -28.181818,   8.33333302,   8.18181801
  58218,    -29.09091,   8.33333302,   8.18181801
  58219,    -20.90909,   8.33333302,     9.090909
  58220,   -21.818182,   8.33333302,     9.090909
  58221,   -22.727272,   8.33333302,     9.090909
  58222,   -23.636364,   8.33333302,     9.090909
  58223,   -24.545454,   8.33333302,     9.090909
  58224,   -25.454546,   8.33333302,     9.090909
  58225,   -26.363636,   8.33333302,     9.090909
  58226,   -27.272728,   8.33333302,     9.090909
  58227,   -28.181818,   8.33333302,     9.090909
  58228,    -29.09091,   8.33333302,     9.090909
  58229,    -20.90909,          7.5,  0.909090936
  58230,   -21.818182,          7.5,  0.909090936
  58231,   -22.727272,          7.5,  0.909090936
  58232,   -23.636364,          7.5,  0.909090936
  58233,   -24.545454,          7.5,  0.909090936
  58234,   -25.454546,          7.5,  0.909090936
  58235,   -26.363636,          7.5,  0.909090936
  58236,   -27.272728,          7.5,  0.909090936
  58237,   -28.181818,          7.5,  0.909090936
  58238,    -29.09091,          7.5,  0.909090936
  58239,    -20.90909,          7.5,   1.81818187
  58240,   -21.818182,          7.5,   1.81818187
  58241,   -22.727272,          7.5,   1.81818187
  58242,   -23.636364,          7.5,   1.81818187
  58243,   -24.545454,          7.5,   1.81818187
  58244,   -25.454546,          7.5,   1.81818187
  58245,   -26.363636,          7.5,   1.81818187
  58246,   -27.272728,          7.5,   1.81818187
  58247,   -28.181818,          7.5,   1.81818187
  58248,    -29.09091,          7.5,   1.81818187
  58249,    -20.90909,          7.5,   2.72727275
  58250,   -21.818182,          7.5,   2.72727275
  58251,   -22.727272,          7.5,   2.72727275
  58252,   -23.636364,          7.5,   2.72727275
  58253,   -24.545454,          7.5,   2.72727275
  58254,   -25.454546,          7.5,   2.72727275
  58255,   -26.363636,          7.5,   2.72727275
  58256,   -27.272728,          7.5,   2.72727275
  58257,   -28.181818,          7.5,   2.72727275
  58258,    -29.09091,          7.5,   2.72727275
  58259,    -20.90909,          7.5,   3.63636374
  58260,   -21.818182,          7.5,   3.63636374
  58261,   -22.727272,          7.5,   3.63636374
  58262,   -23.636364,          7.5,   3.63636374
  58263,   -24.545454,          7.5,   3.63636374
  58264,   -25.454546,          7.5,   3.63636374
  58265,   -26.363636,          7.5,   3.63636374
  58266,   -27.272728,          7.5,   3.63636374
  58267,   -28.181818,          7.5,   3.63636374
  58268,    -29.09091,          7.5,   3.63636374
  58269,    -20.90909,          7.5,    4.5454545
  58270,   -21.818182,          7.5,    4.5454545
  58271,   -22.727272,          7.5,    4.5454545
  58272,   -23.636364,          7.5,    4.5454545
  58273,   -24.545454,          7.5,    4.5454545
  58274,   -25.454546,          7.5,    4.5454545
  58275,   -26.363636,          7.5,    4.5454545
  58276,   -27.272728,          7.5,    4.5454545
  58277,   -28.181818,          7.5,    4.5454545
  58278,    -29.09091,          7.5,    4.5454545
  58279,    -20.90909,          7.5,    5.4545455
  58280,   -21.818182,          7.5,    5.4545455
  58281,   -22.727272,          7.5,    5.4545455
  58282,   -23.636364,          7.5,    5.4545455
  58283,   -24.545454,          7.5,    5.4545455
  58284,   -25.454546,          7.5,    5.4545455
  58285,   -26.363636,          7.5,    5.4545455
  58286,   -27.272728,          7.5,    5.4545455
  58287,   -28.181818,          7.5,    5.4545455
  58288,    -29.09091,          7.5,    5.4545455
  58289,    -20.90909,          7.5,   6.36363649
  58290,   -21.818182,          7.5,   6.36363649
  58291,   -22.727272,          7.5,   6.36363649
  58292,   -23.636364,          7.5,   6.36363649
  58293,   -24.545454,          7.5,   6.36363649
  58294,   -25.454546,          7.5,   6.36363649
  58295,   -26.363636,          7.5,   6.36363649
  58296,   -27.272728,          7.5,   6.36363649
  58297,   -28.181818,          7.5,   6.36363649
  58298,    -29.09091,          7.5,   6.36363649
  58299,    -20.90909,          7.5,   7.27272749
  58300,   -21.818182,          7.5,   7.27272749
  58301,   -22.727272,          7.5,   7.27272749
  58302,   -23.636364,          7.5,   7.27272749
  58303,   -24.545454,          7.5,   7.27272749
  58304,   -25.454546,          7.5,   7.27272749
  58305,   -26.363636,          7.5,   7.27272749
  58306,   -27.272728,          7.5,   7.27272749
  58307,   -28.181818,          7.5,   7.27272749
  58308,    -29.09091,          7.5,   7.27272749
  58309,    -20.90909,          7.5,   8.18181801
  58310,   -21.818182,          7.5,   8.18181801
  58311,   -22.727272,          7.5,   8.18181801
  58312,   -23.636364,          7.5,   8.18181801
  58313,   -24.545454,          7.5,   8.18181801
  58314,   -25.454546,          7.5,   8.18181801
  58315,   -26.363636,          7.5,   8.18181801
  58316,   -27.272728,          7.5,   8.18181801
  58317,   -28.181818,          7.5,   8.18181801
  58318,    -29.09091,          7.5,   8.18181801
  58319,    -20.90909,          7.5,     9.090909
  58320,   -21.818182,          7.5,     9.090909
  58321,   -22.727272,          7.5,     9.090909
  58322,   -23.636364,          7.5,     9.090909
  58323,   -24.545454,          7.5,     9.090909
  58324,   -25.454546,          7.5,     9.090909
  58325,   -26.363636,          7.5,     9.090909
  58326,   -27.272728,          7.5,     9.090909
  58327,   -28.181818,          7.5,     9.090909
  58328,    -29.09091,          7.5,     9.090909
  58329,    -20.90909,   6.66666651,  0.909090936
  58330,   -21.818182,   6.66666651,  0.909090936
  58331,   -22.727272,   6.66666651,  0.909090936
  58332,   -23.636364,   6.66666651,  0.909090936
  58333,   -24.545454,   6.66666651,  0.909090936
  58334,   -25.454546,   6.66666651,  0.909090936
  58335,   -26.363636,   6.66666651,  0.909090936
  58336,   -27.272728,   6.66666651,  0.909090936
  58337,   -28.181818,   6.66666651,  0.909090936
  58338,    -29.09091,   6.66666651,  0.909090936
  58339,    -20.90909,   6.66666651,   1.81818187
  58340,   -21.818182,   6.66666651,   1.81818187
  58341,   -22.727272,   6.66666651,   1.81818187
  58342,   -23.636364,   6.66666651,   1.81818187
  58343,   -24.545454,   6.66666651,   1.81818187
  58344,   -25.454546,   6.66666651,   1.81818187
  58345,   -26.363636,   6.66666651,   1.81818187
  58346,   -27.272728,   6.66666651,   1.81818187
  58347,   -28.181818,   6.66666651,   1.81818187
  58348,    -29.09091,   6.66666651,   1.81818187
  58349,    -20.90909,   6.66666651,   2.72727275
  58350,   -21.818182,   6.66666651,   2.72727275
  58351,   -22.727272,   6.66666651,   2.72727275
  58352,   -23.636364,   6.66666651,   2.72727275
  58353,   -24.545454,   6.66666651,   2.72727275
  58354,   -25.454546,   6.66666651,   2.72727275
  58355,   -26.363636,   6.66666651,   2.72727275
  58356,   -27.272728,   6.66666651,   2.72727275
  58357,   -28.181818,   6.66666651,   2.72727275
  58358,    -29.09091,   6.66666651,   2.72727275
  58359,    -20.90909,   6.66666651,   3.63636374
  58360,   -21.818182,   6.66666651,   3.63636374
  58361,   -22.727272,   6.66666651,   3.63636374
  58362,   -23.636364,   6.66666651,   3.63636374
  58363,   -24.545454,   6.66666651,   3.63636374
  58364,   -25.454546,   6.66666651,   3.63636374
  58365,   -26.363636,   6.66666651,   3.63636374
  58366,   -27.272728,   6.66666651,   3.63636374
  58367,   -28.181818,   6.66666651,   3.63636374
  58368,    -29.09091,   6.66666651,   3.63636374
  58369,    -20.90909,   6.66666651,    4.5454545
  58370,   -21.818182,   6.66666651,    4.5454545
  58371,   -22.727272,   6.66666651,    4.5454545
  58372,   -23.636364,   6.66666651,    4.5454545
  58373,   -24.545454,   6.66666651,    4.5454545
  58374,   -25.454546,   6.66666651,    4.5454545
  58375,   -26.363636,   6.66666651,    4.5454545
  58376,   -27.272728,   6.66666651,    4.5454545
  58377,   -28.181818,   6.66666651,    4.5454545
  58378,    -29.09091,   6.66666651,    4.5454545
  58379,    -20.90909,   6.66666651,    5.4545455
  58380,   -21.818182,   6.66666651,    5.4545455
  58381,   -22.727272,   6.66666651,    5.4545455
  58382,   -23.636364,   6.66666651,    5.4545455
  58383,   -24.545454,   6.66666651,    5.4545455
  58384,   -25.454546,   6.66666651,    5.4545455
  58385,   -26.363636,   6.66666651,    5.4545455
  58386,   -27.272728,   6.66666651,    5.4545455
  58387,   -28.181818,   6.66666651,    5.4545455
  58388,    -29.09091,   6.66666651,    5.4545455
  58389,    -20.90909,   6.66666651,   6.36363649
  58390,   -21.818182,   6.66666651,   6.36363649
  58391,   -22.727272,   6.66666651,   6.36363649
  58392,   -23.636364,   6.66666651,   6.36363649
  58393,   -24.545454,   6.66666651,   6.36363649
  58394,   -25.454546,   6.66666651,   6.36363649
  58395,   -26.363636,   6.66666651,   6.36363649
  58396,   -27.272728,   6.66666651,   6.36363649
  58397,   -28.181818,   6.66666651,   6.36363649
  58398,    -29.09091,   6.66666651,   6.36363649
  58399,    -20.90909,   6.66666651,   7.27272749
  58400,   -21.818182,   6.66666651,   7.27272749
  58401,   -22.727272,   6.66666651,   7.27272749
  58402,   -23.636364,   6.66666651,   7.27272749
  58403,   -24.545454,   6.66666651,   7.27272749
  58404,   -25.454546,   6.66666651,   7.27272749
  58405,   -26.363636,   6.66666651,   7.27272749
  58406,   -27.272728,   6.66666651,   7.27272749
  58407,   -28.181818,   6.66666651,   7.27272749
  58408,    -29.09091,   6.66666651,   7.27272749
  58409,    -20.90909,   6.66666651,   8.18181801
  58410,   -21.818182,   6.66666651,   8.18181801
  58411,   -22.727272,   6.66666651,   8.18181801
  58412,   -23.636364,   6.66666651,   8.18181801
  58413,   -24.545454,   6.66666651,   8.18181801
  58414,   -25.454546,   6.66666651,   8.18181801
  58415,   -26.363636,   6.66666651,   8.18181801
  58416,   -27.272728,   6.66666651,   8.18181801
  58417,   -28.181818,   6.66666651,   8.18181801
  58418,    -29.09091,   6.66666651,   8.18181801
  58419,    -20.90909,   6.66666651,     9.090909
  58420,   -21.818182,   6.66666651,     9.090909
  58421,   -22.727272,   6.66666651,     9.090909
  58422,   -23.636364,   6.66666651,     9.090909
  58423,   -24.545454,   6.66666651,     9.090909
  58424,   -25.454546,   6.66666651,     9.090909
  58425,   -26.363636,   6.66666651,     9.090909
  58426,   -27.272728,   6.66666651,     9.090909
  58427,   -28.181818,   6.66666651,     9.090909
  58428,    -29.09091,   6.66666651,     9.090909
  58429,    -20.90909,   5.83333349,  0.909090936
  58430,   -21.818182,   5.83333349,  0.909090936
  58431,   -22.727272,   5.83333349,  0.909090936
  58432,   -23.636364,   5.83333349,  0.909090936
  58433,   -24.545454,   5.83333349,  0.909090936
  58434,   -25.454546,   5.83333349,  0.909090936
  58435,   -26.363636,   5.83333349,  0.909090936
  58436,   -27.272728,   5.83333349,  0.909090936
  58437,   -28.181818,   5.83333349,  0.909090936
  58438,    -29.09091,   5.83333349,  0.909090936
  58439,    -20.90909,   5.83333349,   1.81818187
  58440,   -21.818182,   5.83333349,   1.81818187
  58441,   -22.727272,   5.83333349,   1.81818187
  58442,   -23.636364,   5.83333349,   1.81818187
  58443,   -24.545454,   5.83333349,   1.81818187
  58444,   -25.454546,   5.83333349,   1.81818187
  58445,   -26.363636,   5.83333349,   1.81818187
  58446,   -27.272728,   5.83333349,   1.81818187
  58447,   -28.181818,   5.83333349,   1.81818187
  58448,    -29.09091,   5.83333349,   1.81818187
  58449,    -20.90909,   5.83333349,   2.72727275
  58450,   -21.818182,   5.83333349,   2.72727275
  58451,   -22.727272,   5.83333349,   2.72727275
  58452,   -23.636364,   5.83333349,   2.72727275
  58453,   -24.545454,   5.83333349,   2.72727275
  58454,   -25.454546,   5.83333349,   2.72727275
  58455,   -26.363636,   5.83333349,   2.72727275
  58456,   -27.272728,   5.83333349,   2.72727275
  58457,   -28.181818,   5.83333349,   2.72727275
  58458,    -29.09091,   5.83333349,   2.72727275
  58459,    -20.90909,   5.83333349,   3.63636374
  58460,   -21.818182,   5.83333349,   3.63636374
  58461,   -22.727272,   5.83333349,   3.63636374
  58462,   -23.636364,   5.83333349,   3.63636374
  58463,   -24.545454,   5.83333349,   3.63636374
  58464,   -25.454546,   5.83333349,   3.63636374
  58465,   -26.363636,   5.83333349,   3.63636374
  58466,   -27.272728,   5.83333349,   3.63636374
  58467,   -28.181818,   5.83333349,   3.63636374
  58468,    -29.09091,   5.83333349,   3.63636374
  58469,    -20.90909,   5.83333349,    4.5454545
  58470,   -21.818182,   5.83333349,    4.5454545
  58471,   -22.727272,   5.83333349,    4.5454545
  58472,   -23.636364,   5.83333349,    4.5454545
  58473,   -24.545454,   5.83333349,    4.5454545
  58474,   -25.454546,   5.83333349,    4.5454545
  58475,   -26.363636,   5.83333349,    4.5454545
  58476,   -27.272728,   5.83333349,    4.5454545
  58477,   -28.181818,   5.83333349,    4.5454545
  58478,    -29.09091,   5.83333349,    4.5454545
  58479,    -20.90909,   5.83333349,    5.4545455
  58480,   -21.818182,   5.83333349,    5.4545455
  58481,   -22.727272,   5.83333349,    5.4545455
  58482,   -23.636364,   5.83333349,    5.4545455
  58483,   -24.545454,   5.83333349,    5.4545455
  58484,   -25.454546,   5.83333349,    5.4545455
  58485,   -26.363636,   5.83333349,    5.4545455
  58486,   -27.272728,   5.83333349,    5.4545455
  58487,   -28.181818,   5.83333349,    5.4545455
  58488,    -29.09091,   5.83333349,    5.4545455
  58489,    -20.90909,   5.83333349,   6.36363649
  58490,   -21.818182,   5.83333349,   6.36363649
  58491,   -22.727272,   5.83333349,   6.36363649
  58492,   -23.636364,   5.83333349,   6.36363649
  58493,   -24.545454,   5.83333349,   6.36363649
  58494,   -25.454546,   5.83333349,   6.36363649
  58495,   -26.363636,   5.83333349,   6.36363649
  58496,   -27.272728,   5.83333349,   6.36363649
  58497,   -28.181818,   5.83333349,   6.36363649
  58498,    -29.09091,   5.83333349,   6.36363649
  58499,    -20.90909,   5.83333349,   7.27272749
  58500,   -21.818182,   5.83333349,   7.27272749
  58501,   -22.727272,   5.83333349,   7.27272749
  58502,   -23.636364,   5.83333349,   7.27272749
  58503,   -24.545454,   5.83333349,   7.27272749
  58504,   -25.454546,   5.83333349,   7.27272749
  58505,   -26.363636,   5.83333349,   7.27272749
  58506,   -27.272728,   5.83333349,   7.27272749
  58507,   -28.181818,   5.83333349,   7.27272749
  58508,    -29.09091,   5.83333349,   7.27272749
  58509,    -20.90909,   5.83333349,   8.18181801
  58510,   -21.818182,   5.83333349,   8.18181801
  58511,   -22.727272,   5.83333349,   8.18181801
  58512,   -23.636364,   5.83333349,   8.18181801
  58513,   -24.545454,   5.83333349,   8.18181801
  58514,   -25.454546,   5.83333349,   8.18181801
  58515,   -26.363636,   5.83333349,   8.18181801
  58516,   -27.272728,   5.83333349,   8.18181801
  58517,   -28.181818,   5.83333349,   8.18181801
  58518,    -29.09091,   5.83333349,   8.18181801
  58519,    -20.90909,   5.83333349,     9.090909
  58520,   -21.818182,   5.83333349,     9.090909
  58521,   -22.727272,   5.83333349,     9.090909
  58522,   -23.636364,   5.83333349,     9.090909
  58523,   -24.545454,   5.83333349,     9.090909
  58524,   -25.454546,   5.83333349,     9.090909
  58525,   -26.363636,   5.83333349,     9.090909
  58526,   -27.272728,   5.83333349,     9.090909
  58527,   -28.181818,   5.83333349,     9.090909
  58528,    -29.09091,   5.83333349,     9.090909
  58529,    -20.90909,           5.,  0.909090936
  58530,   -21.818182,           5.,  0.909090936
  58531,   -22.727272,           5.,  0.909090936
  58532,   -23.636364,           5.,  0.909090936
  58533,   -24.545454,           5.,  0.909090936
  58534,   -25.454546,           5.,  0.909090936
  58535,   -26.363636,           5.,  0.909090936
  58536,   -27.272728,           5.,  0.909090936
  58537,   -28.181818,           5.,  0.909090936
  58538,    -29.09091,           5.,  0.909090936
  58539,    -20.90909,           5.,   1.81818187
  58540,   -21.818182,           5.,   1.81818187
  58541,   -22.727272,           5.,   1.81818187
  58542,   -23.636364,           5.,   1.81818187
  58543,   -24.545454,           5.,   1.81818187
  58544,   -25.454546,           5.,   1.81818187
  58545,   -26.363636,           5.,   1.81818187
  58546,   -27.272728,           5.,   1.81818187
  58547,   -28.181818,           5.,   1.81818187
  58548,    -29.09091,           5.,   1.81818187
  58549,    -20.90909,           5.,   2.72727275
  58550,   -21.818182,           5.,   2.72727275
  58551,   -22.727272,           5.,   2.72727275
  58552,   -23.636364,           5.,   2.72727275
  58553,   -24.545454,           5.,   2.72727275
  58554,   -25.454546,           5.,   2.72727275
  58555,   -26.363636,           5.,   2.72727275
  58556,   -27.272728,           5.,   2.72727275
  58557,   -28.181818,           5.,   2.72727275
  58558,    -29.09091,           5.,   2.72727275
  58559,    -20.90909,           5.,   3.63636374
  58560,   -21.818182,           5.,   3.63636374
  58561,   -22.727272,           5.,   3.63636374
  58562,   -23.636364,           5.,   3.63636374
  58563,   -24.545454,           5.,   3.63636374
  58564,   -25.454546,           5.,   3.63636374
  58565,   -26.363636,           5.,   3.63636374
  58566,   -27.272728,           5.,   3.63636374
  58567,   -28.181818,           5.,   3.63636374
  58568,    -29.09091,           5.,   3.63636374
  58569,    -20.90909,           5.,    4.5454545
  58570,   -21.818182,           5.,    4.5454545
  58571,   -22.727272,           5.,    4.5454545
  58572,   -23.636364,           5.,    4.5454545
  58573,   -24.545454,           5.,    4.5454545
  58574,   -25.454546,           5.,    4.5454545
  58575,   -26.363636,           5.,    4.5454545
  58576,   -27.272728,           5.,    4.5454545
  58577,   -28.181818,           5.,    4.5454545
  58578,    -29.09091,           5.,    4.5454545
  58579,    -20.90909,           5.,    5.4545455
  58580,   -21.818182,           5.,    5.4545455
  58581,   -22.727272,           5.,    5.4545455
  58582,   -23.636364,           5.,    5.4545455
  58583,   -24.545454,           5.,    5.4545455
  58584,   -25.454546,           5.,    5.4545455
  58585,   -26.363636,           5.,    5.4545455
  58586,   -27.272728,           5.,    5.4545455
  58587,   -28.181818,           5.,    5.4545455
  58588,    -29.09091,           5.,    5.4545455
  58589,    -20.90909,           5.,   6.36363649
  58590,   -21.818182,           5.,   6.36363649
  58591,   -22.727272,           5.,   6.36363649
  58592,   -23.636364,           5.,   6.36363649
  58593,   -24.545454,           5.,   6.36363649
  58594,   -25.454546,           5.,   6.36363649
  58595,   -26.363636,           5.,   6.36363649
  58596,   -27.272728,           5.,   6.36363649
  58597,   -28.181818,           5.,   6.36363649
  58598,    -29.09091,           5.,   6.36363649
  58599,    -20.90909,           5.,   7.27272749
  58600,   -21.818182,           5.,   7.27272749
  58601,   -22.727272,           5.,   7.27272749
  58602,   -23.636364,           5.,   7.27272749
  58603,   -24.545454,           5.,   7.27272749
  58604,   -25.454546,           5.,   7.27272749
  58605,   -26.363636,           5.,   7.27272749
  58606,   -27.272728,           5.,   7.27272749
  58607,   -28.181818,           5.,   7.27272749
  58608,    -29.09091,           5.,   7.27272749
  58609,    -20.90909,           5.,   8.18181801
  58610,   -21.818182,           5.,   8.18181801
  58611,   -22.727272,           5.,   8.18181801
  58612,   -23.636364,           5.,   8.18181801
  58613,   -24.545454,           5.,   8.18181801
  58614,   -25.454546,           5.,   8.18181801
  58615,   -26.363636,           5.,   8.18181801
  58616,   -27.272728,           5.,   8.18181801
  58617,   -28.181818,           5.,   8.18181801
  58618,    -29.09091,           5.,   8.18181801
  58619,    -20.90909,           5.,     9.090909
  58620,   -21.818182,           5.,     9.090909
  58621,   -22.727272,           5.,     9.090909
  58622,   -23.636364,           5.,     9.090909
  58623,   -24.545454,           5.,     9.090909
  58624,   -25.454546,           5.,     9.090909
  58625,   -26.363636,           5.,     9.090909
  58626,   -27.272728,           5.,     9.090909
  58627,   -28.181818,           5.,     9.090909
  58628,    -29.09091,           5.,     9.090909
  58629,    -20.90909,   4.16666651,  0.909090936
  58630,   -21.818182,   4.16666651,  0.909090936
  58631,   -22.727272,   4.16666651,  0.909090936
  58632,   -23.636364,   4.16666651,  0.909090936
  58633,   -24.545454,   4.16666651,  0.909090936
  58634,   -25.454546,   4.16666651,  0.909090936
  58635,   -26.363636,   4.16666651,  0.909090936
  58636,   -27.272728,   4.16666651,  0.909090936
  58637,   -28.181818,   4.16666651,  0.909090936
  58638,    -29.09091,   4.16666651,  0.909090936
  58639,    -20.90909,   4.16666651,   1.81818187
  58640,   -21.818182,   4.16666651,   1.81818187
  58641,   -22.727272,   4.16666651,   1.81818187
  58642,   -23.636364,   4.16666651,   1.81818187
  58643,   -24.545454,   4.16666651,   1.81818187
  58644,   -25.454546,   4.16666651,   1.81818187
  58645,   -26.363636,   4.16666651,   1.81818187
  58646,   -27.272728,   4.16666651,   1.81818187
  58647,   -28.181818,   4.16666651,   1.81818187
  58648,    -29.09091,   4.16666651,   1.81818187
  58649,    -20.90909,   4.16666651,   2.72727275
  58650,   -21.818182,   4.16666651,   2.72727275
  58651,   -22.727272,   4.16666651,   2.72727275
  58652,   -23.636364,   4.16666651,   2.72727275
  58653,   -24.545454,   4.16666651,   2.72727275
  58654,   -25.454546,   4.16666651,   2.72727275
  58655,   -26.363636,   4.16666651,   2.72727275
  58656,   -27.272728,   4.16666651,   2.72727275
  58657,   -28.181818,   4.16666651,   2.72727275
  58658,    -29.09091,   4.16666651,   2.72727275
  58659,    -20.90909,   4.16666651,   3.63636374
  58660,   -21.818182,   4.16666651,   3.63636374
  58661,   -22.727272,   4.16666651,   3.63636374
  58662,   -23.636364,   4.16666651,   3.63636374
  58663,   -24.545454,   4.16666651,   3.63636374
  58664,   -25.454546,   4.16666651,   3.63636374
  58665,   -26.363636,   4.16666651,   3.63636374
  58666,   -27.272728,   4.16666651,   3.63636374
  58667,   -28.181818,   4.16666651,   3.63636374
  58668,    -29.09091,   4.16666651,   3.63636374
  58669,    -20.90909,   4.16666651,    4.5454545
  58670,   -21.818182,   4.16666651,    4.5454545
  58671,   -22.727272,   4.16666651,    4.5454545
  58672,   -23.636364,   4.16666651,    4.5454545
  58673,   -24.545454,   4.16666651,    4.5454545
  58674,   -25.454546,   4.16666651,    4.5454545
  58675,   -26.363636,   4.16666651,    4.5454545
  58676,   -27.272728,   4.16666651,    4.5454545
  58677,   -28.181818,   4.16666651,    4.5454545
  58678,    -29.09091,   4.16666651,    4.5454545
  58679,    -20.90909,   4.16666651,    5.4545455
  58680,   -21.818182,   4.16666651,    5.4545455
  58681,   -22.727272,   4.16666651,    5.4545455
  58682,   -23.636364,   4.16666651,    5.4545455
  58683,   -24.545454,   4.16666651,    5.4545455
  58684,   -25.454546,   4.16666651,    5.4545455
  58685,   -26.363636,   4.16666651,    5.4545455
  58686,   -27.272728,   4.16666651,    5.4545455
  58687,   -28.181818,   4.16666651,    5.4545455
  58688,    -29.09091,   4.16666651,    5.4545455
  58689,    -20.90909,   4.16666651,   6.36363649
  58690,   -21.818182,   4.16666651,   6.36363649
  58691,   -22.727272,   4.16666651,   6.36363649
  58692,   -23.636364,   4.16666651,   6.36363649
  58693,   -24.545454,   4.16666651,   6.36363649
  58694,   -25.454546,   4.16666651,   6.36363649
  58695,   -26.363636,   4.16666651,   6.36363649
  58696,   -27.272728,   4.16666651,   6.36363649
  58697,   -28.181818,   4.16666651,   6.36363649
  58698,    -29.09091,   4.16666651,   6.36363649
  58699,    -20.90909,   4.16666651,   7.27272749
  58700,   -21.818182,   4.16666651,   7.27272749
  58701,   -22.727272,   4.16666651,   7.27272749
  58702,   -23.636364,   4.16666651,   7.27272749
  58703,   -24.545454,   4.16666651,   7.27272749
  58704,   -25.454546,   4.16666651,   7.27272749
  58705,   -26.363636,   4.16666651,   7.27272749
  58706,   -27.272728,   4.16666651,   7.27272749
  58707,   -28.181818,   4.16666651,   7.27272749
  58708,    -29.09091,   4.16666651,   7.27272749
  58709,    -20.90909,   4.16666651,   8.18181801
  58710,   -21.818182,   4.16666651,   8.18181801
  58711,   -22.727272,   4.16666651,   8.18181801
  58712,   -23.636364,   4.16666651,   8.18181801
  58713,   -24.545454,   4.16666651,   8.18181801
  58714,   -25.454546,   4.16666651,   8.18181801
  58715,   -26.363636,   4.16666651,   8.18181801
  58716,   -27.272728,   4.16666651,   8.18181801
  58717,   -28.181818,   4.16666651,   8.18181801
  58718,    -29.09091,   4.16666651,   8.18181801
  58719,    -20.90909,   4.16666651,     9.090909
  58720,   -21.818182,   4.16666651,     9.090909
  58721,   -22.727272,   4.16666651,     9.090909
  58722,   -23.636364,   4.16666651,     9.090909
  58723,   -24.545454,   4.16666651,     9.090909
  58724,   -25.454546,   4.16666651,     9.090909
  58725,   -26.363636,   4.16666651,     9.090909
  58726,   -27.272728,   4.16666651,     9.090909
  58727,   -28.181818,   4.16666651,     9.090909
  58728,    -29.09091,   4.16666651,     9.090909
  58729,    -20.90909,   3.33333325,  0.909090936
  58730,   -21.818182,   3.33333325,  0.909090936
  58731,   -22.727272,   3.33333325,  0.909090936
  58732,   -23.636364,   3.33333325,  0.909090936
  58733,   -24.545454,   3.33333325,  0.909090936
  58734,   -25.454546,   3.33333325,  0.909090936
  58735,   -26.363636,   3.33333325,  0.909090936
  58736,   -27.272728,   3.33333325,  0.909090936
  58737,   -28.181818,   3.33333325,  0.909090936
  58738,    -29.09091,   3.33333325,  0.909090936
  58739,    -20.90909,   3.33333325,   1.81818187
  58740,   -21.818182,   3.33333325,   1.81818187
  58741,   -22.727272,   3.33333325,   1.81818187
  58742,   -23.636364,   3.33333325,   1.81818187
  58743,   -24.545454,   3.33333325,   1.81818187
  58744,   -25.454546,   3.33333325,   1.81818187
  58745,   -26.363636,   3.33333325,   1.81818187
  58746,   -27.272728,   3.33333325,   1.81818187
  58747,   -28.181818,   3.33333325,   1.81818187
  58748,    -29.09091,   3.33333325,   1.81818187
  58749,    -20.90909,   3.33333325,   2.72727275
  58750,   -21.818182,   3.33333325,   2.72727275
  58751,   -22.727272,   3.33333325,   2.72727275
  58752,   -23.636364,   3.33333325,   2.72727275
  58753,   -24.545454,   3.33333325,   2.72727275
  58754,   -25.454546,   3.33333325,   2.72727275
  58755,   -26.363636,   3.33333325,   2.72727275
  58756,   -27.272728,   3.33333325,   2.72727275
  58757,   -28.181818,   3.33333325,   2.72727275
  58758,    -29.09091,   3.33333325,   2.72727275
  58759,    -20.90909,   3.33333325,   3.63636374
  58760,   -21.818182,   3.33333325,   3.63636374
  58761,   -22.727272,   3.33333325,   3.63636374
  58762,   -23.636364,   3.33333325,   3.63636374
  58763,   -24.545454,   3.33333325,   3.63636374
  58764,   -25.454546,   3.33333325,   3.63636374
  58765,   -26.363636,   3.33333325,   3.63636374
  58766,   -27.272728,   3.33333325,   3.63636374
  58767,   -28.181818,   3.33333325,   3.63636374
  58768,    -29.09091,   3.33333325,   3.63636374
  58769,    -20.90909,   3.33333325,    4.5454545
  58770,   -21.818182,   3.33333325,    4.5454545
  58771,   -22.727272,   3.33333325,    4.5454545
  58772,   -23.636364,   3.33333325,    4.5454545
  58773,   -24.545454,   3.33333325,    4.5454545
  58774,   -25.454546,   3.33333325,    4.5454545
  58775,   -26.363636,   3.33333325,    4.5454545
  58776,   -27.272728,   3.33333325,    4.5454545
  58777,   -28.181818,   3.33333325,    4.5454545
  58778,    -29.09091,   3.33333325,    4.5454545
  58779,    -20.90909,   3.33333325,    5.4545455
  58780,   -21.818182,   3.33333325,    5.4545455
  58781,   -22.727272,   3.33333325,    5.4545455
  58782,   -23.636364,   3.33333325,    5.4545455
  58783,   -24.545454,   3.33333325,    5.4545455
  58784,   -25.454546,   3.33333325,    5.4545455
  58785,   -26.363636,   3.33333325,    5.4545455
  58786,   -27.272728,   3.33333325,    5.4545455
  58787,   -28.181818,   3.33333325,    5.4545455
  58788,    -29.09091,   3.33333325,    5.4545455
  58789,    -20.90909,   3.33333325,   6.36363649
  58790,   -21.818182,   3.33333325,   6.36363649
  58791,   -22.727272,   3.33333325,   6.36363649
  58792,   -23.636364,   3.33333325,   6.36363649
  58793,   -24.545454,   3.33333325,   6.36363649
  58794,   -25.454546,   3.33333325,   6.36363649
  58795,   -26.363636,   3.33333325,   6.36363649
  58796,   -27.272728,   3.33333325,   6.36363649
  58797,   -28.181818,   3.33333325,   6.36363649
  58798,    -29.09091,   3.33333325,   6.36363649
  58799,    -20.90909,   3.33333325,   7.27272749
  58800,   -21.818182,   3.33333325,   7.27272749
  58801,   -22.727272,   3.33333325,   7.27272749
  58802,   -23.636364,   3.33333325,   7.27272749
  58803,   -24.545454,   3.33333325,   7.27272749
  58804,   -25.454546,   3.33333325,   7.27272749
  58805,   -26.363636,   3.33333325,   7.27272749
  58806,   -27.272728,   3.33333325,   7.27272749
  58807,   -28.181818,   3.33333325,   7.27272749
  58808,    -29.09091,   3.33333325,   7.27272749
  58809,    -20.90909,   3.33333325,   8.18181801
  58810,   -21.818182,   3.33333325,   8.18181801
  58811,   -22.727272,   3.33333325,   8.18181801
  58812,   -23.636364,   3.33333325,   8.18181801
  58813,   -24.545454,   3.33333325,   8.18181801
  58814,   -25.454546,   3.33333325,   8.18181801
  58815,   -26.363636,   3.33333325,   8.18181801
  58816,   -27.272728,   3.33333325,   8.18181801
  58817,   -28.181818,   3.33333325,   8.18181801
  58818,    -29.09091,   3.33333325,   8.18181801
  58819,    -20.90909,   3.33333325,     9.090909
  58820,   -21.818182,   3.33333325,     9.090909
  58821,   -22.727272,   3.33333325,     9.090909
  58822,   -23.636364,   3.33333325,     9.090909
  58823,   -24.545454,   3.33333325,     9.090909
  58824,   -25.454546,   3.33333325,     9.090909
  58825,   -26.363636,   3.33333325,     9.090909
  58826,   -27.272728,   3.33333325,     9.090909
  58827,   -28.181818,   3.33333325,     9.090909
  58828,    -29.09091,   3.33333325,     9.090909
  58829,    -20.90909,          2.5,  0.909090936
  58830,   -21.818182,          2.5,  0.909090936
  58831,   -22.727272,          2.5,  0.909090936
  58832,   -23.636364,          2.5,  0.909090936
  58833,   -24.545454,          2.5,  0.909090936
  58834,   -25.454546,          2.5,  0.909090936
  58835,   -26.363636,          2.5,  0.909090936
  58836,   -27.272728,          2.5,  0.909090936
  58837,   -28.181818,          2.5,  0.909090936
  58838,    -29.09091,          2.5,  0.909090936
  58839,    -20.90909,          2.5,   1.81818187
  58840,   -21.818182,          2.5,   1.81818187
  58841,   -22.727272,          2.5,   1.81818187
  58842,   -23.636364,          2.5,   1.81818187
  58843,   -24.545454,          2.5,   1.81818187
  58844,   -25.454546,          2.5,   1.81818187
  58845,   -26.363636,          2.5,   1.81818187
  58846,   -27.272728,          2.5,   1.81818187
  58847,   -28.181818,          2.5,   1.81818187
  58848,    -29.09091,          2.5,   1.81818187
  58849,    -20.90909,          2.5,   2.72727275
  58850,   -21.818182,          2.5,   2.72727275
  58851,   -22.727272,          2.5,   2.72727275
  58852,   -23.636364,          2.5,   2.72727275
  58853,   -24.545454,          2.5,   2.72727275
  58854,   -25.454546,          2.5,   2.72727275
  58855,   -26.363636,          2.5,   2.72727275
  58856,   -27.272728,          2.5,   2.72727275
  58857,   -28.181818,          2.5,   2.72727275
  58858,    -29.09091,          2.5,   2.72727275
  58859,    -20.90909,          2.5,   3.63636374
  58860,   -21.818182,          2.5,   3.63636374
  58861,   -22.727272,          2.5,   3.63636374
  58862,   -23.636364,          2.5,   3.63636374
  58863,   -24.545454,          2.5,   3.63636374
  58864,   -25.454546,          2.5,   3.63636374
  58865,   -26.363636,          2.5,   3.63636374
  58866,   -27.272728,          2.5,   3.63636374
  58867,   -28.181818,          2.5,   3.63636374
  58868,    -29.09091,          2.5,   3.63636374
  58869,    -20.90909,          2.5,    4.5454545
  58870,   -21.818182,          2.5,    4.5454545
  58871,   -22.727272,          2.5,    4.5454545
  58872,   -23.636364,          2.5,    4.5454545
  58873,   -24.545454,          2.5,    4.5454545
  58874,   -25.454546,          2.5,    4.5454545
  58875,   -26.363636,          2.5,    4.5454545
  58876,   -27.272728,          2.5,    4.5454545
  58877,   -28.181818,          2.5,    4.5454545
  58878,    -29.09091,          2.5,    4.5454545
  58879,    -20.90909,          2.5,    5.4545455
  58880,   -21.818182,          2.5,    5.4545455
  58881,   -22.727272,          2.5,    5.4545455
  58882,   -23.636364,          2.5,    5.4545455
  58883,   -24.545454,          2.5,    5.4545455
  58884,   -25.454546,          2.5,    5.4545455
  58885,   -26.363636,          2.5,    5.4545455
  58886,   -27.272728,          2.5,    5.4545455
  58887,   -28.181818,          2.5,    5.4545455
  58888,    -29.09091,          2.5,    5.4545455
  58889,    -20.90909,          2.5,   6.36363649
  58890,   -21.818182,          2.5,   6.36363649
  58891,   -22.727272,          2.5,   6.36363649
  58892,   -23.636364,          2.5,   6.36363649
  58893,   -24.545454,          2.5,   6.36363649
  58894,   -25.454546,          2.5,   6.36363649
  58895,   -26.363636,          2.5,   6.36363649
  58896,   -27.272728,          2.5,   6.36363649
  58897,   -28.181818,          2.5,   6.36363649
  58898,    -29.09091,          2.5,   6.36363649
  58899,    -20.90909,          2.5,   7.27272749
  58900,   -21.818182,          2.5,   7.27272749
  58901,   -22.727272,          2.5,   7.27272749
  58902,   -23.636364,          2.5,   7.27272749
  58903,   -24.545454,          2.5,   7.27272749
  58904,   -25.454546,          2.5,   7.27272749
  58905,   -26.363636,          2.5,   7.27272749
  58906,   -27.272728,          2.5,   7.27272749
  58907,   -28.181818,          2.5,   7.27272749
  58908,    -29.09091,          2.5,   7.27272749
  58909,    -20.90909,          2.5,   8.18181801
  58910,   -21.818182,          2.5,   8.18181801
  58911,   -22.727272,          2.5,   8.18181801
  58912,   -23.636364,          2.5,   8.18181801
  58913,   -24.545454,          2.5,   8.18181801
  58914,   -25.454546,          2.5,   8.18181801
  58915,   -26.363636,          2.5,   8.18181801
  58916,   -27.272728,          2.5,   8.18181801
  58917,   -28.181818,          2.5,   8.18181801
  58918,    -29.09091,          2.5,   8.18181801
  58919,    -20.90909,          2.5,     9.090909
  58920,   -21.818182,          2.5,     9.090909
  58921,   -22.727272,          2.5,     9.090909
  58922,   -23.636364,          2.5,     9.090909
  58923,   -24.545454,          2.5,     9.090909
  58924,   -25.454546,          2.5,     9.090909
  58925,   -26.363636,          2.5,     9.090909
  58926,   -27.272728,          2.5,     9.090909
  58927,   -28.181818,          2.5,     9.090909
  58928,    -29.09091,          2.5,     9.090909
  58929,    -20.90909,   1.66666663,  0.909090936
  58930,   -21.818182,   1.66666663,  0.909090936
  58931,   -22.727272,   1.66666663,  0.909090936
  58932,   -23.636364,   1.66666663,  0.909090936
  58933,   -24.545454,   1.66666663,  0.909090936
  58934,   -25.454546,   1.66666663,  0.909090936
  58935,   -26.363636,   1.66666663,  0.909090936
  58936,   -27.272728,   1.66666663,  0.909090936
  58937,   -28.181818,   1.66666663,  0.909090936
  58938,    -29.09091,   1.66666663,  0.909090936
  58939,    -20.90909,   1.66666663,   1.81818187
  58940,   -21.818182,   1.66666663,   1.81818187
  58941,   -22.727272,   1.66666663,   1.81818187
  58942,   -23.636364,   1.66666663,   1.81818187
  58943,   -24.545454,   1.66666663,   1.81818187
  58944,   -25.454546,   1.66666663,   1.81818187
  58945,   -26.363636,   1.66666663,   1.81818187
  58946,   -27.272728,   1.66666663,   1.81818187
  58947,   -28.181818,   1.66666663,   1.81818187
  58948,    -29.09091,   1.66666663,   1.81818187
  58949,    -20.90909,   1.66666663,   2.72727275
  58950,   -21.818182,   1.66666663,   2.72727275
  58951,   -22.727272,   1.66666663,   2.72727275
  58952,   -23.636364,   1.66666663,   2.72727275
  58953,   -24.545454,   1.66666663,   2.72727275
  58954,   -25.454546,   1.66666663,   2.72727275
  58955,   -26.363636,   1.66666663,   2.72727275
  58956,   -27.272728,   1.66666663,   2.72727275
  58957,   -28.181818,   1.66666663,   2.72727275
  58958,    -29.09091,   1.66666663,   2.72727275
  58959,    -20.90909,   1.66666663,   3.63636374
  58960,   -21.818182,   1.66666663,   3.63636374
  58961,   -22.727272,   1.66666663,   3.63636374
  58962,   -23.636364,   1.66666663,   3.63636374
  58963,   -24.545454,   1.66666663,   3.63636374
  58964,   -25.454546,   1.66666663,   3.63636374
  58965,   -26.363636,   1.66666663,   3.63636374
  58966,   -27.272728,   1.66666663,   3.63636374
  58967,   -28.181818,   1.66666663,   3.63636374
  58968,    -29.09091,   1.66666663,   3.63636374
  58969,    -20.90909,   1.66666663,    4.5454545
  58970,   -21.818182,   1.66666663,    4.5454545
  58971,   -22.727272,   1.66666663,    4.5454545
  58972,   -23.636364,   1.66666663,    4.5454545
  58973,   -24.545454,   1.66666663,    4.5454545
  58974,   -25.454546,   1.66666663,    4.5454545
  58975,   -26.363636,   1.66666663,    4.5454545
  58976,   -27.272728,   1.66666663,    4.5454545
  58977,   -28.181818,   1.66666663,    4.5454545
  58978,    -29.09091,   1.66666663,    4.5454545
  58979,    -20.90909,   1.66666663,    5.4545455
  58980,   -21.818182,   1.66666663,    5.4545455
  58981,   -22.727272,   1.66666663,    5.4545455
  58982,   -23.636364,   1.66666663,    5.4545455
  58983,   -24.545454,   1.66666663,    5.4545455
  58984,   -25.454546,   1.66666663,    5.4545455
  58985,   -26.363636,   1.66666663,    5.4545455
  58986,   -27.272728,   1.66666663,    5.4545455
  58987,   -28.181818,   1.66666663,    5.4545455
  58988,    -29.09091,   1.66666663,    5.4545455
  58989,    -20.90909,   1.66666663,   6.36363649
  58990,   -21.818182,   1.66666663,   6.36363649
  58991,   -22.727272,   1.66666663,   6.36363649
  58992,   -23.636364,   1.66666663,   6.36363649
  58993,   -24.545454,   1.66666663,   6.36363649
  58994,   -25.454546,   1.66666663,   6.36363649
  58995,   -26.363636,   1.66666663,   6.36363649
  58996,   -27.272728,   1.66666663,   6.36363649
  58997,   -28.181818,   1.66666663,   6.36363649
  58998,    -29.09091,   1.66666663,   6.36363649
  58999,    -20.90909,   1.66666663,   7.27272749
  59000,   -21.818182,   1.66666663,   7.27272749
  59001,   -22.727272,   1.66666663,   7.27272749
  59002,   -23.636364,   1.66666663,   7.27272749
  59003,   -24.545454,   1.66666663,   7.27272749
  59004,   -25.454546,   1.66666663,   7.27272749
  59005,   -26.363636,   1.66666663,   7.27272749
  59006,   -27.272728,   1.66666663,   7.27272749
  59007,   -28.181818,   1.66666663,   7.27272749
  59008,    -29.09091,   1.66666663,   7.27272749
  59009,    -20.90909,   1.66666663,   8.18181801
  59010,   -21.818182,   1.66666663,   8.18181801
  59011,   -22.727272,   1.66666663,   8.18181801
  59012,   -23.636364,   1.66666663,   8.18181801
  59013,   -24.545454,   1.66666663,   8.18181801
  59014,   -25.454546,   1.66666663,   8.18181801
  59015,   -26.363636,   1.66666663,   8.18181801
  59016,   -27.272728,   1.66666663,   8.18181801
  59017,   -28.181818,   1.66666663,   8.18181801
  59018,    -29.09091,   1.66666663,   8.18181801
  59019,    -20.90909,   1.66666663,     9.090909
  59020,   -21.818182,   1.66666663,     9.090909
  59021,   -22.727272,   1.66666663,     9.090909
  59022,   -23.636364,   1.66666663,     9.090909
  59023,   -24.545454,   1.66666663,     9.090909
  59024,   -25.454546,   1.66666663,     9.090909
  59025,   -26.363636,   1.66666663,     9.090909
  59026,   -27.272728,   1.66666663,     9.090909
  59027,   -28.181818,   1.66666663,     9.090909
  59028,    -29.09091,   1.66666663,     9.090909
  59029,    -20.90909,  0.833333313,  0.909090936
  59030,   -21.818182,  0.833333313,  0.909090936
  59031,   -22.727272,  0.833333313,  0.909090936
  59032,   -23.636364,  0.833333313,  0.909090936
  59033,   -24.545454,  0.833333313,  0.909090936
  59034,   -25.454546,  0.833333313,  0.909090936
  59035,   -26.363636,  0.833333313,  0.909090936
  59036,   -27.272728,  0.833333313,  0.909090936
  59037,   -28.181818,  0.833333313,  0.909090936
  59038,    -29.09091,  0.833333313,  0.909090936
  59039,    -20.90909,  0.833333313,   1.81818187
  59040,   -21.818182,  0.833333313,   1.81818187
  59041,   -22.727272,  0.833333313,   1.81818187
  59042,   -23.636364,  0.833333313,   1.81818187
  59043,   -24.545454,  0.833333313,   1.81818187
  59044,   -25.454546,  0.833333313,   1.81818187
  59045,   -26.363636,  0.833333313,   1.81818187
  59046,   -27.272728,  0.833333313,   1.81818187
  59047,   -28.181818,  0.833333313,   1.81818187
  59048,    -29.09091,  0.833333313,   1.81818187
  59049,    -20.90909,  0.833333313,   2.72727275
  59050,   -21.818182,  0.833333313,   2.72727275
  59051,   -22.727272,  0.833333313,   2.72727275
  59052,   -23.636364,  0.833333313,   2.72727275
  59053,   -24.545454,  0.833333313,   2.72727275
  59054,   -25.454546,  0.833333313,   2.72727275
  59055,   -26.363636,  0.833333313,   2.72727275
  59056,   -27.272728,  0.833333313,   2.72727275
  59057,   -28.181818,  0.833333313,   2.72727275
  59058,    -29.09091,  0.833333313,   2.72727275
  59059,    -20.90909,  0.833333313,   3.63636374
  59060,   -21.818182,  0.833333313,   3.63636374
  59061,   -22.727272,  0.833333313,   3.63636374
  59062,   -23.636364,  0.833333313,   3.63636374
  59063,   -24.545454,  0.833333313,   3.63636374
  59064,   -25.454546,  0.833333313,   3.63636374
  59065,   -26.363636,  0.833333313,   3.63636374
  59066,   -27.272728,  0.833333313,   3.63636374
  59067,   -28.181818,  0.833333313,   3.63636374
  59068,    -29.09091,  0.833333313,   3.63636374
  59069,    -20.90909,  0.833333313,    4.5454545
  59070,   -21.818182,  0.833333313,    4.5454545
  59071,   -22.727272,  0.833333313,    4.5454545
  59072,   -23.636364,  0.833333313,    4.5454545
  59073,   -24.545454,  0.833333313,    4.5454545
  59074,   -25.454546,  0.833333313,    4.5454545
  59075,   -26.363636,  0.833333313,    4.5454545
  59076,   -27.272728,  0.833333313,    4.5454545
  59077,   -28.181818,  0.833333313,    4.5454545
  59078,    -29.09091,  0.833333313,    4.5454545
  59079,    -20.90909,  0.833333313,    5.4545455
  59080,   -21.818182,  0.833333313,    5.4545455
  59081,   -22.727272,  0.833333313,    5.4545455
  59082,   -23.636364,  0.833333313,    5.4545455
  59083,   -24.545454,  0.833333313,    5.4545455
  59084,   -25.454546,  0.833333313,    5.4545455
  59085,   -26.363636,  0.833333313,    5.4545455
  59086,   -27.272728,  0.833333313,    5.4545455
  59087,   -28.181818,  0.833333313,    5.4545455
  59088,    -29.09091,  0.833333313,    5.4545455
  59089,    -20.90909,  0.833333313,   6.36363649
  59090,   -21.818182,  0.833333313,   6.36363649
  59091,   -22.727272,  0.833333313,   6.36363649
  59092,   -23.636364,  0.833333313,   6.36363649
  59093,   -24.545454,  0.833333313,   6.36363649
  59094,   -25.454546,  0.833333313,   6.36363649
  59095,   -26.363636,  0.833333313,   6.36363649
  59096,   -27.272728,  0.833333313,   6.36363649
  59097,   -28.181818,  0.833333313,   6.36363649
  59098,    -29.09091,  0.833333313,   6.36363649
  59099,    -20.90909,  0.833333313,   7.27272749
  59100,   -21.818182,  0.833333313,   7.27272749
  59101,   -22.727272,  0.833333313,   7.27272749
  59102,   -23.636364,  0.833333313,   7.27272749
  59103,   -24.545454,  0.833333313,   7.27272749
  59104,   -25.454546,  0.833333313,   7.27272749
  59105,   -26.363636,  0.833333313,   7.27272749
  59106,   -27.272728,  0.833333313,   7.27272749
  59107,   -28.181818,  0.833333313,   7.27272749
  59108,    -29.09091,  0.833333313,   7.27272749
  59109,    -20.90909,  0.833333313,   8.18181801
  59110,   -21.818182,  0.833333313,   8.18181801
  59111,   -22.727272,  0.833333313,   8.18181801
  59112,   -23.636364,  0.833333313,   8.18181801
  59113,   -24.545454,  0.833333313,   8.18181801
  59114,   -25.454546,  0.833333313,   8.18181801
  59115,   -26.363636,  0.833333313,   8.18181801
  59116,   -27.272728,  0.833333313,   8.18181801
  59117,   -28.181818,  0.833333313,   8.18181801
  59118,    -29.09091,  0.833333313,   8.18181801
  59119,    -20.90909,  0.833333313,     9.090909
  59120,   -21.818182,  0.833333313,     9.090909
  59121,   -22.727272,  0.833333313,     9.090909
  59122,   -23.636364,  0.833333313,     9.090909
  59123,   -24.545454,  0.833333313,     9.090909
  59124,   -25.454546,  0.833333313,     9.090909
  59125,   -26.363636,  0.833333313,     9.090909
  59126,   -27.272728,  0.833333313,     9.090909
  59127,   -28.181818,  0.833333313,     9.090909
  59128,    -29.09091,  0.833333313,     9.090909
  59129,     29.09091,   9.16666698,  0.909090936
  59130,    28.181818,   9.16666698,  0.909090936
  59131,    27.272728,   9.16666698,  0.909090936
  59132,    26.363636,   9.16666698,  0.909090936
  59133,    25.454546,   9.16666698,  0.909090936
  59134,    24.545454,   9.16666698,  0.909090936
  59135,    23.636364,   9.16666698,  0.909090936
  59136,    22.727272,   9.16666698,  0.909090936
  59137,    21.818182,   9.16666698,  0.909090936
  59138,     20.90909,   9.16666698,  0.909090936
  59139,     29.09091,   9.16666698,   1.81818187
  59140,    28.181818,   9.16666698,   1.81818187
  59141,    27.272728,   9.16666698,   1.81818187
  59142,    26.363636,   9.16666698,   1.81818187
  59143,    25.454546,   9.16666698,   1.81818187
  59144,    24.545454,   9.16666698,   1.81818187
  59145,    23.636364,   9.16666698,   1.81818187
  59146,    22.727272,   9.16666698,   1.81818187
  59147,    21.818182,   9.16666698,   1.81818187
  59148,     20.90909,   9.16666698,   1.81818187
  59149,     29.09091,   9.16666698,   2.72727275
  59150,    28.181818,   9.16666698,   2.72727275
  59151,    27.272728,   9.16666698,   2.72727275
  59152,    26.363636,   9.16666698,   2.72727275
  59153,    25.454546,   9.16666698,   2.72727275
  59154,    24.545454,   9.16666698,   2.72727275
  59155,    23.636364,   9.16666698,   2.72727275
  59156,    22.727272,   9.16666698,   2.72727275
  59157,    21.818182,   9.16666698,   2.72727275
  59158,     20.90909,   9.16666698,   2.72727275
  59159,     29.09091,   9.16666698,   3.63636374
  59160,    28.181818,   9.16666698,   3.63636374
  59161,    27.272728,   9.16666698,   3.63636374
  59162,    26.363636,   9.16666698,   3.63636374
  59163,    25.454546,   9.16666698,   3.63636374
  59164,    24.545454,   9.16666698,   3.63636374
  59165,    23.636364,   9.16666698,   3.63636374
  59166,    22.727272,   9.16666698,   3.63636374
  59167,    21.818182,   9.16666698,   3.63636374
  59168,     20.90909,   9.16666698,   3.63636374
  59169,     29.09091,   9.16666698,    4.5454545
  59170,    28.181818,   9.16666698,    4.5454545
  59171,    27.272728,   9.16666698,    4.5454545
  59172,    26.363636,   9.16666698,    4.5454545
  59173,    25.454546,   9.16666698,    4.5454545
  59174,    24.545454,   9.16666698,    4.5454545
  59175,    23.636364,   9.16666698,    4.5454545
  59176,    22.727272,   9.16666698,    4.5454545
  59177,    21.818182,   9.16666698,    4.5454545
  59178,     20.90909,   9.16666698,    4.5454545
  59179,     29.09091,   9.16666698,    5.4545455
  59180,    28.181818,   9.16666698,    5.4545455
  59181,    27.272728,   9.16666698,    5.4545455
  59182,    26.363636,   9.16666698,    5.4545455
  59183,    25.454546,   9.16666698,    5.4545455
  59184,    24.545454,   9.16666698,    5.4545455
  59185,    23.636364,   9.16666698,    5.4545455
  59186,    22.727272,   9.16666698,    5.4545455
  59187,    21.818182,   9.16666698,    5.4545455
  59188,     20.90909,   9.16666698,    5.4545455
  59189,     29.09091,   9.16666698,   6.36363649
  59190,    28.181818,   9.16666698,   6.36363649
  59191,    27.272728,   9.16666698,   6.36363649
  59192,    26.363636,   9.16666698,   6.36363649
  59193,    25.454546,   9.16666698,   6.36363649
  59194,    24.545454,   9.16666698,   6.36363649
  59195,    23.636364,   9.16666698,   6.36363649
  59196,    22.727272,   9.16666698,   6.36363649
  59197,    21.818182,   9.16666698,   6.36363649
  59198,     20.90909,   9.16666698,   6.36363649
  59199,     29.09091,   9.16666698,   7.27272749
  59200,    28.181818,   9.16666698,   7.27272749
  59201,    27.272728,   9.16666698,   7.27272749
  59202,    26.363636,   9.16666698,   7.27272749
  59203,    25.454546,   9.16666698,   7.27272749
  59204,    24.545454,   9.16666698,   7.27272749
  59205,    23.636364,   9.16666698,   7.27272749
  59206,    22.727272,   9.16666698,   7.27272749
  59207,    21.818182,   9.16666698,   7.27272749
  59208,     20.90909,   9.16666698,   7.27272749
  59209,     29.09091,   9.16666698,   8.18181801
  59210,    28.181818,   9.16666698,   8.18181801
  59211,    27.272728,   9.16666698,   8.18181801
  59212,    26.363636,   9.16666698,   8.18181801
  59213,    25.454546,   9.16666698,   8.18181801
  59214,    24.545454,   9.16666698,   8.18181801
  59215,    23.636364,   9.16666698,   8.18181801
  59216,    22.727272,   9.16666698,   8.18181801
  59217,    21.818182,   9.16666698,   8.18181801
  59218,     20.90909,   9.16666698,   8.18181801
  59219,     29.09091,   9.16666698,     9.090909
  59220,    28.181818,   9.16666698,     9.090909
  59221,    27.272728,   9.16666698,     9.090909
  59222,    26.363636,   9.16666698,     9.090909
  59223,    25.454546,   9.16666698,     9.090909
  59224,    24.545454,   9.16666698,     9.090909
  59225,    23.636364,   9.16666698,     9.090909
  59226,    22.727272,   9.16666698,     9.090909
  59227,    21.818182,   9.16666698,     9.090909
  59228,     20.90909,   9.16666698,     9.090909
  59229,     29.09091,   8.33333302,  0.909090936
  59230,    28.181818,   8.33333302,  0.909090936
  59231,    27.272728,   8.33333302,  0.909090936
  59232,    26.363636,   8.33333302,  0.909090936
  59233,    25.454546,   8.33333302,  0.909090936
  59234,    24.545454,   8.33333302,  0.909090936
  59235,    23.636364,   8.33333302,  0.909090936
  59236,    22.727272,   8.33333302,  0.909090936
  59237,    21.818182,   8.33333302,  0.909090936
  59238,     20.90909,   8.33333302,  0.909090936
  59239,     29.09091,   8.33333302,   1.81818187
  59240,    28.181818,   8.33333302,   1.81818187
  59241,    27.272728,   8.33333302,   1.81818187
  59242,    26.363636,   8.33333302,   1.81818187
  59243,    25.454546,   8.33333302,   1.81818187
  59244,    24.545454,   8.33333302,   1.81818187
  59245,    23.636364,   8.33333302,   1.81818187
  59246,    22.727272,   8.33333302,   1.81818187
  59247,    21.818182,   8.33333302,   1.81818187
  59248,     20.90909,   8.33333302,   1.81818187
  59249,     29.09091,   8.33333302,   2.72727275
  59250,    28.181818,   8.33333302,   2.72727275
  59251,    27.272728,   8.33333302,   2.72727275
  59252,    26.363636,   8.33333302,   2.72727275
  59253,    25.454546,   8.33333302,   2.72727275
  59254,    24.545454,   8.33333302,   2.72727275
  59255,    23.636364,   8.33333302,   2.72727275
  59256,    22.727272,   8.33333302,   2.72727275
  59257,    21.818182,   8.33333302,   2.72727275
  59258,     20.90909,   8.33333302,   2.72727275
  59259,     29.09091,   8.33333302,   3.63636374
  59260,    28.181818,   8.33333302,   3.63636374
  59261,    27.272728,   8.33333302,   3.63636374
  59262,    26.363636,   8.33333302,   3.63636374
  59263,    25.454546,   8.33333302,   3.63636374
  59264,    24.545454,   8.33333302,   3.63636374
  59265,    23.636364,   8.33333302,   3.63636374
  59266,    22.727272,   8.33333302,   3.63636374
  59267,    21.818182,   8.33333302,   3.63636374
  59268,     20.90909,   8.33333302,   3.63636374
  59269,     29.09091,   8.33333302,    4.5454545
  59270,    28.181818,   8.33333302,    4.5454545
  59271,    27.272728,   8.33333302,    4.5454545
  59272,    26.363636,   8.33333302,    4.5454545
  59273,    25.454546,   8.33333302,    4.5454545
  59274,    24.545454,   8.33333302,    4.5454545
  59275,    23.636364,   8.33333302,    4.5454545
  59276,    22.727272,   8.33333302,    4.5454545
  59277,    21.818182,   8.33333302,    4.5454545
  59278,     20.90909,   8.33333302,    4.5454545
  59279,     29.09091,   8.33333302,    5.4545455
  59280,    28.181818,   8.33333302,    5.4545455
  59281,    27.272728,   8.33333302,    5.4545455
  59282,    26.363636,   8.33333302,    5.4545455
  59283,    25.454546,   8.33333302,    5.4545455
  59284,    24.545454,   8.33333302,    5.4545455
  59285,    23.636364,   8.33333302,    5.4545455
  59286,    22.727272,   8.33333302,    5.4545455
  59287,    21.818182,   8.33333302,    5.4545455
  59288,     20.90909,   8.33333302,    5.4545455
  59289,     29.09091,   8.33333302,   6.36363649
  59290,    28.181818,   8.33333302,   6.36363649
  59291,    27.272728,   8.33333302,   6.36363649
  59292,    26.363636,   8.33333302,   6.36363649
  59293,    25.454546,   8.33333302,   6.36363649
  59294,    24.545454,   8.33333302,   6.36363649
  59295,    23.636364,   8.33333302,   6.36363649
  59296,    22.727272,   8.33333302,   6.36363649
  59297,    21.818182,   8.33333302,   6.36363649
  59298,     20.90909,   8.33333302,   6.36363649
  59299,     29.09091,   8.33333302,   7.27272749
  59300,    28.181818,   8.33333302,   7.27272749
  59301,    27.272728,   8.33333302,   7.27272749
  59302,    26.363636,   8.33333302,   7.27272749
  59303,    25.454546,   8.33333302,   7.27272749
  59304,    24.545454,   8.33333302,   7.27272749
  59305,    23.636364,   8.33333302,   7.27272749
  59306,    22.727272,   8.33333302,   7.27272749
  59307,    21.818182,   8.33333302,   7.27272749
  59308,     20.90909,   8.33333302,   7.27272749
  59309,     29.09091,   8.33333302,   8.18181801
  59310,    28.181818,   8.33333302,   8.18181801
  59311,    27.272728,   8.33333302,   8.18181801
  59312,    26.363636,   8.33333302,   8.18181801
  59313,    25.454546,   8.33333302,   8.18181801
  59314,    24.545454,   8.33333302,   8.18181801
  59315,    23.636364,   8.33333302,   8.18181801
  59316,    22.727272,   8.33333302,   8.18181801
  59317,    21.818182,   8.33333302,   8.18181801
  59318,     20.90909,   8.33333302,   8.18181801
  59319,     29.09091,   8.33333302,     9.090909
  59320,    28.181818,   8.33333302,     9.090909
  59321,    27.272728,   8.33333302,     9.090909
  59322,    26.363636,   8.33333302,     9.090909
  59323,    25.454546,   8.33333302,     9.090909
  59324,    24.545454,   8.33333302,     9.090909
  59325,    23.636364,   8.33333302,     9.090909
  59326,    22.727272,   8.33333302,     9.090909
  59327,    21.818182,   8.33333302,     9.090909
  59328,     20.90909,   8.33333302,     9.090909
  59329,     29.09091,          7.5,  0.909090936
  59330,    28.181818,          7.5,  0.909090936
  59331,    27.272728,          7.5,  0.909090936
  59332,    26.363636,          7.5,  0.909090936
  59333,    25.454546,          7.5,  0.909090936
  59334,    24.545454,          7.5,  0.909090936
  59335,    23.636364,          7.5,  0.909090936
  59336,    22.727272,          7.5,  0.909090936
  59337,    21.818182,          7.5,  0.909090936
  59338,     20.90909,          7.5,  0.909090936
  59339,     29.09091,          7.5,   1.81818187
  59340,    28.181818,          7.5,   1.81818187
  59341,    27.272728,          7.5,   1.81818187
  59342,    26.363636,          7.5,   1.81818187
  59343,    25.454546,          7.5,   1.81818187
  59344,    24.545454,          7.5,   1.81818187
  59345,    23.636364,          7.5,   1.81818187
  59346,    22.727272,          7.5,   1.81818187
  59347,    21.818182,          7.5,   1.81818187
  59348,     20.90909,          7.5,   1.81818187
  59349,     29.09091,          7.5,   2.72727275
  59350,    28.181818,          7.5,   2.72727275
  59351,    27.272728,          7.5,   2.72727275
  59352,    26.363636,          7.5,   2.72727275
  59353,    25.454546,          7.5,   2.72727275
  59354,    24.545454,          7.5,   2.72727275
  59355,    23.636364,          7.5,   2.72727275
  59356,    22.727272,          7.5,   2.72727275
  59357,    21.818182,          7.5,   2.72727275
  59358,     20.90909,          7.5,   2.72727275
  59359,     29.09091,          7.5,   3.63636374
  59360,    28.181818,          7.5,   3.63636374
  59361,    27.272728,          7.5,   3.63636374
  59362,    26.363636,          7.5,   3.63636374
  59363,    25.454546,          7.5,   3.63636374
  59364,    24.545454,          7.5,   3.63636374
  59365,    23.636364,          7.5,   3.63636374
  59366,    22.727272,          7.5,   3.63636374
  59367,    21.818182,          7.5,   3.63636374
  59368,     20.90909,          7.5,   3.63636374
  59369,     29.09091,          7.5,    4.5454545
  59370,    28.181818,          7.5,    4.5454545
  59371,    27.272728,          7.5,    4.5454545
  59372,    26.363636,          7.5,    4.5454545
  59373,    25.454546,          7.5,    4.5454545
  59374,    24.545454,          7.5,    4.5454545
  59375,    23.636364,          7.5,    4.5454545
  59376,    22.727272,          7.5,    4.5454545
  59377,    21.818182,          7.5,    4.5454545
  59378,     20.90909,          7.5,    4.5454545
  59379,     29.09091,          7.5,    5.4545455
  59380,    28.181818,          7.5,    5.4545455
  59381,    27.272728,          7.5,    5.4545455
  59382,    26.363636,          7.5,    5.4545455
  59383,    25.454546,          7.5,    5.4545455
  59384,    24.545454,          7.5,    5.4545455
  59385,    23.636364,          7.5,    5.4545455
  59386,    22.727272,          7.5,    5.4545455
  59387,    21.818182,          7.5,    5.4545455
  59388,     20.90909,          7.5,    5.4545455
  59389,     29.09091,          7.5,   6.36363649
  59390,    28.181818,          7.5,   6.36363649
  59391,    27.272728,          7.5,   6.36363649
  59392,    26.363636,          7.5,   6.36363649
  59393,    25.454546,          7.5,   6.36363649
  59394,    24.545454,          7.5,   6.36363649
  59395,    23.636364,          7.5,   6.36363649
  59396,    22.727272,          7.5,   6.36363649
  59397,    21.818182,          7.5,   6.36363649
  59398,     20.90909,          7.5,   6.36363649
  59399,     29.09091,          7.5,   7.27272749
  59400,    28.181818,          7.5,   7.27272749
  59401,    27.272728,          7.5,   7.27272749
  59402,    26.363636,          7.5,   7.27272749
  59403,    25.454546,          7.5,   7.27272749
  59404,    24.545454,          7.5,   7.27272749
  59405,    23.636364,          7.5,   7.27272749
  59406,    22.727272,          7.5,   7.27272749
  59407,    21.818182,          7.5,   7.27272749
  59408,     20.90909,          7.5,   7.27272749
  59409,     29.09091,          7.5,   8.18181801
  59410,    28.181818,          7.5,   8.18181801
  59411,    27.272728,          7.5,   8.18181801
  59412,    26.363636,          7.5,   8.18181801
  59413,    25.454546,          7.5,   8.18181801
  59414,    24.545454,          7.5,   8.18181801
  59415,    23.636364,          7.5,   8.18181801
  59416,    22.727272,          7.5,   8.18181801
  59417,    21.818182,          7.5,   8.18181801
  59418,     20.90909,          7.5,   8.18181801
  59419,     29.09091,          7.5,     9.090909
  59420,    28.181818,          7.5,     9.090909
  59421,    27.272728,          7.5,     9.090909
  59422,    26.363636,          7.5,     9.090909
  59423,    25.454546,          7.5,     9.090909
  59424,    24.545454,          7.5,     9.090909
  59425,    23.636364,          7.5,     9.090909
  59426,    22.727272,          7.5,     9.090909
  59427,    21.818182,          7.5,     9.090909
  59428,     20.90909,          7.5,     9.090909
  59429,     29.09091,   6.66666651,  0.909090936
  59430,    28.181818,   6.66666651,  0.909090936
  59431,    27.272728,   6.66666651,  0.909090936
  59432,    26.363636,   6.66666651,  0.909090936
  59433,    25.454546,   6.66666651,  0.909090936
  59434,    24.545454,   6.66666651,  0.909090936
  59435,    23.636364,   6.66666651,  0.909090936
  59436,    22.727272,   6.66666651,  0.909090936
  59437,    21.818182,   6.66666651,  0.909090936
  59438,     20.90909,   6.66666651,  0.909090936
  59439,     29.09091,   6.66666651,   1.81818187
  59440,    28.181818,   6.66666651,   1.81818187
  59441,    27.272728,   6.66666651,   1.81818187
  59442,    26.363636,   6.66666651,   1.81818187
  59443,    25.454546,   6.66666651,   1.81818187
  59444,    24.545454,   6.66666651,   1.81818187
  59445,    23.636364,   6.66666651,   1.81818187
  59446,    22.727272,   6.66666651,   1.81818187
  59447,    21.818182,   6.66666651,   1.81818187
  59448,     20.90909,   6.66666651,   1.81818187
  59449,     29.09091,   6.66666651,   2.72727275
  59450,    28.181818,   6.66666651,   2.72727275
  59451,    27.272728,   6.66666651,   2.72727275
  59452,    26.363636,   6.66666651,   2.72727275
  59453,    25.454546,   6.66666651,   2.72727275
  59454,    24.545454,   6.66666651,   2.72727275
  59455,    23.636364,   6.66666651,   2.72727275
  59456,    22.727272,   6.66666651,   2.72727275
  59457,    21.818182,   6.66666651,   2.72727275
  59458,     20.90909,   6.66666651,   2.72727275
  59459,     29.09091,   6.66666651,   3.63636374
  59460,    28.181818,   6.66666651,   3.63636374
  59461,    27.272728,   6.66666651,   3.63636374
  59462,    26.363636,   6.66666651,   3.63636374
  59463,    25.454546,   6.66666651,   3.63636374
  59464,    24.545454,   6.66666651,   3.63636374
  59465,    23.636364,   6.66666651,   3.63636374
  59466,    22.727272,   6.66666651,   3.63636374
  59467,    21.818182,   6.66666651,   3.63636374
  59468,     20.90909,   6.66666651,   3.63636374
  59469,     29.09091,   6.66666651,    4.5454545
  59470,    28.181818,   6.66666651,    4.5454545
  59471,    27.272728,   6.66666651,    4.5454545
  59472,    26.363636,   6.66666651,    4.5454545
  59473,    25.454546,   6.66666651,    4.5454545
  59474,    24.545454,   6.66666651,    4.5454545
  59475,    23.636364,   6.66666651,    4.5454545
  59476,    22.727272,   6.66666651,    4.5454545
  59477,    21.818182,   6.66666651,    4.5454545
  59478,     20.90909,   6.66666651,    4.5454545
  59479,     29.09091,   6.66666651,    5.4545455
  59480,    28.181818,   6.66666651,    5.4545455
  59481,    27.272728,   6.66666651,    5.4545455
  59482,    26.363636,   6.66666651,    5.4545455
  59483,    25.454546,   6.66666651,    5.4545455
  59484,    24.545454,   6.66666651,    5.4545455
  59485,    23.636364,   6.66666651,    5.4545455
  59486,    22.727272,   6.66666651,    5.4545455
  59487,    21.818182,   6.66666651,    5.4545455
  59488,     20.90909,   6.66666651,    5.4545455
  59489,     29.09091,   6.66666651,   6.36363649
  59490,    28.181818,   6.66666651,   6.36363649
  59491,    27.272728,   6.66666651,   6.36363649
  59492,    26.363636,   6.66666651,   6.36363649
  59493,    25.454546,   6.66666651,   6.36363649
  59494,    24.545454,   6.66666651,   6.36363649
  59495,    23.636364,   6.66666651,   6.36363649
  59496,    22.727272,   6.66666651,   6.36363649
  59497,    21.818182,   6.66666651,   6.36363649
  59498,     20.90909,   6.66666651,   6.36363649
  59499,     29.09091,   6.66666651,   7.27272749
  59500,    28.181818,   6.66666651,   7.27272749
  59501,    27.272728,   6.66666651,   7.27272749
  59502,    26.363636,   6.66666651,   7.27272749
  59503,    25.454546,   6.66666651,   7.27272749
  59504,    24.545454,   6.66666651,   7.27272749
  59505,    23.636364,   6.66666651,   7.27272749
  59506,    22.727272,   6.66666651,   7.27272749
  59507,    21.818182,   6.66666651,   7.27272749
  59508,     20.90909,   6.66666651,   7.27272749
  59509,     29.09091,   6.66666651,   8.18181801
  59510,    28.181818,   6.66666651,   8.18181801
  59511,    27.272728,   6.66666651,   8.18181801
  59512,    26.363636,   6.66666651,   8.18181801
  59513,    25.454546,   6.66666651,   8.18181801
  59514,    24.545454,   6.66666651,   8.18181801
  59515,    23.636364,   6.66666651,   8.18181801
  59516,    22.727272,   6.66666651,   8.18181801
  59517,    21.818182,   6.66666651,   8.18181801
  59518,     20.90909,   6.66666651,   8.18181801
  59519,     29.09091,   6.66666651,     9.090909
  59520,    28.181818,   6.66666651,     9.090909
  59521,    27.272728,   6.66666651,     9.090909
  59522,    26.363636,   6.66666651,     9.090909
  59523,    25.454546,   6.66666651,     9.090909
  59524,    24.545454,   6.66666651,     9.090909
  59525,    23.636364,   6.66666651,     9.090909
  59526,    22.727272,   6.66666651,     9.090909
  59527,    21.818182,   6.66666651,     9.090909
  59528,     20.90909,   6.66666651,     9.090909
  59529,     29.09091,   5.83333349,  0.909090936
  59530,    28.181818,   5.83333349,  0.909090936
  59531,    27.272728,   5.83333349,  0.909090936
  59532,    26.363636,   5.83333349,  0.909090936
  59533,    25.454546,   5.83333349,  0.909090936
  59534,    24.545454,   5.83333349,  0.909090936
  59535,    23.636364,   5.83333349,  0.909090936
  59536,    22.727272,   5.83333349,  0.909090936
  59537,    21.818182,   5.83333349,  0.909090936
  59538,     20.90909,   5.83333349,  0.909090936
  59539,     29.09091,   5.83333349,   1.81818187
  59540,    28.181818,   5.83333349,   1.81818187
  59541,    27.272728,   5.83333349,   1.81818187
  59542,    26.363636,   5.83333349,   1.81818187
  59543,    25.454546,   5.83333349,   1.81818187
  59544,    24.545454,   5.83333349,   1.81818187
  59545,    23.636364,   5.83333349,   1.81818187
  59546,    22.727272,   5.83333349,   1.81818187
  59547,    21.818182,   5.83333349,   1.81818187
  59548,     20.90909,   5.83333349,   1.81818187
  59549,     29.09091,   5.83333349,   2.72727275
  59550,    28.181818,   5.83333349,   2.72727275
  59551,    27.272728,   5.83333349,   2.72727275
  59552,    26.363636,   5.83333349,   2.72727275
  59553,    25.454546,   5.83333349,   2.72727275
  59554,    24.545454,   5.83333349,   2.72727275
  59555,    23.636364,   5.83333349,   2.72727275
  59556,    22.727272,   5.83333349,   2.72727275
  59557,    21.818182,   5.83333349,   2.72727275
  59558,     20.90909,   5.83333349,   2.72727275
  59559,     29.09091,   5.83333349,   3.63636374
  59560,    28.181818,   5.83333349,   3.63636374
  59561,    27.272728,   5.83333349,   3.63636374
  59562,    26.363636,   5.83333349,   3.63636374
  59563,    25.454546,   5.83333349,   3.63636374
  59564,    24.545454,   5.83333349,   3.63636374
  59565,    23.636364,   5.83333349,   3.63636374
  59566,    22.727272,   5.83333349,   3.63636374
  59567,    21.818182,   5.83333349,   3.63636374
  59568,     20.90909,   5.83333349,   3.63636374
  59569,     29.09091,   5.83333349,    4.5454545
  59570,    28.181818,   5.83333349,    4.5454545
  59571,    27.272728,   5.83333349,    4.5454545
  59572,    26.363636,   5.83333349,    4.5454545
  59573,    25.454546,   5.83333349,    4.5454545
  59574,    24.545454,   5.83333349,    4.5454545
  59575,    23.636364,   5.83333349,    4.5454545
  59576,    22.727272,   5.83333349,    4.5454545
  59577,    21.818182,   5.83333349,    4.5454545
  59578,     20.90909,   5.83333349,    4.5454545
  59579,     29.09091,   5.83333349,    5.4545455
  59580,    28.181818,   5.83333349,    5.4545455
  59581,    27.272728,   5.83333349,    5.4545455
  59582,    26.363636,   5.83333349,    5.4545455
  59583,    25.454546,   5.83333349,    5.4545455
  59584,    24.545454,   5.83333349,    5.4545455
  59585,    23.636364,   5.83333349,    5.4545455
  59586,    22.727272,   5.83333349,    5.4545455
  59587,    21.818182,   5.83333349,    5.4545455
  59588,     20.90909,   5.83333349,    5.4545455
  59589,     29.09091,   5.83333349,   6.36363649
  59590,    28.181818,   5.83333349,   6.36363649
  59591,    27.272728,   5.83333349,   6.36363649
  59592,    26.363636,   5.83333349,   6.36363649
  59593,    25.454546,   5.83333349,   6.36363649
  59594,    24.545454,   5.83333349,   6.36363649
  59595,    23.636364,   5.83333349,   6.36363649
  59596,    22.727272,   5.83333349,   6.36363649
  59597,    21.818182,   5.83333349,   6.36363649
  59598,     20.90909,   5.83333349,   6.36363649
  59599,     29.09091,   5.83333349,   7.27272749
  59600,    28.181818,   5.83333349,   7.27272749
  59601,    27.272728,   5.83333349,   7.27272749
  59602,    26.363636,   5.83333349,   7.27272749
  59603,    25.454546,   5.83333349,   7.27272749
  59604,    24.545454,   5.83333349,   7.27272749
  59605,    23.636364,   5.83333349,   7.27272749
  59606,    22.727272,   5.83333349,   7.27272749
  59607,    21.818182,   5.83333349,   7.27272749
  59608,     20.90909,   5.83333349,   7.27272749
  59609,     29.09091,   5.83333349,   8.18181801
  59610,    28.181818,   5.83333349,   8.18181801
  59611,    27.272728,   5.83333349,   8.18181801
  59612,    26.363636,   5.83333349,   8.18181801
  59613,    25.454546,   5.83333349,   8.18181801
  59614,    24.545454,   5.83333349,   8.18181801
  59615,    23.636364,   5.83333349,   8.18181801
  59616,    22.727272,   5.83333349,   8.18181801
  59617,    21.818182,   5.83333349,   8.18181801
  59618,     20.90909,   5.83333349,   8.18181801
  59619,     29.09091,   5.83333349,     9.090909
  59620,    28.181818,   5.83333349,     9.090909
  59621,    27.272728,   5.83333349,     9.090909
  59622,    26.363636,   5.83333349,     9.090909
  59623,    25.454546,   5.83333349,     9.090909
  59624,    24.545454,   5.83333349,     9.090909
  59625,    23.636364,   5.83333349,     9.090909
  59626,    22.727272,   5.83333349,     9.090909
  59627,    21.818182,   5.83333349,     9.090909
  59628,     20.90909,   5.83333349,     9.090909
  59629,     29.09091,           5.,  0.909090936
  59630,    28.181818,           5.,  0.909090936
  59631,    27.272728,           5.,  0.909090936
  59632,    26.363636,           5.,  0.909090936
  59633,    25.454546,           5.,  0.909090936
  59634,    24.545454,           5.,  0.909090936
  59635,    23.636364,           5.,  0.909090936
  59636,    22.727272,           5.,  0.909090936
  59637,    21.818182,           5.,  0.909090936
  59638,     20.90909,           5.,  0.909090936
  59639,     29.09091,           5.,   1.81818187
  59640,    28.181818,           5.,   1.81818187
  59641,    27.272728,           5.,   1.81818187
  59642,    26.363636,           5.,   1.81818187
  59643,    25.454546,           5.,   1.81818187
  59644,    24.545454,           5.,   1.81818187
  59645,    23.636364,           5.,   1.81818187
  59646,    22.727272,           5.,   1.81818187
  59647,    21.818182,           5.,   1.81818187
  59648,     20.90909,           5.,   1.81818187
  59649,     29.09091,           5.,   2.72727275
  59650,    28.181818,           5.,   2.72727275
  59651,    27.272728,           5.,   2.72727275
  59652,    26.363636,           5.,   2.72727275
  59653,    25.454546,           5.,   2.72727275
  59654,    24.545454,           5.,   2.72727275
  59655,    23.636364,           5.,   2.72727275
  59656,    22.727272,           5.,   2.72727275
  59657,    21.818182,           5.,   2.72727275
  59658,     20.90909,           5.,   2.72727275
  59659,     29.09091,           5.,   3.63636374
  59660,    28.181818,           5.,   3.63636374
  59661,    27.272728,           5.,   3.63636374
  59662,    26.363636,           5.,   3.63636374
  59663,    25.454546,           5.,   3.63636374
  59664,    24.545454,           5.,   3.63636374
  59665,    23.636364,           5.,   3.63636374
  59666,    22.727272,           5.,   3.63636374
  59667,    21.818182,           5.,   3.63636374
  59668,     20.90909,           5.,   3.63636374
  59669,     29.09091,           5.,    4.5454545
  59670,    28.181818,           5.,    4.5454545
  59671,    27.272728,           5.,    4.5454545
  59672,    26.363636,           5.,    4.5454545
  59673,    25.454546,           5.,    4.5454545
  59674,    24.545454,           5.,    4.5454545
  59675,    23.636364,           5.,    4.5454545
  59676,    22.727272,           5.,    4.5454545
  59677,    21.818182,           5.,    4.5454545
  59678,     20.90909,           5.,    4.5454545
  59679,     29.09091,           5.,    5.4545455
  59680,    28.181818,           5.,    5.4545455
  59681,    27.272728,           5.,    5.4545455
  59682,    26.363636,           5.,    5.4545455
  59683,    25.454546,           5.,    5.4545455
  59684,    24.545454,           5.,    5.4545455
  59685,    23.636364,           5.,    5.4545455
  59686,    22.727272,           5.,    5.4545455
  59687,    21.818182,           5.,    5.4545455
  59688,     20.90909,           5.,    5.4545455
  59689,     29.09091,           5.,   6.36363649
  59690,    28.181818,           5.,   6.36363649
  59691,    27.272728,           5.,   6.36363649
  59692,    26.363636,           5.,   6.36363649
  59693,    25.454546,           5.,   6.36363649
  59694,    24.545454,           5.,   6.36363649
  59695,    23.636364,           5.,   6.36363649
  59696,    22.727272,           5.,   6.36363649
  59697,    21.818182,           5.,   6.36363649
  59698,     20.90909,           5.,   6.36363649
  59699,     29.09091,           5.,   7.27272749
  59700,    28.181818,           5.,   7.27272749
  59701,    27.272728,           5.,   7.27272749
  59702,    26.363636,           5.,   7.27272749
  59703,    25.454546,           5.,   7.27272749
  59704,    24.545454,           5.,   7.27272749
  59705,    23.636364,           5.,   7.27272749
  59706,    22.727272,           5.,   7.27272749
  59707,    21.818182,           5.,   7.27272749
  59708,     20.90909,           5.,   7.27272749
  59709,     29.09091,           5.,   8.18181801
  59710,    28.181818,           5.,   8.18181801
  59711,    27.272728,           5.,   8.18181801
  59712,    26.363636,           5.,   8.18181801
  59713,    25.454546,           5.,   8.18181801
  59714,    24.545454,           5.,   8.18181801
  59715,    23.636364,           5.,   8.18181801
  59716,    22.727272,           5.,   8.18181801
  59717,    21.818182,           5.,   8.18181801
  59718,     20.90909,           5.,   8.18181801
  59719,     29.09091,           5.,     9.090909
  59720,    28.181818,           5.,     9.090909
  59721,    27.272728,           5.,     9.090909
  59722,    26.363636,           5.,     9.090909
  59723,    25.454546,           5.,     9.090909
  59724,    24.545454,           5.,     9.090909
  59725,    23.636364,           5.,     9.090909
  59726,    22.727272,           5.,     9.090909
  59727,    21.818182,           5.,     9.090909
  59728,     20.90909,           5.,     9.090909
  59729,     29.09091,   4.16666651,  0.909090936
  59730,    28.181818,   4.16666651,  0.909090936
  59731,    27.272728,   4.16666651,  0.909090936
  59732,    26.363636,   4.16666651,  0.909090936
  59733,    25.454546,   4.16666651,  0.909090936
  59734,    24.545454,   4.16666651,  0.909090936
  59735,    23.636364,   4.16666651,  0.909090936
  59736,    22.727272,   4.16666651,  0.909090936
  59737,    21.818182,   4.16666651,  0.909090936
  59738,     20.90909,   4.16666651,  0.909090936
  59739,     29.09091,   4.16666651,   1.81818187
  59740,    28.181818,   4.16666651,   1.81818187
  59741,    27.272728,   4.16666651,   1.81818187
  59742,    26.363636,   4.16666651,   1.81818187
  59743,    25.454546,   4.16666651,   1.81818187
  59744,    24.545454,   4.16666651,   1.81818187
  59745,    23.636364,   4.16666651,   1.81818187
  59746,    22.727272,   4.16666651,   1.81818187
  59747,    21.818182,   4.16666651,   1.81818187
  59748,     20.90909,   4.16666651,   1.81818187
  59749,     29.09091,   4.16666651,   2.72727275
  59750,    28.181818,   4.16666651,   2.72727275
  59751,    27.272728,   4.16666651,   2.72727275
  59752,    26.363636,   4.16666651,   2.72727275
  59753,    25.454546,   4.16666651,   2.72727275
  59754,    24.545454,   4.16666651,   2.72727275
  59755,    23.636364,   4.16666651,   2.72727275
  59756,    22.727272,   4.16666651,   2.72727275
  59757,    21.818182,   4.16666651,   2.72727275
  59758,     20.90909,   4.16666651,   2.72727275
  59759,     29.09091,   4.16666651,   3.63636374
  59760,    28.181818,   4.16666651,   3.63636374
  59761,    27.272728,   4.16666651,   3.63636374
  59762,    26.363636,   4.16666651,   3.63636374
  59763,    25.454546,   4.16666651,   3.63636374
  59764,    24.545454,   4.16666651,   3.63636374
  59765,    23.636364,   4.16666651,   3.63636374
  59766,    22.727272,   4.16666651,   3.63636374
  59767,    21.818182,   4.16666651,   3.63636374
  59768,     20.90909,   4.16666651,   3.63636374
  59769,     29.09091,   4.16666651,    4.5454545
  59770,    28.181818,   4.16666651,    4.5454545
  59771,    27.272728,   4.16666651,    4.5454545
  59772,    26.363636,   4.16666651,    4.5454545
  59773,    25.454546,   4.16666651,    4.5454545
  59774,    24.545454,   4.16666651,    4.5454545
  59775,    23.636364,   4.16666651,    4.5454545
  59776,    22.727272,   4.16666651,    4.5454545
  59777,    21.818182,   4.16666651,    4.5454545
  59778,     20.90909,   4.16666651,    4.5454545
  59779,     29.09091,   4.16666651,    5.4545455
  59780,    28.181818,   4.16666651,    5.4545455
  59781,    27.272728,   4.16666651,    5.4545455
  59782,    26.363636,   4.16666651,    5.4545455
  59783,    25.454546,   4.16666651,    5.4545455
  59784,    24.545454,   4.16666651,    5.4545455
  59785,    23.636364,   4.16666651,    5.4545455
  59786,    22.727272,   4.16666651,    5.4545455
  59787,    21.818182,   4.16666651,    5.4545455
  59788,     20.90909,   4.16666651,    5.4545455
  59789,     29.09091,   4.16666651,   6.36363649
  59790,    28.181818,   4.16666651,   6.36363649
  59791,    27.272728,   4.16666651,   6.36363649
  59792,    26.363636,   4.16666651,   6.36363649
  59793,    25.454546,   4.16666651,   6.36363649
  59794,    24.545454,   4.16666651,   6.36363649
  59795,    23.636364,   4.16666651,   6.36363649
  59796,    22.727272,   4.16666651,   6.36363649
  59797,    21.818182,   4.16666651,   6.36363649
  59798,     20.90909,   4.16666651,   6.36363649
  59799,     29.09091,   4.16666651,   7.27272749
  59800,    28.181818,   4.16666651,   7.27272749
  59801,    27.272728,   4.16666651,   7.27272749
  59802,    26.363636,   4.16666651,   7.27272749
  59803,    25.454546,   4.16666651,   7.27272749
  59804,    24.545454,   4.16666651,   7.27272749
  59805,    23.636364,   4.16666651,   7.27272749
  59806,    22.727272,   4.16666651,   7.27272749
  59807,    21.818182,   4.16666651,   7.27272749
  59808,     20.90909,   4.16666651,   7.27272749
  59809,     29.09091,   4.16666651,   8.18181801
  59810,    28.181818,   4.16666651,   8.18181801
  59811,    27.272728,   4.16666651,   8.18181801
  59812,    26.363636,   4.16666651,   8.18181801
  59813,    25.454546,   4.16666651,   8.18181801
  59814,    24.545454,   4.16666651,   8.18181801
  59815,    23.636364,   4.16666651,   8.18181801
  59816,    22.727272,   4.16666651,   8.18181801
  59817,    21.818182,   4.16666651,   8.18181801
  59818,     20.90909,   4.16666651,   8.18181801
  59819,     29.09091,   4.16666651,     9.090909
  59820,    28.181818,   4.16666651,     9.090909
  59821,    27.272728,   4.16666651,     9.090909
  59822,    26.363636,   4.16666651,     9.090909
  59823,    25.454546,   4.16666651,     9.090909
  59824,    24.545454,   4.16666651,     9.090909
  59825,    23.636364,   4.16666651,     9.090909
  59826,    22.727272,   4.16666651,     9.090909
  59827,    21.818182,   4.16666651,     9.090909
  59828,     20.90909,   4.16666651,     9.090909
  59829,     29.09091,   3.33333325,  0.909090936
  59830,    28.181818,   3.33333325,  0.909090936
  59831,    27.272728,   3.33333325,  0.909090936
  59832,    26.363636,   3.33333325,  0.909090936
  59833,    25.454546,   3.33333325,  0.909090936
  59834,    24.545454,   3.33333325,  0.909090936
  59835,    23.636364,   3.33333325,  0.909090936
  59836,    22.727272,   3.33333325,  0.909090936
  59837,    21.818182,   3.33333325,  0.909090936
  59838,     20.90909,   3.33333325,  0.909090936
  59839,     29.09091,   3.33333325,   1.81818187
  59840,    28.181818,   3.33333325,   1.81818187
  59841,    27.272728,   3.33333325,   1.81818187
  59842,    26.363636,   3.33333325,   1.81818187
  59843,    25.454546,   3.33333325,   1.81818187
  59844,    24.545454,   3.33333325,   1.81818187
  59845,    23.636364,   3.33333325,   1.81818187
  59846,    22.727272,   3.33333325,   1.81818187
  59847,    21.818182,   3.33333325,   1.81818187
  59848,     20.90909,   3.33333325,   1.81818187
  59849,     29.09091,   3.33333325,   2.72727275
  59850,    28.181818,   3.33333325,   2.72727275
  59851,    27.272728,   3.33333325,   2.72727275
  59852,    26.363636,   3.33333325,   2.72727275
  59853,    25.454546,   3.33333325,   2.72727275
  59854,    24.545454,   3.33333325,   2.72727275
  59855,    23.636364,   3.33333325,   2.72727275
  59856,    22.727272,   3.33333325,   2.72727275
  59857,    21.818182,   3.33333325,   2.72727275
  59858,     20.90909,   3.33333325,   2.72727275
  59859,     29.09091,   3.33333325,   3.63636374
  59860,    28.181818,   3.33333325,   3.63636374
  59861,    27.272728,   3.33333325,   3.63636374
  59862,    26.363636,   3.33333325,   3.63636374
  59863,    25.454546,   3.33333325,   3.63636374
  59864,    24.545454,   3.33333325,   3.63636374
  59865,    23.636364,   3.33333325,   3.63636374
  59866,    22.727272,   3.33333325,   3.63636374
  59867,    21.818182,   3.33333325,   3.63636374
  59868,     20.90909,   3.33333325,   3.63636374
  59869,     29.09091,   3.33333325,    4.5454545
  59870,    28.181818,   3.33333325,    4.5454545
  59871,    27.272728,   3.33333325,    4.5454545
  59872,    26.363636,   3.33333325,    4.5454545
  59873,    25.454546,   3.33333325,    4.5454545
  59874,    24.545454,   3.33333325,    4.5454545
  59875,    23.636364,   3.33333325,    4.5454545
  59876,    22.727272,   3.33333325,    4.5454545
  59877,    21.818182,   3.33333325,    4.5454545
  59878,     20.90909,   3.33333325,    4.5454545
  59879,     29.09091,   3.33333325,    5.4545455
  59880,    28.181818,   3.33333325,    5.4545455
  59881,    27.272728,   3.33333325,    5.4545455
  59882,    26.363636,   3.33333325,    5.4545455
  59883,    25.454546,   3.33333325,    5.4545455
  59884,    24.545454,   3.33333325,    5.4545455
  59885,    23.636364,   3.33333325,    5.4545455
  59886,    22.727272,   3.33333325,    5.4545455
  59887,    21.818182,   3.33333325,    5.4545455
  59888,     20.90909,   3.33333325,    5.4545455
  59889,     29.09091,   3.33333325,   6.36363649
  59890,    28.181818,   3.33333325,   6.36363649
  59891,    27.272728,   3.33333325,   6.36363649
  59892,    26.363636,   3.33333325,   6.36363649
  59893,    25.454546,   3.33333325,   6.36363649
  59894,    24.545454,   3.33333325,   6.36363649
  59895,    23.636364,   3.33333325,   6.36363649
  59896,    22.727272,   3.33333325,   6.36363649
  59897,    21.818182,   3.33333325,   6.36363649
  59898,     20.90909,   3.33333325,   6.36363649
  59899,     29.09091,   3.33333325,   7.27272749
  59900,    28.181818,   3.33333325,   7.27272749
  59901,    27.272728,   3.33333325,   7.27272749
  59902,    26.363636,   3.33333325,   7.27272749
  59903,    25.454546,   3.33333325,   7.27272749
  59904,    24.545454,   3.33333325,   7.27272749
  59905,    23.636364,   3.33333325,   7.27272749
  59906,    22.727272,   3.33333325,   7.27272749
  59907,    21.818182,   3.33333325,   7.27272749
  59908,     20.90909,   3.33333325,   7.27272749
  59909,     29.09091,   3.33333325,   8.18181801
  59910,    28.181818,   3.33333325,   8.18181801
  59911,    27.272728,   3.33333325,   8.18181801
  59912,    26.363636,   3.33333325,   8.18181801
  59913,    25.454546,   3.33333325,   8.18181801
  59914,    24.545454,   3.33333325,   8.18181801
  59915,    23.636364,   3.33333325,   8.18181801
  59916,    22.727272,   3.33333325,   8.18181801
  59917,    21.818182,   3.33333325,   8.18181801
  59918,     20.90909,   3.33333325,   8.18181801
  59919,     29.09091,   3.33333325,     9.090909
  59920,    28.181818,   3.33333325,     9.090909
  59921,    27.272728,   3.33333325,     9.090909
  59922,    26.363636,   3.33333325,     9.090909
  59923,    25.454546,   3.33333325,     9.090909
  59924,    24.545454,   3.33333325,     9.090909
  59925,    23.636364,   3.33333325,     9.090909
  59926,    22.727272,   3.33333325,     9.090909
  59927,    21.818182,   3.33333325,     9.090909
  59928,     20.90909,   3.33333325,     9.090909
  59929,     29.09091,          2.5,  0.909090936
  59930,    28.181818,          2.5,  0.909090936
  59931,    27.272728,          2.5,  0.909090936
  59932,    26.363636,          2.5,  0.909090936
  59933,    25.454546,          2.5,  0.909090936
  59934,    24.545454,          2.5,  0.909090936
  59935,    23.636364,          2.5,  0.909090936
  59936,    22.727272,          2.5,  0.909090936
  59937,    21.818182,          2.5,  0.909090936
  59938,     20.90909,          2.5,  0.909090936
  59939,     29.09091,          2.5,   1.81818187
  59940,    28.181818,          2.5,   1.81818187
  59941,    27.272728,          2.5,   1.81818187
  59942,    26.363636,          2.5,   1.81818187
  59943,    25.454546,          2.5,   1.81818187
  59944,    24.545454,          2.5,   1.81818187
  59945,    23.636364,          2.5,   1.81818187
  59946,    22.727272,          2.5,   1.81818187
  59947,    21.818182,          2.5,   1.81818187
  59948,     20.90909,          2.5,   1.81818187
  59949,     29.09091,          2.5,   2.72727275
  59950,    28.181818,          2.5,   2.72727275
  59951,    27.272728,          2.5,   2.72727275
  59952,    26.363636,          2.5,   2.72727275
  59953,    25.454546,          2.5,   2.72727275
  59954,    24.545454,          2.5,   2.72727275
  59955,    23.636364,          2.5,   2.72727275
  59956,    22.727272,          2.5,   2.72727275
  59957,    21.818182,          2.5,   2.72727275
  59958,     20.90909,          2.5,   2.72727275
  59959,     29.09091,          2.5,   3.63636374
  59960,    28.181818,          2.5,   3.63636374
  59961,    27.272728,          2.5,   3.63636374
  59962,    26.363636,          2.5,   3.63636374
  59963,    25.454546,          2.5,   3.63636374
  59964,    24.545454,          2.5,   3.63636374
  59965,    23.636364,          2.5,   3.63636374
  59966,    22.727272,          2.5,   3.63636374
  59967,    21.818182,          2.5,   3.63636374
  59968,     20.90909,          2.5,   3.63636374
  59969,     29.09091,          2.5,    4.5454545
  59970,    28.181818,          2.5,    4.5454545
  59971,    27.272728,          2.5,    4.5454545
  59972,    26.363636,          2.5,    4.5454545
  59973,    25.454546,          2.5,    4.5454545
  59974,    24.545454,          2.5,    4.5454545
  59975,    23.636364,          2.5,    4.5454545
  59976,    22.727272,          2.5,    4.5454545
  59977,    21.818182,          2.5,    4.5454545
  59978,     20.90909,          2.5,    4.5454545
  59979,     29.09091,          2.5,    5.4545455
  59980,    28.181818,          2.5,    5.4545455
  59981,    27.272728,          2.5,    5.4545455
  59982,    26.363636,          2.5,    5.4545455
  59983,    25.454546,          2.5,    5.4545455
  59984,    24.545454,          2.5,    5.4545455
  59985,    23.636364,          2.5,    5.4545455
  59986,    22.727272,          2.5,    5.4545455
  59987,    21.818182,          2.5,    5.4545455
  59988,     20.90909,          2.5,    5.4545455
  59989,     29.09091,          2.5,   6.36363649
  59990,    28.181818,          2.5,   6.36363649
  59991,    27.272728,          2.5,   6.36363649
  59992,    26.363636,          2.5,   6.36363649
  59993,    25.454546,          2.5,   6.36363649
  59994,    24.545454,          2.5,   6.36363649
