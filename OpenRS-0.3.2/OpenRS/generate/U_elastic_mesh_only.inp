  33995,  -15.0830746,   71.6227264,  -6.36363649
  33996,  -15.6031809,   72.3683319,  -6.36363649
  33997,  -16.1232853,    73.113945,  -6.36363649
  33998,  -16.6433926,   73.8595581,  -6.36363649
  33999,  -11.9624405,   67.1490555,  -7.27272749
  34000,  -12.4825449,   67.8946686,  -7.27272749
  34001,  -13.0026512,   68.6402817,  -7.27272749
  34002,  -13.5227575,   69.3858871,  -7.27272749
  34003,  -14.0428638,   70.1315002,  -7.27272749
  34004,  -14.5629683,   70.8771133,  -7.27272749
  34005,  -15.0830746,   71.6227264,  -7.27272749
  34006,  -15.6031809,   72.3683319,  -7.27272749
  34007,  -16.1232853,    73.113945,  -7.27272749
  34008,  -16.6433926,   73.8595581,  -7.27272749
  34009,  -11.9624405,   67.1490555,  -8.18181801
  34010,  -12.4825449,   67.8946686,  -8.18181801
  34011,  -13.0026512,   68.6402817,  -8.18181801
  34012,  -13.5227575,   69.3858871,  -8.18181801
  34013,  -14.0428638,   70.1315002,  -8.18181801
  34014,  -14.5629683,   70.8771133,  -8.18181801
  34015,  -15.0830746,   71.6227264,  -8.18181801
  34016,  -15.6031809,   72.3683319,  -8.18181801
  34017,  -16.1232853,    73.113945,  -8.18181801
  34018,  -16.6433926,   73.8595581,  -8.18181801
  34019,  -11.9624405,   67.1490555,    -9.090909
  34020,  -12.4825449,   67.8946686,    -9.090909
  34021,  -13.0026512,   68.6402817,    -9.090909
  34022,  -13.5227575,   69.3858871,    -9.090909
  34023,  -14.0428638,   70.1315002,    -9.090909
  34024,  -14.5629683,   70.8771133,    -9.090909
  34025,  -15.0830746,   71.6227264,    -9.090909
  34026,  -15.6031809,   72.3683319,    -9.090909
  34027,  -16.1232853,    73.113945,    -9.090909
  34028,  -16.6433926,   73.8595581,    -9.090909
  34029,  -12.5059462,   66.7568283, -0.909090936
  34030,  -13.0496836,   67.4853897, -0.909090936
  34031,    -13.59342,   68.2139435, -0.909090936
  34032,  -14.1371574,   68.9425049, -0.909090936
  34033,  -14.6808939,   69.6710587, -0.909090936
  34034,  -15.2246294,   70.3996201, -0.909090936
  34035,  -15.7683668,   71.1281738, -0.909090936
  34036,  -16.3121033,   71.8567352, -0.909090936
  34037,  -16.8558407,   72.5852966, -0.909090936
  34038,  -17.3995781,   73.3138504, -0.909090936
  34039,  -12.5059462,   66.7568283,  -1.81818187
  34040,  -13.0496836,   67.4853897,  -1.81818187
  34041,    -13.59342,   68.2139435,  -1.81818187
  34042,  -14.1371574,   68.9425049,  -1.81818187
  34043,  -14.6808939,   69.6710587,  -1.81818187
  34044,  -15.2246294,   70.3996201,  -1.81818187
  34045,  -15.7683668,   71.1281738,  -1.81818187
  34046,  -16.3121033,   71.8567352,  -1.81818187
  34047,  -16.8558407,   72.5852966,  -1.81818187
  34048,  -17.3995781,   73.3138504,  -1.81818187
  34049,  -12.5059462,   66.7568283,  -2.72727275
  34050,  -13.0496836,   67.4853897,  -2.72727275
  34051,    -13.59342,   68.2139435,  -2.72727275
  34052,  -14.1371574,   68.9425049,  -2.72727275
  34053,  -14.6808939,   69.6710587,  -2.72727275
  34054,  -15.2246294,   70.3996201,  -2.72727275
  34055,  -15.7683668,   71.1281738,  -2.72727275
  34056,  -16.3121033,   71.8567352,  -2.72727275
  34057,  -16.8558407,   72.5852966,  -2.72727275
  34058,  -17.3995781,   73.3138504,  -2.72727275
  34059,  -12.5059462,   66.7568283,  -3.63636374
  34060,  -13.0496836,   67.4853897,  -3.63636374
  34061,    -13.59342,   68.2139435,  -3.63636374
  34062,  -14.1371574,   68.9425049,  -3.63636374
  34063,  -14.6808939,   69.6710587,  -3.63636374
  34064,  -15.2246294,   70.3996201,  -3.63636374
  34065,  -15.7683668,   71.1281738,  -3.63636374
  34066,  -16.3121033,   71.8567352,  -3.63636374
  34067,  -16.8558407,   72.5852966,  -3.63636374
  34068,  -17.3995781,   73.3138504,  -3.63636374
  34069,  -12.5059462,   66.7568283,   -4.5454545
  34070,  -13.0496836,   67.4853897,   -4.5454545
  34071,    -13.59342,   68.2139435,   -4.5454545
  34072,  -14.1371574,   68.9425049,   -4.5454545
  34073,  -14.6808939,   69.6710587,   -4.5454545
  34074,  -15.2246294,   70.3996201,   -4.5454545
  34075,  -15.7683668,   71.1281738,   -4.5454545
  34076,  -16.3121033,   71.8567352,   -4.5454545
  34077,  -16.8558407,   72.5852966,   -4.5454545
  34078,  -17.3995781,   73.3138504,   -4.5454545
  34079,  -12.5059462,   66.7568283,   -5.4545455
  34080,  -13.0496836,   67.4853897,   -5.4545455
  34081,    -13.59342,   68.2139435,   -5.4545455
  34082,  -14.1371574,   68.9425049,   -5.4545455
  34083,  -14.6808939,   69.6710587,   -5.4545455
  34084,  -15.2246294,   70.3996201,   -5.4545455
  34085,  -15.7683668,   71.1281738,   -5.4545455
  34086,  -16.3121033,   71.8567352,   -5.4545455
  34087,  -16.8558407,   72.5852966,   -5.4545455
  34088,  -17.3995781,   73.3138504,   -5.4545455
  34089,  -12.5059462,   66.7568283,  -6.36363649
  34090,  -13.0496836,   67.4853897,  -6.36363649
  34091,    -13.59342,   68.2139435,  -6.36363649
  34092,  -14.1371574,   68.9425049,  -6.36363649
  34093,  -14.6808939,   69.6710587,  -6.36363649
  34094,  -15.2246294,   70.3996201,  -6.36363649
  34095,  -15.7683668,   71.1281738,  -6.36363649
  34096,  -16.3121033,   71.8567352,  -6.36363649
  34097,  -16.8558407,   72.5852966,  -6.36363649
  34098,  -17.3995781,   73.3138504,  -6.36363649
  34099,  -12.5059462,   66.7568283,  -7.27272749
  34100,  -13.0496836,   67.4853897,  -7.27272749
  34101,    -13.59342,   68.2139435,  -7.27272749
  34102,  -14.1371574,   68.9425049,  -7.27272749
  34103,  -14.6808939,   69.6710587,  -7.27272749
  34104,  -15.2246294,   70.3996201,  -7.27272749
  34105,  -15.7683668,   71.1281738,  -7.27272749
  34106,  -16.3121033,   71.8567352,  -7.27272749
  34107,  -16.8558407,   72.5852966,  -7.27272749
  34108,  -17.3995781,   73.3138504,  -7.27272749
  34109,  -12.5059462,   66.7568283,  -8.18181801
  34110,  -13.0496836,   67.4853897,  -8.18181801
  34111,    -13.59342,   68.2139435,  -8.18181801
  34112,  -14.1371574,   68.9425049,  -8.18181801
  34113,  -14.6808939,   69.6710587,  -8.18181801
  34114,  -15.2246294,   70.3996201,  -8.18181801
  34115,  -15.7683668,   71.1281738,  -8.18181801
  34116,  -16.3121033,   71.8567352,  -8.18181801
  34117,  -16.8558407,   72.5852966,  -8.18181801
  34118,  -17.3995781,   73.3138504,  -8.18181801
  34119,  -12.5059462,   66.7568283,    -9.090909
  34120,  -13.0496836,   67.4853897,    -9.090909
  34121,    -13.59342,   68.2139435,    -9.090909
  34122,  -14.1371574,   68.9425049,    -9.090909
  34123,  -14.6808939,   69.6710587,    -9.090909
  34124,  -15.2246294,   70.3996201,    -9.090909
  34125,  -15.7683668,   71.1281738,    -9.090909
  34126,  -16.3121033,   71.8567352,    -9.090909
  34127,  -16.8558407,   72.5852966,    -9.090909
  34128,  -17.3995781,   73.3138504,    -9.090909
  34129,  -13.0366058,   66.3473892, -0.909090936
  34130,  -13.6034145,   67.0581436, -0.909090936
  34131,  -14.1702242,    67.768898, -0.909090936
  34132,  -14.7370329,   68.4796524, -0.909090936
  34133,  -15.3038416,   69.1904068, -0.909090936
  34134,  -15.8706512,   69.9011612, -0.909090936
  34135,  -16.4374599,   70.6119232, -0.909090936
  34136,  -17.0042686,   71.3226776, -0.909090936
  34137,  -17.5710773,    72.033432, -0.909090936
  34138,   -18.137888,   72.7441864, -0.909090936
  34139,  -13.0366058,   66.3473892,  -1.81818187
  34140,  -13.6034145,   67.0581436,  -1.81818187
  34141,  -14.1702242,    67.768898,  -1.81818187
  34142,  -14.7370329,   68.4796524,  -1.81818187
  34143,  -15.3038416,   69.1904068,  -1.81818187
  34144,  -15.8706512,   69.9011612,  -1.81818187
  34145,  -16.4374599,   70.6119232,  -1.81818187
  34146,  -17.0042686,   71.3226776,  -1.81818187
  34147,  -17.5710773,    72.033432,  -1.81818187
  34148,   -18.137888,   72.7441864,  -1.81818187
  34149,  -13.0366058,   66.3473892,  -2.72727275
  34150,  -13.6034145,   67.0581436,  -2.72727275
  34151,  -14.1702242,    67.768898,  -2.72727275
  34152,  -14.7370329,   68.4796524,  -2.72727275
  34153,  -15.3038416,   69.1904068,  -2.72727275
  34154,  -15.8706512,   69.9011612,  -2.72727275
  34155,  -16.4374599,   70.6119232,  -2.72727275
  34156,  -17.0042686,   71.3226776,  -2.72727275
  34157,  -17.5710773,    72.033432,  -2.72727275
  34158,   -18.137888,   72.7441864,  -2.72727275
  34159,  -13.0366058,   66.3473892,  -3.63636374
  34160,  -13.6034145,   67.0581436,  -3.63636374
  34161,  -14.1702242,    67.768898,  -3.63636374
  34162,  -14.7370329,   68.4796524,  -3.63636374
  34163,  -15.3038416,   69.1904068,  -3.63636374
  34164,  -15.8706512,   69.9011612,  -3.63636374
  34165,  -16.4374599,   70.6119232,  -3.63636374
  34166,  -17.0042686,   71.3226776,  -3.63636374
  34167,  -17.5710773,    72.033432,  -3.63636374
  34168,   -18.137888,   72.7441864,  -3.63636374
  34169,  -13.0366058,   66.3473892,   -4.5454545
  34170,  -13.6034145,   67.0581436,   -4.5454545
  34171,  -14.1702242,    67.768898,   -4.5454545
  34172,  -14.7370329,   68.4796524,   -4.5454545
  34173,  -15.3038416,   69.1904068,   -4.5454545
  34174,  -15.8706512,   69.9011612,   -4.5454545
  34175,  -16.4374599,   70.6119232,   -4.5454545
  34176,  -17.0042686,   71.3226776,   -4.5454545
  34177,  -17.5710773,    72.033432,   -4.5454545
  34178,   -18.137888,   72.7441864,   -4.5454545
  34179,  -13.0366058,   66.3473892,   -5.4545455
  34180,  -13.6034145,   67.0581436,   -5.4545455
  34181,  -14.1702242,    67.768898,   -5.4545455
  34182,  -14.7370329,   68.4796524,   -5.4545455
  34183,  -15.3038416,   69.1904068,   -5.4545455
  34184,  -15.8706512,   69.9011612,   -5.4545455
  34185,  -16.4374599,   70.6119232,   -5.4545455
  34186,  -17.0042686,   71.3226776,   -5.4545455
  34187,  -17.5710773,    72.033432,   -5.4545455
  34188,   -18.137888,   72.7441864,   -5.4545455
  34189,  -13.0366058,   66.3473892,  -6.36363649
  34190,  -13.6034145,   67.0581436,  -6.36363649
  34191,  -14.1702242,    67.768898,  -6.36363649
  34192,  -14.7370329,   68.4796524,  -6.36363649
  34193,  -15.3038416,   69.1904068,  -6.36363649
  34194,  -15.8706512,   69.9011612,  -6.36363649
  34195,  -16.4374599,   70.6119232,  -6.36363649
  34196,  -17.0042686,   71.3226776,  -6.36363649
  34197,  -17.5710773,    72.033432,  -6.36363649
  34198,   -18.137888,   72.7441864,  -6.36363649
  34199,  -13.0366058,   66.3473892,  -7.27272749
  34200,  -13.6034145,   67.0581436,  -7.27272749
  34201,  -14.1702242,    67.768898,  -7.27272749
  34202,  -14.7370329,   68.4796524,  -7.27272749
  34203,  -15.3038416,   69.1904068,  -7.27272749
  34204,  -15.8706512,   69.9011612,  -7.27272749
  34205,  -16.4374599,   70.6119232,  -7.27272749
  34206,  -17.0042686,   71.3226776,  -7.27272749
  34207,  -17.5710773,    72.033432,  -7.27272749
  34208,   -18.137888,   72.7441864,  -7.27272749
  34209,  -13.0366058,   66.3473892,  -8.18181801
  34210,  -13.6034145,   67.0581436,  -8.18181801
  34211,  -14.1702242,    67.768898,  -8.18181801
  34212,  -14.7370329,   68.4796524,  -8.18181801
  34213,  -15.3038416,   69.1904068,  -8.18181801
  34214,  -15.8706512,   69.9011612,  -8.18181801
  34215,  -16.4374599,   70.6119232,  -8.18181801
  34216,  -17.0042686,   71.3226776,  -8.18181801
  34217,  -17.5710773,    72.033432,  -8.18181801
  34218,   -18.137888,   72.7441864,  -8.18181801
  34219,  -13.0366058,   66.3473892,    -9.090909
  34220,  -13.6034145,   67.0581436,    -9.090909
  34221,  -14.1702242,    67.768898,    -9.090909
  34222,  -14.7370329,   68.4796524,    -9.090909
  34223,  -15.3038416,   69.1904068,    -9.090909
  34224,  -15.8706512,   69.9011612,    -9.090909
  34225,  -16.4374599,   70.6119232,    -9.090909
  34226,  -17.0042686,   71.3226776,    -9.090909
  34227,  -17.5710773,    72.033432,    -9.090909
  34228,   -18.137888,   72.7441864,    -9.090909
  34229,  -13.5538654,   65.9211426, -0.909090936
  34230,  -14.1431646,   66.6133652, -0.909090936
  34231,  -14.7324638,   67.3055878, -0.909090936
  34232,  -15.3217621,   67.9978104, -0.909090936
  34233,  -15.9110603,   68.6900406, -0.909090936
  34234,  -16.5003586,   69.3822632, -0.909090936
  34235,  -17.0896568,   70.0744858, -0.909090936
  34236,  -17.6789589,   70.7667084, -0.909090936
  34237,  -18.2682571,    71.458931, -0.909090936
  34238,  -18.8575554,   72.1511536, -0.909090936
  34239,  -13.5538654,   65.9211426,  -1.81818187
  34240,  -14.1431646,   66.6133652,  -1.81818187
  34241,  -14.7324638,   67.3055878,  -1.81818187
  34242,  -15.3217621,   67.9978104,  -1.81818187
  34243,  -15.9110603,   68.6900406,  -1.81818187
  34244,  -16.5003586,   69.3822632,  -1.81818187
  34245,  -17.0896568,   70.0744858,  -1.81818187
  34246,  -17.6789589,   70.7667084,  -1.81818187
  34247,  -18.2682571,    71.458931,  -1.81818187
  34248,  -18.8575554,   72.1511536,  -1.81818187
  34249,  -13.5538654,   65.9211426,  -2.72727275
  34250,  -14.1431646,   66.6133652,  -2.72727275
  34251,  -14.7324638,   67.3055878,  -2.72727275
  34252,  -15.3217621,   67.9978104,  -2.72727275
  34253,  -15.9110603,   68.6900406,  -2.72727275
  34254,  -16.5003586,   69.3822632,  -2.72727275
  34255,  -17.0896568,   70.0744858,  -2.72727275
  34256,  -17.6789589,   70.7667084,  -2.72727275
  34257,  -18.2682571,    71.458931,  -2.72727275
  34258,  -18.8575554,   72.1511536,  -2.72727275
  34259,  -13.5538654,   65.9211426,  -3.63636374
  34260,  -14.1431646,   66.6133652,  -3.63636374
  34261,  -14.7324638,   67.3055878,  -3.63636374
  34262,  -15.3217621,   67.9978104,  -3.63636374
  34263,  -15.9110603,   68.6900406,  -3.63636374
  34264,  -16.5003586,   69.3822632,  -3.63636374
  34265,  -17.0896568,   70.0744858,  -3.63636374
  34266,  -17.6789589,   70.7667084,  -3.63636374
  34267,  -18.2682571,    71.458931,  -3.63636374
  34268,  -18.8575554,   72.1511536,  -3.63636374
  34269,  -13.5538654,   65.9211426,   -4.5454545
  34270,  -14.1431646,   66.6133652,   -4.5454545
  34271,  -14.7324638,   67.3055878,   -4.5454545
  34272,  -15.3217621,   67.9978104,   -4.5454545
  34273,  -15.9110603,   68.6900406,   -4.5454545
  34274,  -16.5003586,   69.3822632,   -4.5454545
  34275,  -17.0896568,   70.0744858,   -4.5454545
  34276,  -17.6789589,   70.7667084,   -4.5454545
  34277,  -18.2682571,    71.458931,   -4.5454545
  34278,  -18.8575554,   72.1511536,   -4.5454545
  34279,  -13.5538654,   65.9211426,   -5.4545455
  34280,  -14.1431646,   66.6133652,   -5.4545455
  34281,  -14.7324638,   67.3055878,   -5.4545455
  34282,  -15.3217621,   67.9978104,   -5.4545455
  34283,  -15.9110603,   68.6900406,   -5.4545455
  34284,  -16.5003586,   69.3822632,   -5.4545455
  34285,  -17.0896568,   70.0744858,   -5.4545455
  34286,  -17.6789589,   70.7667084,   -5.4545455
  34287,  -18.2682571,    71.458931,   -5.4545455
  34288,  -18.8575554,   72.1511536,   -5.4545455
  34289,  -13.5538654,   65.9211426,  -6.36363649
  34290,  -14.1431646,   66.6133652,  -6.36363649
  34291,  -14.7324638,   67.3055878,  -6.36363649
  34292,  -15.3217621,   67.9978104,  -6.36363649
  34293,  -15.9110603,   68.6900406,  -6.36363649
  34294,  -16.5003586,   69.3822632,  -6.36363649
  34295,  -17.0896568,   70.0744858,  -6.36363649
  34296,  -17.6789589,   70.7667084,  -6.36363649
  34297,  -18.2682571,    71.458931,  -6.36363649
  34298,  -18.8575554,   72.1511536,  -6.36363649
  34299,  -13.5538654,   65.9211426,  -7.27272749
  34300,  -14.1431646,   66.6133652,  -7.27272749
  34301,  -14.7324638,   67.3055878,  -7.27272749
  34302,  -15.3217621,   67.9978104,  -7.27272749
  34303,  -15.9110603,   68.6900406,  -7.27272749
  34304,  -16.5003586,   69.3822632,  -7.27272749
  34305,  -17.0896568,   70.0744858,  -7.27272749
  34306,  -17.6789589,   70.7667084,  -7.27272749
  34307,  -18.2682571,    71.458931,  -7.27272749
  34308,  -18.8575554,   72.1511536,  -7.27272749
  34309,  -13.5538654,   65.9211426,  -8.18181801
  34310,  -14.1431646,   66.6133652,  -8.18181801
  34311,  -14.7324638,   67.3055878,  -8.18181801
  34312,  -15.3217621,   67.9978104,  -8.18181801
  34313,  -15.9110603,   68.6900406,  -8.18181801
  34314,  -16.5003586,   69.3822632,  -8.18181801
  34315,  -17.0896568,   70.0744858,  -8.18181801
  34316,  -17.6789589,   70.7667084,  -8.18181801
  34317,  -18.2682571,    71.458931,  -8.18181801
  34318,  -18.8575554,   72.1511536,  -8.18181801
  34319,  -13.5538654,   65.9211426,    -9.090909
  34320,  -14.1431646,   66.6133652,    -9.090909
  34321,  -14.7324638,   67.3055878,    -9.090909
  34322,  -15.3217621,   67.9978104,    -9.090909
  34323,  -15.9110603,   68.6900406,    -9.090909
  34324,  -16.5003586,   69.3822632,    -9.090909
  34325,  -17.0896568,   70.0744858,    -9.090909
  34326,  -17.6789589,   70.7667084,    -9.090909
  34327,  -18.2682571,    71.458931,    -9.090909
  34328,  -18.8575554,   72.1511536,    -9.090909
  34329,  -14.0572014,   65.4785385, -0.909090936
  34330,  -14.6683826,   66.1515198, -0.909090936
  34331,  -15.2795658,    66.824501, -0.909090936
  34332,   -15.890748,   67.4974823, -0.909090936
  34333,  -16.5019302,   68.1704636, -0.909090936
  34334,  -17.1131134,   68.8434372, -0.909090936
  34335,  -17.7242966,   69.5164185, -0.909090936
  34336,  -18.3354778,   70.1893997, -0.909090936
  34337,  -18.9466591,    70.862381, -0.909090936
  34338,  -19.5578423,   71.5353622, -0.909090936
  34339,  -14.0572014,   65.4785385,  -1.81818187
  34340,  -14.6683826,   66.1515198,  -1.81818187
  34341,  -15.2795658,    66.824501,  -1.81818187
  34342,   -15.890748,   67.4974823,  -1.81818187
  34343,  -16.5019302,   68.1704636,  -1.81818187
  34344,  -17.1131134,   68.8434372,  -1.81818187
  34345,  -17.7242966,   69.5164185,  -1.81818187
  34346,  -18.3354778,   70.1893997,  -1.81818187
  34347,  -18.9466591,    70.862381,  -1.81818187
  34348,  -19.5578423,   71.5353622,  -1.81818187
  34349,  -14.0572014,   65.4785385,  -2.72727275
  34350,  -14.6683826,   66.1515198,  -2.72727275
  34351,  -15.2795658,    66.824501,  -2.72727275
  34352,   -15.890748,   67.4974823,  -2.72727275
  34353,  -16.5019302,   68.1704636,  -2.72727275
  34354,  -17.1131134,   68.8434372,  -2.72727275
  34355,  -17.7242966,   69.5164185,  -2.72727275
  34356,  -18.3354778,   70.1893997,  -2.72727275
  34357,  -18.9466591,    70.862381,  -2.72727275
  34358,  -19.5578423,   71.5353622,  -2.72727275
  34359,  -14.0572014,   65.4785385,  -3.63636374
  34360,  -14.6683826,   66.1515198,  -3.63636374
  34361,  -15.2795658,    66.824501,  -3.63636374
  34362,   -15.890748,   67.4974823,  -3.63636374
  34363,  -16.5019302,   68.1704636,  -3.63636374
  34364,  -17.1131134,   68.8434372,  -3.63636374
  34365,  -17.7242966,   69.5164185,  -3.63636374
  34366,  -18.3354778,   70.1893997,  -3.63636374
  34367,  -18.9466591,    70.862381,  -3.63636374
  34368,  -19.5578423,   71.5353622,  -3.63636374
  34369,  -14.0572014,   65.4785385,   -4.5454545
  34370,  -14.6683826,   66.1515198,   -4.5454545
  34371,  -15.2795658,    66.824501,   -4.5454545
  34372,   -15.890748,   67.4974823,   -4.5454545
  34373,  -16.5019302,   68.1704636,   -4.5454545
  34374,  -17.1131134,   68.8434372,   -4.5454545
  34375,  -17.7242966,   69.5164185,   -4.5454545
  34376,  -18.3354778,   70.1893997,   -4.5454545
  34377,  -18.9466591,    70.862381,   -4.5454545
  34378,  -19.5578423,   71.5353622,   -4.5454545
  34379,  -14.0572014,   65.4785385,   -5.4545455
  34380,  -14.6683826,   66.1515198,   -5.4545455
  34381,  -15.2795658,    66.824501,   -5.4545455
  34382,   -15.890748,   67.4974823,   -5.4545455
  34383,  -16.5019302,   68.1704636,   -5.4545455
  34384,  -17.1131134,   68.8434372,   -5.4545455
  34385,  -17.7242966,   69.5164185,   -5.4545455
  34386,  -18.3354778,   70.1893997,   -5.4545455
  34387,  -18.9466591,    70.862381,   -5.4545455
  34388,  -19.5578423,   71.5353622,   -5.4545455
  34389,  -14.0572014,   65.4785385,  -6.36363649
  34390,  -14.6683826,   66.1515198,  -6.36363649
  34391,  -15.2795658,    66.824501,  -6.36363649
  34392,   -15.890748,   67.4974823,  -6.36363649
  34393,  -16.5019302,   68.1704636,  -6.36363649
  34394,  -17.1131134,   68.8434372,  -6.36363649
  34395,  -17.7242966,   69.5164185,  -6.36363649
  34396,  -18.3354778,   70.1893997,  -6.36363649
  34397,  -18.9466591,    70.862381,  -6.36363649
  34398,  -19.5578423,   71.5353622,  -6.36363649
  34399,  -14.0572014,   65.4785385,  -7.27272749
  34400,  -14.6683826,   66.1515198,  -7.27272749
  34401,  -15.2795658,    66.824501,  -7.27272749
  34402,   -15.890748,   67.4974823,  -7.27272749
  34403,  -16.5019302,   68.1704636,  -7.27272749
  34404,  -17.1131134,   68.8434372,  -7.27272749
  34405,  -17.7242966,   69.5164185,  -7.27272749
  34406,  -18.3354778,   70.1893997,  -7.27272749
  34407,  -18.9466591,    70.862381,  -7.27272749
  34408,  -19.5578423,   71.5353622,  -7.27272749
  34409,  -14.0572014,   65.4785385,  -8.18181801
  34410,  -14.6683826,   66.1515198,  -8.18181801
  34411,  -15.2795658,    66.824501,  -8.18181801
  34412,   -15.890748,   67.4974823,  -8.18181801
  34413,  -16.5019302,   68.1704636,  -8.18181801
  34414,  -17.1131134,   68.8434372,  -8.18181801
  34415,  -17.7242966,   69.5164185,  -8.18181801
  34416,  -18.3354778,   70.1893997,  -8.18181801
  34417,  -18.9466591,    70.862381,  -8.18181801
  34418,  -19.5578423,   71.5353622,  -8.18181801
  34419,  -14.0572014,   65.4785385,    -9.090909
  34420,  -14.6683826,   66.1515198,    -9.090909
  34421,  -15.2795658,    66.824501,    -9.090909
  34422,   -15.890748,   67.4974823,    -9.090909
  34423,  -16.5019302,   68.1704636,    -9.090909
  34424,  -17.1131134,   68.8434372,    -9.090909
  34425,  -17.7242966,   69.5164185,    -9.090909
  34426,  -18.3354778,   70.1893997,    -9.090909
  34427,  -18.9466591,    70.862381,    -9.090909
  34428,  -19.5578423,   71.5353622,    -9.090909
  34429,  -14.5460892,   65.0200348, -0.909090936
  34430,  -15.1785278,   65.6730804, -0.909090936
  34431,  -15.8109665,   66.3261185, -0.909090936
  34432,  -16.4434032,   66.9791641, -0.909090936
  34433,  -17.0758419,   67.6322098, -0.909090936
  34434,  -17.7082806,   68.2852554, -0.909090936
  34435,  -18.3407192,   68.9383011, -0.909090936
  34436,  -18.9731579,   69.5913467, -0.909090936
  34437,  -19.6055965,   70.2443924, -0.909090936
  34438,  -20.2380352,    70.897438, -0.909090936
  34439,  -14.5460892,   65.0200348,  -1.81818187
  34440,  -15.1785278,   65.6730804,  -1.81818187
  34441,  -15.8109665,   66.3261185,  -1.81818187
  34442,  -16.4434032,   66.9791641,  -1.81818187
  34443,  -17.0758419,   67.6322098,  -1.81818187
  34444,  -17.7082806,   68.2852554,  -1.81818187
  34445,  -18.3407192,   68.9383011,  -1.81818187
  34446,  -18.9731579,   69.5913467,  -1.81818187
  34447,  -19.6055965,   70.2443924,  -1.81818187
  34448,  -20.2380352,    70.897438,  -1.81818187
  34449,  -14.5460892,   65.0200348,  -2.72727275
  34450,  -15.1785278,   65.6730804,  -2.72727275
  34451,  -15.8109665,   66.3261185,  -2.72727275
  34452,  -16.4434032,   66.9791641,  -2.72727275
  34453,  -17.0758419,   67.6322098,  -2.72727275
  34454,  -17.7082806,   68.2852554,  -2.72727275
  34455,  -18.3407192,   68.9383011,  -2.72727275
  34456,  -18.9731579,   69.5913467,  -2.72727275
  34457,  -19.6055965,   70.2443924,  -2.72727275
  34458,  -20.2380352,    70.897438,  -2.72727275
  34459,  -14.5460892,   65.0200348,  -3.63636374
  34460,  -15.1785278,   65.6730804,  -3.63636374
  34461,  -15.8109665,   66.3261185,  -3.63636374
  34462,  -16.4434032,   66.9791641,  -3.63636374
  34463,  -17.0758419,   67.6322098,  -3.63636374
  34464,  -17.7082806,   68.2852554,  -3.63636374
  34465,  -18.3407192,   68.9383011,  -3.63636374
  34466,  -18.9731579,   69.5913467,  -3.63636374
  34467,  -19.6055965,   70.2443924,  -3.63636374
  34468,  -20.2380352,    70.897438,  -3.63636374
  34469,  -14.5460892,   65.0200348,   -4.5454545
  34470,  -15.1785278,   65.6730804,   -4.5454545
  34471,  -15.8109665,   66.3261185,   -4.5454545
  34472,  -16.4434032,   66.9791641,   -4.5454545
  34473,  -17.0758419,   67.6322098,   -4.5454545
  34474,  -17.7082806,   68.2852554,   -4.5454545
  34475,  -18.3407192,   68.9383011,   -4.5454545
  34476,  -18.9731579,   69.5913467,   -4.5454545
  34477,  -19.6055965,   70.2443924,   -4.5454545
  34478,  -20.2380352,    70.897438,   -4.5454545
  34479,  -14.5460892,   65.0200348,   -5.4545455
  34480,  -15.1785278,   65.6730804,   -5.4545455
  34481,  -15.8109665,   66.3261185,   -5.4545455
  34482,  -16.4434032,   66.9791641,   -5.4545455
  34483,  -17.0758419,   67.6322098,   -5.4545455
  34484,  -17.7082806,   68.2852554,   -5.4545455
  34485,  -18.3407192,   68.9383011,   -5.4545455
  34486,  -18.9731579,   69.5913467,   -5.4545455
  34487,  -19.6055965,   70.2443924,   -5.4545455
  34488,  -20.2380352,    70.897438,   -5.4545455
  34489,  -14.5460892,   65.0200348,  -6.36363649
  34490,  -15.1785278,   65.6730804,  -6.36363649
  34491,  -15.8109665,   66.3261185,  -6.36363649
  34492,  -16.4434032,   66.9791641,  -6.36363649
  34493,  -17.0758419,   67.6322098,  -6.36363649
  34494,  -17.7082806,   68.2852554,  -6.36363649
  34495,  -18.3407192,   68.9383011,  -6.36363649
  34496,  -18.9731579,   69.5913467,  -6.36363649
  34497,  -19.6055965,   70.2443924,  -6.36363649
  34498,  -20.2380352,    70.897438,  -6.36363649
  34499,  -14.5460892,   65.0200348,  -7.27272749
  34500,  -15.1785278,   65.6730804,  -7.27272749
  34501,  -15.8109665,   66.3261185,  -7.27272749
  34502,  -16.4434032,   66.9791641,  -7.27272749
  34503,  -17.0758419,   67.6322098,  -7.27272749
  34504,  -17.7082806,   68.2852554,  -7.27272749
  34505,  -18.3407192,   68.9383011,  -7.27272749
  34506,  -18.9731579,   69.5913467,  -7.27272749
  34507,  -19.6055965,   70.2443924,  -7.27272749
  34508,  -20.2380352,    70.897438,  -7.27272749
  34509,  -14.5460892,   65.0200348,  -8.18181801
  34510,  -15.1785278,   65.6730804,  -8.18181801
  34511,  -15.8109665,   66.3261185,  -8.18181801
  34512,  -16.4434032,   66.9791641,  -8.18181801
  34513,  -17.0758419,   67.6322098,  -8.18181801
  34514,  -17.7082806,   68.2852554,  -8.18181801
  34515,  -18.3407192,   68.9383011,  -8.18181801
  34516,  -18.9731579,   69.5913467,  -8.18181801
  34517,  -19.6055965,   70.2443924,  -8.18181801
  34518,  -20.2380352,    70.897438,  -8.18181801
  34519,  -14.5460892,   65.0200348,    -9.090909
  34520,  -15.1785278,   65.6730804,    -9.090909
  34521,  -15.8109665,   66.3261185,    -9.090909
  34522,  -16.4434032,   66.9791641,    -9.090909
  34523,  -17.0758419,   67.6322098,    -9.090909
  34524,  -17.7082806,   68.2852554,    -9.090909
  34525,  -18.3407192,   68.9383011,    -9.090909
  34526,  -18.9731579,   69.5913467,    -9.090909
  34527,  -19.6055965,   70.2443924,    -9.090909
  34528,  -20.2380352,    70.897438,    -9.090909
  34529,  -15.0200319,   64.5460892, -0.909090936
  34530,  -15.6730766,   65.1785278, -0.909090936
  34531,  -16.3261223,   65.8109665, -0.909090936
  34532,   -16.979166,   66.4434052, -0.909090936
  34533,  -17.6322117,   67.0758438, -0.909090936
  34534,  -18.2852554,   67.7082825, -0.909090936
  34535,  -18.9383011,   68.3407211, -0.909090936
  34536,  -19.5913467,   68.9731598, -0.909090936
  34537,  -20.2443905,   69.6055984, -0.909090936
  34538,  -20.8974361,   70.2380371, -0.909090936
  34539,  -15.0200319,   64.5460892,  -1.81818187
  34540,  -15.6730766,   65.1785278,  -1.81818187
  34541,  -16.3261223,   65.8109665,  -1.81818187
  34542,   -16.979166,   66.4434052,  -1.81818187
  34543,  -17.6322117,   67.0758438,  -1.81818187
  34544,  -18.2852554,   67.7082825,  -1.81818187
  34545,  -18.9383011,   68.3407211,  -1.81818187
  34546,  -19.5913467,   68.9731598,  -1.81818187
  34547,  -20.2443905,   69.6055984,  -1.81818187
  34548,  -20.8974361,   70.2380371,  -1.81818187
  34549,  -15.0200319,   64.5460892,  -2.72727275
  34550,  -15.6730766,   65.1785278,  -2.72727275
  34551,  -16.3261223,   65.8109665,  -2.72727275
  34552,   -16.979166,   66.4434052,  -2.72727275
  34553,  -17.6322117,   67.0758438,  -2.72727275
  34554,  -18.2852554,   67.7082825,  -2.72727275
  34555,  -18.9383011,   68.3407211,  -2.72727275
  34556,  -19.5913467,   68.9731598,  -2.72727275
  34557,  -20.2443905,   69.6055984,  -2.72727275
  34558,  -20.8974361,   70.2380371,  -2.72727275
  34559,  -15.0200319,   64.5460892,  -3.63636374
  34560,  -15.6730766,   65.1785278,  -3.63636374
  34561,  -16.3261223,   65.8109665,  -3.63636374
  34562,   -16.979166,   66.4434052,  -3.63636374
  34563,  -17.6322117,   67.0758438,  -3.63636374
  34564,  -18.2852554,   67.7082825,  -3.63636374
  34565,  -18.9383011,   68.3407211,  -3.63636374
  34566,  -19.5913467,   68.9731598,  -3.63636374
  34567,  -20.2443905,   69.6055984,  -3.63636374
  34568,  -20.8974361,   70.2380371,  -3.63636374
  34569,  -15.0200319,   64.5460892,   -4.5454545
  34570,  -15.6730766,   65.1785278,   -4.5454545
  34571,  -16.3261223,   65.8109665,   -4.5454545
  34572,   -16.979166,   66.4434052,   -4.5454545
  34573,  -17.6322117,   67.0758438,   -4.5454545
  34574,  -18.2852554,   67.7082825,   -4.5454545
  34575,  -18.9383011,   68.3407211,   -4.5454545
  34576,  -19.5913467,   68.9731598,   -4.5454545
  34577,  -20.2443905,   69.6055984,   -4.5454545
  34578,  -20.8974361,   70.2380371,   -4.5454545
  34579,  -15.0200319,   64.5460892,   -5.4545455
  34580,  -15.6730766,   65.1785278,   -5.4545455
  34581,  -16.3261223,   65.8109665,   -5.4545455
  34582,   -16.979166,   66.4434052,   -5.4545455
  34583,  -17.6322117,   67.0758438,   -5.4545455
  34584,  -18.2852554,   67.7082825,   -5.4545455
  34585,  -18.9383011,   68.3407211,   -5.4545455
  34586,  -19.5913467,   68.9731598,   -5.4545455
  34587,  -20.2443905,   69.6055984,   -5.4545455
  34588,  -20.8974361,   70.2380371,   -5.4545455
  34589,  -15.0200319,   64.5460892,  -6.36363649
  34590,  -15.6730766,   65.1785278,  -6.36363649
  34591,  -16.3261223,   65.8109665,  -6.36363649
  34592,   -16.979166,   66.4434052,  -6.36363649
  34593,  -17.6322117,   67.0758438,  -6.36363649
  34594,  -18.2852554,   67.7082825,  -6.36363649
  34595,  -18.9383011,   68.3407211,  -6.36363649
  34596,  -19.5913467,   68.9731598,  -6.36363649
  34597,  -20.2443905,   69.6055984,  -6.36363649
  34598,  -20.8974361,   70.2380371,  -6.36363649
  34599,  -15.0200319,   64.5460892,  -7.27272749
  34600,  -15.6730766,   65.1785278,  -7.27272749
  34601,  -16.3261223,   65.8109665,  -7.27272749
  34602,   -16.979166,   66.4434052,  -7.27272749
  34603,  -17.6322117,   67.0758438,  -7.27272749
  34604,  -18.2852554,   67.7082825,  -7.27272749
  34605,  -18.9383011,   68.3407211,  -7.27272749
  34606,  -19.5913467,   68.9731598,  -7.27272749
  34607,  -20.2443905,   69.6055984,  -7.27272749
  34608,  -20.8974361,   70.2380371,  -7.27272749
  34609,  -15.0200319,   64.5460892,  -8.18181801
  34610,  -15.6730766,   65.1785278,  -8.18181801
  34611,  -16.3261223,   65.8109665,  -8.18181801
  34612,   -16.979166,   66.4434052,  -8.18181801
  34613,  -17.6322117,   67.0758438,  -8.18181801
  34614,  -18.2852554,   67.7082825,  -8.18181801
  34615,  -18.9383011,   68.3407211,  -8.18181801
  34616,  -19.5913467,   68.9731598,  -8.18181801
  34617,  -20.2443905,   69.6055984,  -8.18181801
  34618,  -20.8974361,   70.2380371,  -8.18181801
  34619,  -15.0200319,   64.5460892,    -9.090909
  34620,  -15.6730766,   65.1785278,    -9.090909
  34621,  -16.3261223,   65.8109665,    -9.090909
  34622,   -16.979166,   66.4434052,    -9.090909
  34623,  -17.6322117,   67.0758438,    -9.090909
  34624,  -18.2852554,   67.7082825,    -9.090909
  34625,  -18.9383011,   68.3407211,    -9.090909
  34626,  -19.5913467,   68.9731598,    -9.090909
  34627,  -20.2443905,   69.6055984,    -9.090909
  34628,  -20.8974361,   70.2380371,    -9.090909
  34629,  -15.4785395,   64.0571976, -0.909090936
  34630,  -16.1515198,   64.6683807, -0.909090936
  34631,  -16.8244991,   65.2795639, -0.909090936
  34632,  -17.4974804,   65.8907471, -0.909090936
  34633,  -18.1704597,   66.5019302, -0.909090936
  34634,  -18.8434372,   67.1131134, -0.909090936
  34635,  -19.5164185,   67.7242966, -0.909090936
  34636,  -20.1893978,   68.3354797, -0.909090936
  34637,  -20.8623772,   68.9466629, -0.909090936
  34638,  -21.5353584,   69.5578461, -0.909090936
  34639,  -15.4785395,   64.0571976,  -1.81818187
  34640,  -16.1515198,   64.6683807,  -1.81818187
  34641,  -16.8244991,   65.2795639,  -1.81818187
  34642,  -17.4974804,   65.8907471,  -1.81818187
  34643,  -18.1704597,   66.5019302,  -1.81818187
  34644,  -18.8434372,   67.1131134,  -1.81818187
  34645,  -19.5164185,   67.7242966,  -1.81818187
  34646,  -20.1893978,   68.3354797,  -1.81818187
  34647,  -20.8623772,   68.9466629,  -1.81818187
  34648,  -21.5353584,   69.5578461,  -1.81818187
  34649,  -15.4785395,   64.0571976,  -2.72727275
  34650,  -16.1515198,   64.6683807,  -2.72727275
  34651,  -16.8244991,   65.2795639,  -2.72727275
  34652,  -17.4974804,   65.8907471,  -2.72727275
  34653,  -18.1704597,   66.5019302,  -2.72727275
  34654,  -18.8434372,   67.1131134,  -2.72727275
  34655,  -19.5164185,   67.7242966,  -2.72727275
  34656,  -20.1893978,   68.3354797,  -2.72727275
  34657,  -20.8623772,   68.9466629,  -2.72727275
  34658,  -21.5353584,   69.5578461,  -2.72727275
  34659,  -15.4785395,   64.0571976,  -3.63636374
  34660,  -16.1515198,   64.6683807,  -3.63636374
  34661,  -16.8244991,   65.2795639,  -3.63636374
  34662,  -17.4974804,   65.8907471,  -3.63636374
  34663,  -18.1704597,   66.5019302,  -3.63636374
  34664,  -18.8434372,   67.1131134,  -3.63636374
  34665,  -19.5164185,   67.7242966,  -3.63636374
  34666,  -20.1893978,   68.3354797,  -3.63636374
  34667,  -20.8623772,   68.9466629,  -3.63636374
  34668,  -21.5353584,   69.5578461,  -3.63636374
  34669,  -15.4785395,   64.0571976,   -4.5454545
  34670,  -16.1515198,   64.6683807,   -4.5454545
  34671,  -16.8244991,   65.2795639,   -4.5454545
  34672,  -17.4974804,   65.8907471,   -4.5454545
  34673,  -18.1704597,   66.5019302,   -4.5454545
  34674,  -18.8434372,   67.1131134,   -4.5454545
  34675,  -19.5164185,   67.7242966,   -4.5454545
  34676,  -20.1893978,   68.3354797,   -4.5454545
  34677,  -20.8623772,   68.9466629,   -4.5454545
  34678,  -21.5353584,   69.5578461,   -4.5454545
  34679,  -15.4785395,   64.0571976,   -5.4545455
  34680,  -16.1515198,   64.6683807,   -5.4545455
  34681,  -16.8244991,   65.2795639,   -5.4545455
  34682,  -17.4974804,   65.8907471,   -5.4545455
  34683,  -18.1704597,   66.5019302,   -5.4545455
  34684,  -18.8434372,   67.1131134,   -5.4545455
  34685,  -19.5164185,   67.7242966,   -5.4545455
  34686,  -20.1893978,   68.3354797,   -5.4545455
  34687,  -20.8623772,   68.9466629,   -5.4545455
  34688,  -21.5353584,   69.5578461,   -5.4545455
  34689,  -15.4785395,   64.0571976,  -6.36363649
  34690,  -16.1515198,   64.6683807,  -6.36363649
  34691,  -16.8244991,   65.2795639,  -6.36363649
  34692,  -17.4974804,   65.8907471,  -6.36363649
  34693,  -18.1704597,   66.5019302,  -6.36363649
  34694,  -18.8434372,   67.1131134,  -6.36363649
  34695,  -19.5164185,   67.7242966,  -6.36363649
  34696,  -20.1893978,   68.3354797,  -6.36363649
  34697,  -20.8623772,   68.9466629,  -6.36363649
  34698,  -21.5353584,   69.5578461,  -6.36363649
  34699,  -15.4785395,   64.0571976,  -7.27272749
  34700,  -16.1515198,   64.6683807,  -7.27272749
  34701,  -16.8244991,   65.2795639,  -7.27272749
  34702,  -17.4974804,   65.8907471,  -7.27272749
  34703,  -18.1704597,   66.5019302,  -7.27272749
  34704,  -18.8434372,   67.1131134,  -7.27272749
  34705,  -19.5164185,   67.7242966,  -7.27272749
  34706,  -20.1893978,   68.3354797,  -7.27272749
  34707,  -20.8623772,   68.9466629,  -7.27272749
  34708,  -21.5353584,   69.5578461,  -7.27272749
  34709,  -15.4785395,   64.0571976,  -8.18181801
  34710,  -16.1515198,   64.6683807,  -8.18181801
  34711,  -16.8244991,   65.2795639,  -8.18181801
  34712,  -17.4974804,   65.8907471,  -8.18181801
  34713,  -18.1704597,   66.5019302,  -8.18181801
  34714,  -18.8434372,   67.1131134,  -8.18181801
  34715,  -19.5164185,   67.7242966,  -8.18181801
  34716,  -20.1893978,   68.3354797,  -8.18181801
  34717,  -20.8623772,   68.9466629,  -8.18181801
  34718,  -21.5353584,   69.5578461,  -8.18181801
  34719,  -15.4785395,   64.0571976,    -9.090909
  34720,  -16.1515198,   64.6683807,    -9.090909
  34721,  -16.8244991,   65.2795639,    -9.090909
  34722,  -17.4974804,   65.8907471,    -9.090909
  34723,  -18.1704597,   66.5019302,    -9.090909
  34724,  -18.8434372,   67.1131134,    -9.090909
  34725,  -19.5164185,   67.7242966,    -9.090909
  34726,  -20.1893978,   68.3354797,    -9.090909
  34727,  -20.8623772,   68.9466629,    -9.090909
  34728,  -21.5353584,   69.5578461,    -9.090909
  34729,  -15.9211416,   63.5538673, -0.909090936
  34730,  -16.6133671,   64.1431656, -0.909090936
  34731,  -17.3055897,     64.73246, -0.909090936
  34732,  -17.9978142,   65.3217621, -0.909090936
  34733,  -18.6900368,   65.9110641, -0.909090936
  34734,  -19.3822613,   66.5003586, -0.909090936
  34735,  -20.0744839,   67.0896606, -0.909090936
  34736,  -20.7667084,   67.6789551, -0.909090936
  34737,   -21.458931,   68.2682571, -0.909090936
  34738,  -22.1511555,   68.8575516, -0.909090936
  34739,  -15.9211416,   63.5538673,  -1.81818187
  34740,  -16.6133671,   64.1431656,  -1.81818187
  34741,  -17.3055897,     64.73246,  -1.81818187
  34742,  -17.9978142,   65.3217621,  -1.81818187
  34743,  -18.6900368,   65.9110641,  -1.81818187
  34744,  -19.3822613,   66.5003586,  -1.81818187
  34745,  -20.0744839,   67.0896606,  -1.81818187
  34746,  -20.7667084,   67.6789551,  -1.81818187
  34747,   -21.458931,   68.2682571,  -1.81818187
  34748,  -22.1511555,   68.8575516,  -1.81818187
  34749,  -15.9211416,   63.5538673,  -2.72727275
  34750,  -16.6133671,   64.1431656,  -2.72727275
  34751,  -17.3055897,     64.73246,  -2.72727275
  34752,  -17.9978142,   65.3217621,  -2.72727275
  34753,  -18.6900368,   65.9110641,  -2.72727275
  34754,  -19.3822613,   66.5003586,  -2.72727275
  34755,  -20.0744839,   67.0896606,  -2.72727275
  34756,  -20.7667084,   67.6789551,  -2.72727275
  34757,   -21.458931,   68.2682571,  -2.72727275
  34758,  -22.1511555,   68.8575516,  -2.72727275
  34759,  -15.9211416,   63.5538673,  -3.63636374
  34760,  -16.6133671,   64.1431656,  -3.63636374
  34761,  -17.3055897,     64.73246,  -3.63636374
  34762,  -17.9978142,   65.3217621,  -3.63636374
  34763,  -18.6900368,   65.9110641,  -3.63636374
  34764,  -19.3822613,   66.5003586,  -3.63636374
  34765,  -20.0744839,   67.0896606,  -3.63636374
  34766,  -20.7667084,   67.6789551,  -3.63636374
  34767,   -21.458931,   68.2682571,  -3.63636374
  34768,  -22.1511555,   68.8575516,  -3.63636374
  34769,  -15.9211416,   63.5538673,   -4.5454545
  34770,  -16.6133671,   64.1431656,   -4.5454545
  34771,  -17.3055897,     64.73246,   -4.5454545
  34772,  -17.9978142,   65.3217621,   -4.5454545
  34773,  -18.6900368,   65.9110641,   -4.5454545
  34774,  -19.3822613,   66.5003586,   -4.5454545
  34775,  -20.0744839,   67.0896606,   -4.5454545
  34776,  -20.7667084,   67.6789551,   -4.5454545
  34777,   -21.458931,   68.2682571,   -4.5454545
  34778,  -22.1511555,   68.8575516,   -4.5454545
  34779,  -15.9211416,   63.5538673,   -5.4545455
  34780,  -16.6133671,   64.1431656,   -5.4545455
  34781,  -17.3055897,     64.73246,   -5.4545455
  34782,  -17.9978142,   65.3217621,   -5.4545455
  34783,  -18.6900368,   65.9110641,   -5.4545455
  34784,  -19.3822613,   66.5003586,   -5.4545455
  34785,  -20.0744839,   67.0896606,   -5.4545455
  34786,  -20.7667084,   67.6789551,   -5.4545455
  34787,   -21.458931,   68.2682571,   -5.4545455
  34788,  -22.1511555,   68.8575516,   -5.4545455
  34789,  -15.9211416,   63.5538673,  -6.36363649
  34790,  -16.6133671,   64.1431656,  -6.36363649
  34791,  -17.3055897,     64.73246,  -6.36363649
  34792,  -17.9978142,   65.3217621,  -6.36363649
  34793,  -18.6900368,   65.9110641,  -6.36363649
  34794,  -19.3822613,   66.5003586,  -6.36363649
  34795,  -20.0744839,   67.0896606,  -6.36363649
  34796,  -20.7667084,   67.6789551,  -6.36363649
  34797,   -21.458931,   68.2682571,  -6.36363649
  34798,  -22.1511555,   68.8575516,  -6.36363649
  34799,  -15.9211416,   63.5538673,  -7.27272749
  34800,  -16.6133671,   64.1431656,  -7.27272749
  34801,  -17.3055897,     64.73246,  -7.27272749
  34802,  -17.9978142,   65.3217621,  -7.27272749
  34803,  -18.6900368,   65.9110641,  -7.27272749
  34804,  -19.3822613,   66.5003586,  -7.27272749
  34805,  -20.0744839,   67.0896606,  -7.27272749
  34806,  -20.7667084,   67.6789551,  -7.27272749
  34807,   -21.458931,   68.2682571,  -7.27272749
  34808,  -22.1511555,   68.8575516,  -7.27272749
  34809,  -15.9211416,   63.5538673,  -8.18181801
  34810,  -16.6133671,   64.1431656,  -8.18181801
  34811,  -17.3055897,     64.73246,  -8.18181801
  34812,  -17.9978142,   65.3217621,  -8.18181801
  34813,  -18.6900368,   65.9110641,  -8.18181801
  34814,  -19.3822613,   66.5003586,  -8.18181801
  34815,  -20.0744839,   67.0896606,  -8.18181801
  34816,  -20.7667084,   67.6789551,  -8.18181801
  34817,   -21.458931,   68.2682571,  -8.18181801
  34818,  -22.1511555,   68.8575516,  -8.18181801
  34819,  -15.9211416,   63.5538673,    -9.090909
  34820,  -16.6133671,   64.1431656,    -9.090909
  34821,  -17.3055897,     64.73246,    -9.090909
  34822,  -17.9978142,   65.3217621,    -9.090909
  34823,  -18.6900368,   65.9110641,    -9.090909
  34824,  -19.3822613,   66.5003586,    -9.090909
  34825,  -20.0744839,   67.0896606,    -9.090909
  34826,  -20.7667084,   67.6789551,    -9.090909
  34827,   -21.458931,   68.2682571,    -9.090909
  34828,  -22.1511555,   68.8575516,    -9.090909
  34829,  -16.3473854,   63.0366058, -0.909090936
  34830,  -17.0581417,   63.6034126, -0.909090936
  34831,   -17.768898,   64.1702194, -0.909090936
  34832,  -18.4796524,     64.73703, -0.909090936
  34833,  -19.1904087,   65.3038406, -0.909090936
  34834,  -19.9011631,   65.8706512, -0.909090936
  34835,  -20.6119194,   66.4374619, -0.909090936
  34836,  -21.3226757,   67.0042648, -0.909090936
  34837,  -22.0334301,   67.5710754, -0.909090936
  34838,  -22.7441864,    68.137886, -0.909090936
  34839,  -16.3473854,   63.0366058,  -1.81818187
  34840,  -17.0581417,   63.6034126,  -1.81818187
  34841,   -17.768898,   64.1702194,  -1.81818187
  34842,  -18.4796524,     64.73703,  -1.81818187
  34843,  -19.1904087,   65.3038406,  -1.81818187
  34844,  -19.9011631,   65.8706512,  -1.81818187
  34845,  -20.6119194,   66.4374619,  -1.81818187
  34846,  -21.3226757,   67.0042648,  -1.81818187
  34847,  -22.0334301,   67.5710754,  -1.81818187
  34848,  -22.7441864,    68.137886,  -1.81818187
  34849,  -16.3473854,   63.0366058,  -2.72727275
  34850,  -17.0581417,   63.6034126,  -2.72727275
  34851,   -17.768898,   64.1702194,  -2.72727275
  34852,  -18.4796524,     64.73703,  -2.72727275
  34853,  -19.1904087,   65.3038406,  -2.72727275
  34854,  -19.9011631,   65.8706512,  -2.72727275
  34855,  -20.6119194,   66.4374619,  -2.72727275
  34856,  -21.3226757,   67.0042648,  -2.72727275
  34857,  -22.0334301,   67.5710754,  -2.72727275
  34858,  -22.7441864,    68.137886,  -2.72727275
  34859,  -16.3473854,   63.0366058,  -3.63636374
  34860,  -17.0581417,   63.6034126,  -3.63636374
  34861,   -17.768898,   64.1702194,  -3.63636374
  34862,  -18.4796524,     64.73703,  -3.63636374
  34863,  -19.1904087,   65.3038406,  -3.63636374
  34864,  -19.9011631,   65.8706512,  -3.63636374
  34865,  -20.6119194,   66.4374619,  -3.63636374
  34866,  -21.3226757,   67.0042648,  -3.63636374
  34867,  -22.0334301,   67.5710754,  -3.63636374
  34868,  -22.7441864,    68.137886,  -3.63636374
  34869,  -16.3473854,   63.0366058,   -4.5454545
  34870,  -17.0581417,   63.6034126,   -4.5454545
  34871,   -17.768898,   64.1702194,   -4.5454545
  34872,  -18.4796524,     64.73703,   -4.5454545
  34873,  -19.1904087,   65.3038406,   -4.5454545
  34874,  -19.9011631,   65.8706512,   -4.5454545
  34875,  -20.6119194,   66.4374619,   -4.5454545
  34876,  -21.3226757,   67.0042648,   -4.5454545
  34877,  -22.0334301,   67.5710754,   -4.5454545
  34878,  -22.7441864,    68.137886,   -4.5454545
  34879,  -16.3473854,   63.0366058,   -5.4545455
  34880,  -17.0581417,   63.6034126,   -5.4545455
  34881,   -17.768898,   64.1702194,   -5.4545455
  34882,  -18.4796524,     64.73703,   -5.4545455
  34883,  -19.1904087,   65.3038406,   -5.4545455
  34884,  -19.9011631,   65.8706512,   -5.4545455
  34885,  -20.6119194,   66.4374619,   -5.4545455
  34886,  -21.3226757,   67.0042648,   -5.4545455
  34887,  -22.0334301,   67.5710754,   -5.4545455
  34888,  -22.7441864,    68.137886,   -5.4545455
  34889,  -16.3473854,   63.0366058,  -6.36363649
  34890,  -17.0581417,   63.6034126,  -6.36363649
  34891,   -17.768898,   64.1702194,  -6.36363649
  34892,  -18.4796524,     64.73703,  -6.36363649
  34893,  -19.1904087,   65.3038406,  -6.36363649
  34894,  -19.9011631,   65.8706512,  -6.36363649
  34895,  -20.6119194,   66.4374619,  -6.36363649
  34896,  -21.3226757,   67.0042648,  -6.36363649
  34897,  -22.0334301,   67.5710754,  -6.36363649
  34898,  -22.7441864,    68.137886,  -6.36363649
  34899,  -16.3473854,   63.0366058,  -7.27272749
  34900,  -17.0581417,   63.6034126,  -7.27272749
  34901,   -17.768898,   64.1702194,  -7.27272749
  34902,  -18.4796524,     64.73703,  -7.27272749
  34903,  -19.1904087,   65.3038406,  -7.27272749
  34904,  -19.9011631,   65.8706512,  -7.27272749
  34905,  -20.6119194,   66.4374619,  -7.27272749
  34906,  -21.3226757,   67.0042648,  -7.27272749
  34907,  -22.0334301,   67.5710754,  -7.27272749
  34908,  -22.7441864,    68.137886,  -7.27272749
  34909,  -16.3473854,   63.0366058,  -8.18181801
  34910,  -17.0581417,   63.6034126,  -8.18181801
  34911,   -17.768898,   64.1702194,  -8.18181801
  34912,  -18.4796524,     64.73703,  -8.18181801
  34913,  -19.1904087,   65.3038406,  -8.18181801
  34914,  -19.9011631,   65.8706512,  -8.18181801
  34915,  -20.6119194,   66.4374619,  -8.18181801
  34916,  -21.3226757,   67.0042648,  -8.18181801
  34917,  -22.0334301,   67.5710754,  -8.18181801
  34918,  -22.7441864,    68.137886,  -8.18181801
  34919,  -16.3473854,   63.0366058,    -9.090909
  34920,  -17.0581417,   63.6034126,    -9.090909
  34921,   -17.768898,   64.1702194,    -9.090909
  34922,  -18.4796524,     64.73703,    -9.090909
  34923,  -19.1904087,   65.3038406,    -9.090909
  34924,  -19.9011631,   65.8706512,    -9.090909
  34925,  -20.6119194,   66.4374619,    -9.090909
  34926,  -21.3226757,   67.0042648,    -9.090909
  34927,  -22.0334301,   67.5710754,    -9.090909
  34928,  -22.7441864,    68.137886,    -9.090909
  34929,  -16.7568302,   62.5059471, -0.909090936
  34930,  -17.4853878,   63.0496826, -0.909090936
  34931,  -18.2139454,   63.5934219, -0.909090936
  34932,   -18.942503,   64.1371613, -0.909090936
  34933,  -19.6710625,   64.6808929, -0.909090936
  34934,   -20.399622,   65.2246323, -0.909090936
  34935,  -21.1281796,   65.7683716, -0.909090936
  34936,  -21.8567371,   66.3121033, -0.909090936
  34937,  -22.5852947,   66.8558426, -0.909090936
  34938,  -23.3138523,   67.3995819, -0.909090936
  34939,  -16.7568302,   62.5059471,  -1.81818187
  34940,  -17.4853878,   63.0496826,  -1.81818187
  34941,  -18.2139454,   63.5934219,  -1.81818187
  34942,   -18.942503,   64.1371613,  -1.81818187
  34943,  -19.6710625,   64.6808929,  -1.81818187
  34944,   -20.399622,   65.2246323,  -1.81818187
  34945,  -21.1281796,   65.7683716,  -1.81818187
  34946,  -21.8567371,   66.3121033,  -1.81818187
  34947,  -22.5852947,   66.8558426,  -1.81818187
  34948,  -23.3138523,   67.3995819,  -1.81818187
  34949,  -16.7568302,   62.5059471,  -2.72727275
  34950,  -17.4853878,   63.0496826,  -2.72727275
  34951,  -18.2139454,   63.5934219,  -2.72727275
  34952,   -18.942503,   64.1371613,  -2.72727275
  34953,  -19.6710625,   64.6808929,  -2.72727275
  34954,   -20.399622,   65.2246323,  -2.72727275
  34955,  -21.1281796,   65.7683716,  -2.72727275
  34956,  -21.8567371,   66.3121033,  -2.72727275
  34957,  -22.5852947,   66.8558426,  -2.72727275
  34958,  -23.3138523,   67.3995819,  -2.72727275
  34959,  -16.7568302,   62.5059471,  -3.63636374
  34960,  -17.4853878,   63.0496826,  -3.63636374
  34961,  -18.2139454,   63.5934219,  -3.63636374
  34962,   -18.942503,   64.1371613,  -3.63636374
  34963,  -19.6710625,   64.6808929,  -3.63636374
  34964,   -20.399622,   65.2246323,  -3.63636374
  34965,  -21.1281796,   65.7683716,  -3.63636374
  34966,  -21.8567371,   66.3121033,  -3.63636374
  34967,  -22.5852947,   66.8558426,  -3.63636374
  34968,  -23.3138523,   67.3995819,  -3.63636374
  34969,  -16.7568302,   62.5059471,   -4.5454545
  34970,  -17.4853878,   63.0496826,   -4.5454545
  34971,  -18.2139454,   63.5934219,   -4.5454545
  34972,   -18.942503,   64.1371613,   -4.5454545
  34973,  -19.6710625,   64.6808929,   -4.5454545
  34974,   -20.399622,   65.2246323,   -4.5454545
  34975,  -21.1281796,   65.7683716,   -4.5454545
  34976,  -21.8567371,   66.3121033,   -4.5454545
  34977,  -22.5852947,   66.8558426,   -4.5454545
  34978,  -23.3138523,   67.3995819,   -4.5454545
  34979,  -16.7568302,   62.5059471,   -5.4545455
  34980,  -17.4853878,   63.0496826,   -5.4545455
  34981,  -18.2139454,   63.5934219,   -5.4545455
  34982,   -18.942503,   64.1371613,   -5.4545455
  34983,  -19.6710625,   64.6808929,   -5.4545455
  34984,   -20.399622,   65.2246323,   -5.4545455
  34985,  -21.1281796,   65.7683716,   -5.4545455
  34986,  -21.8567371,   66.3121033,   -5.4545455
  34987,  -22.5852947,   66.8558426,   -5.4545455
  34988,  -23.3138523,   67.3995819,   -5.4545455
  34989,  -16.7568302,   62.5059471,  -6.36363649
  34990,  -17.4853878,   63.0496826,  -6.36363649
  34991,  -18.2139454,   63.5934219,  -6.36363649
  34992,   -18.942503,   64.1371613,  -6.36363649
  34993,  -19.6710625,   64.6808929,  -6.36363649
  34994,   -20.399622,   65.2246323,  -6.36363649
  34995,  -21.1281796,   65.7683716,  -6.36363649
  34996,  -21.8567371,   66.3121033,  -6.36363649
  34997,  -22.5852947,   66.8558426,  -6.36363649
  34998,  -23.3138523,   67.3995819,  -6.36363649
  34999,  -16.7568302,   62.5059471,  -7.27272749
  35000,  -17.4853878,   63.0496826,  -7.27272749
  35001,  -18.2139454,   63.5934219,  -7.27272749
  35002,   -18.942503,   64.1371613,  -7.27272749
  35003,  -19.6710625,   64.6808929,  -7.27272749
  35004,   -20.399622,   65.2246323,  -7.27272749
  35005,  -21.1281796,   65.7683716,  -7.27272749
  35006,  -21.8567371,   66.3121033,  -7.27272749
  35007,  -22.5852947,   66.8558426,  -7.27272749
  35008,  -23.3138523,   67.3995819,  -7.27272749
  35009,  -16.7568302,   62.5059471,  -8.18181801
  35010,  -17.4853878,   63.0496826,  -8.18181801
  35011,  -18.2139454,   63.5934219,  -8.18181801
  35012,   -18.942503,   64.1371613,  -8.18181801
  35013,  -19.6710625,   64.6808929,  -8.18181801
  35014,   -20.399622,   65.2246323,  -8.18181801
  35015,  -21.1281796,   65.7683716,  -8.18181801
  35016,  -21.8567371,   66.3121033,  -8.18181801
  35017,  -22.5852947,   66.8558426,  -8.18181801
  35018,  -23.3138523,   67.3995819,  -8.18181801
  35019,  -16.7568302,   62.5059471,    -9.090909
  35020,  -17.4853878,   63.0496826,    -9.090909
  35021,  -18.2139454,   63.5934219,    -9.090909
  35022,   -18.942503,   64.1371613,    -9.090909
  35023,  -19.6710625,   64.6808929,    -9.090909
  35024,   -20.399622,   65.2246323,    -9.090909
  35025,  -21.1281796,   65.7683716,    -9.090909
  35026,  -21.8567371,   66.3121033,    -9.090909
  35027,  -22.5852947,   66.8558426,    -9.090909
  35028,  -23.3138523,   67.3995819,    -9.090909
  35029,  -17.1490555,   61.9624405, -0.909090936
  35030,  -17.8946667,   62.4825439, -0.909090936
  35031,  -18.6402779,   63.0026512, -0.909090936
  35032,  -19.3858891,   63.5227585, -0.909090936
  35033,  -20.1315002,   64.0428619, -0.909090936
  35034,  -20.8771133,    64.562973, -0.909090936
  35035,  -21.6227245,   65.0830765, -0.909090936
  35036,  -22.3683357,   65.6031799, -0.909090936
  35037,  -23.1139469,    66.123291, -0.909090936
  35038,  -23.8595581,   66.6433945, -0.909090936
  35039,  -17.1490555,   61.9624405,  -1.81818187
  35040,  -17.8946667,   62.4825439,  -1.81818187
  35041,  -18.6402779,   63.0026512,  -1.81818187
  35042,  -19.3858891,   63.5227585,  -1.81818187
  35043,  -20.1315002,   64.0428619,  -1.81818187
  35044,  -20.8771133,    64.562973,  -1.81818187
  35045,  -21.6227245,   65.0830765,  -1.81818187
  35046,  -22.3683357,   65.6031799,  -1.81818187
  35047,  -23.1139469,    66.123291,  -1.81818187
  35048,  -23.8595581,   66.6433945,  -1.81818187
  35049,  -17.1490555,   61.9624405,  -2.72727275
  35050,  -17.8946667,   62.4825439,  -2.72727275
  35051,  -18.6402779,   63.0026512,  -2.72727275
  35052,  -19.3858891,   63.5227585,  -2.72727275
  35053,  -20.1315002,   64.0428619,  -2.72727275
  35054,  -20.8771133,    64.562973,  -2.72727275
  35055,  -21.6227245,   65.0830765,  -2.72727275
  35056,  -22.3683357,   65.6031799,  -2.72727275
  35057,  -23.1139469,    66.123291,  -2.72727275
  35058,  -23.8595581,   66.6433945,  -2.72727275
  35059,  -17.1490555,   61.9624405,  -3.63636374
  35060,  -17.8946667,   62.4825439,  -3.63636374
  35061,  -18.6402779,   63.0026512,  -3.63636374
  35062,  -19.3858891,   63.5227585,  -3.63636374
  35063,  -20.1315002,   64.0428619,  -3.63636374
  35064,  -20.8771133,    64.562973,  -3.63636374
  35065,  -21.6227245,   65.0830765,  -3.63636374
  35066,  -22.3683357,   65.6031799,  -3.63636374
  35067,  -23.1139469,    66.123291,  -3.63636374
  35068,  -23.8595581,   66.6433945,  -3.63636374
  35069,  -17.1490555,   61.9624405,   -4.5454545
  35070,  -17.8946667,   62.4825439,   -4.5454545
  35071,  -18.6402779,   63.0026512,   -4.5454545
  35072,  -19.3858891,   63.5227585,   -4.5454545
  35073,  -20.1315002,   64.0428619,   -4.5454545
  35074,  -20.8771133,    64.562973,   -4.5454545
  35075,  -21.6227245,   65.0830765,   -4.5454545
  35076,  -22.3683357,   65.6031799,   -4.5454545
  35077,  -23.1139469,    66.123291,   -4.5454545
  35078,  -23.8595581,   66.6433945,   -4.5454545
  35079,  -17.1490555,   61.9624405,   -5.4545455
  35080,  -17.8946667,   62.4825439,   -5.4545455
  35081,  -18.6402779,   63.0026512,   -5.4545455
  35082,  -19.3858891,   63.5227585,   -5.4545455
  35083,  -20.1315002,   64.0428619,   -5.4545455
  35084,  -20.8771133,    64.562973,   -5.4545455
  35085,  -21.6227245,   65.0830765,   -5.4545455
  35086,  -22.3683357,   65.6031799,   -5.4545455
  35087,  -23.1139469,    66.123291,   -5.4545455
  35088,  -23.8595581,   66.6433945,   -5.4545455
  35089,  -17.1490555,   61.9624405,  -6.36363649
  35090,  -17.8946667,   62.4825439,  -6.36363649
  35091,  -18.6402779,   63.0026512,  -6.36363649
  35092,  -19.3858891,   63.5227585,  -6.36363649
  35093,  -20.1315002,   64.0428619,  -6.36363649
  35094,  -20.8771133,    64.562973,  -6.36363649
  35095,  -21.6227245,   65.0830765,  -6.36363649
  35096,  -22.3683357,   65.6031799,  -6.36363649
  35097,  -23.1139469,    66.123291,  -6.36363649
  35098,  -23.8595581,   66.6433945,  -6.36363649
  35099,  -17.1490555,   61.9624405,  -7.27272749
  35100,  -17.8946667,   62.4825439,  -7.27272749
  35101,  -18.6402779,   63.0026512,  -7.27272749
  35102,  -19.3858891,   63.5227585,  -7.27272749
  35103,  -20.1315002,   64.0428619,  -7.27272749
  35104,  -20.8771133,    64.562973,  -7.27272749
  35105,  -21.6227245,   65.0830765,  -7.27272749
  35106,  -22.3683357,   65.6031799,  -7.27272749
  35107,  -23.1139469,    66.123291,  -7.27272749
  35108,  -23.8595581,   66.6433945,  -7.27272749
  35109,  -17.1490555,   61.9624405,  -8.18181801
  35110,  -17.8946667,   62.4825439,  -8.18181801
  35111,  -18.6402779,   63.0026512,  -8.18181801
  35112,  -19.3858891,   63.5227585,  -8.18181801
  35113,  -20.1315002,   64.0428619,  -8.18181801
  35114,  -20.8771133,    64.562973,  -8.18181801
  35115,  -21.6227245,   65.0830765,  -8.18181801
  35116,  -22.3683357,   65.6031799,  -8.18181801
  35117,  -23.1139469,    66.123291,  -8.18181801
  35118,  -23.8595581,   66.6433945,  -8.18181801
  35119,  -17.1490555,   61.9624405,    -9.090909
  35120,  -17.8946667,   62.4825439,    -9.090909
  35121,  -18.6402779,   63.0026512,    -9.090909
  35122,  -19.3858891,   63.5227585,    -9.090909
  35123,  -20.1315002,   64.0428619,    -9.090909
  35124,  -20.8771133,    64.562973,    -9.090909
  35125,  -21.6227245,   65.0830765,    -9.090909
  35126,  -22.3683357,   65.6031799,    -9.090909
  35127,  -23.1139469,    66.123291,    -9.090909
  35128,  -23.8595581,   66.6433945,    -9.090909
  35129,  -17.5236607,   61.4066391, -0.909090936
  35130,  -18.2855587,   61.9025803, -0.909090936
  35131,  -19.0474567,   62.3985214, -0.909090936
  35132,  -19.8093548,   62.8944626, -0.909090936
  35133,  -20.5712528,   63.3904037, -0.909090936
  35134,   -21.333149,   63.8863411, -0.909090936
  35135,  -22.0950489,   64.3822861, -0.909090936
  35136,  -22.8569469,   64.8782272, -0.909090936
  35137,   -23.618845,   65.3741684, -0.909090936
  35138,   -24.380743,   65.8701096, -0.909090936
  35139,  -17.5236607,   61.4066391,  -1.81818187
  35140,  -18.2855587,   61.9025803,  -1.81818187
  35141,  -19.0474567,   62.3985214,  -1.81818187
  35142,  -19.8093548,   62.8944626,  -1.81818187
  35143,  -20.5712528,   63.3904037,  -1.81818187
  35144,   -21.333149,   63.8863411,  -1.81818187
  35145,  -22.0950489,   64.3822861,  -1.81818187
  35146,  -22.8569469,   64.8782272,  -1.81818187
  35147,   -23.618845,   65.3741684,  -1.81818187
  35148,   -24.380743,   65.8701096,  -1.81818187
  35149,  -17.5236607,   61.4066391,  -2.72727275
  35150,  -18.2855587,   61.9025803,  -2.72727275
  35151,  -19.0474567,   62.3985214,  -2.72727275
  35152,  -19.8093548,   62.8944626,  -2.72727275
  35153,  -20.5712528,   63.3904037,  -2.72727275
  35154,   -21.333149,   63.8863411,  -2.72727275
  35155,  -22.0950489,   64.3822861,  -2.72727275
  35156,  -22.8569469,   64.8782272,  -2.72727275
  35157,   -23.618845,   65.3741684,  -2.72727275
  35158,   -24.380743,   65.8701096,  -2.72727275
  35159,  -17.5236607,   61.4066391,  -3.63636374
  35160,  -18.2855587,   61.9025803,  -3.63636374
  35161,  -19.0474567,   62.3985214,  -3.63636374
  35162,  -19.8093548,   62.8944626,  -3.63636374
  35163,  -20.5712528,   63.3904037,  -3.63636374
  35164,   -21.333149,   63.8863411,  -3.63636374
  35165,  -22.0950489,   64.3822861,  -3.63636374
  35166,  -22.8569469,   64.8782272,  -3.63636374
  35167,   -23.618845,   65.3741684,  -3.63636374
  35168,   -24.380743,   65.8701096,  -3.63636374
  35169,  -17.5236607,   61.4066391,   -4.5454545
  35170,  -18.2855587,   61.9025803,   -4.5454545
  35171,  -19.0474567,   62.3985214,   -4.5454545
  35172,  -19.8093548,   62.8944626,   -4.5454545
  35173,  -20.5712528,   63.3904037,   -4.5454545
  35174,   -21.333149,   63.8863411,   -4.5454545
  35175,  -22.0950489,   64.3822861,   -4.5454545
  35176,  -22.8569469,   64.8782272,   -4.5454545
  35177,   -23.618845,   65.3741684,   -4.5454545
  35178,   -24.380743,   65.8701096,   -4.5454545
  35179,  -17.5236607,   61.4066391,   -5.4545455
  35180,  -18.2855587,   61.9025803,   -5.4545455
  35181,  -19.0474567,   62.3985214,   -5.4545455
  35182,  -19.8093548,   62.8944626,   -5.4545455
  35183,  -20.5712528,   63.3904037,   -5.4545455
  35184,   -21.333149,   63.8863411,   -5.4545455
  35185,  -22.0950489,   64.3822861,   -5.4545455
  35186,  -22.8569469,   64.8782272,   -5.4545455
  35187,   -23.618845,   65.3741684,   -5.4545455
  35188,   -24.380743,   65.8701096,   -5.4545455
  35189,  -17.5236607,   61.4066391,  -6.36363649
  35190,  -18.2855587,   61.9025803,  -6.36363649
  35191,  -19.0474567,   62.3985214,  -6.36363649
  35192,  -19.8093548,   62.8944626,  -6.36363649
  35193,  -20.5712528,   63.3904037,  -6.36363649
  35194,   -21.333149,   63.8863411,  -6.36363649
  35195,  -22.0950489,   64.3822861,  -6.36363649
  35196,  -22.8569469,   64.8782272,  -6.36363649
  35197,   -23.618845,   65.3741684,  -6.36363649
  35198,   -24.380743,   65.8701096,  -6.36363649
  35199,  -17.5236607,   61.4066391,  -7.27272749
  35200,  -18.2855587,   61.9025803,  -7.27272749
  35201,  -19.0474567,   62.3985214,  -7.27272749
  35202,  -19.8093548,   62.8944626,  -7.27272749
  35203,  -20.5712528,   63.3904037,  -7.27272749
  35204,   -21.333149,   63.8863411,  -7.27272749
  35205,  -22.0950489,   64.3822861,  -7.27272749
  35206,  -22.8569469,   64.8782272,  -7.27272749
  35207,   -23.618845,   65.3741684,  -7.27272749
  35208,   -24.380743,   65.8701096,  -7.27272749
  35209,  -17.5236607,   61.4066391,  -8.18181801
  35210,  -18.2855587,   61.9025803,  -8.18181801
  35211,  -19.0474567,   62.3985214,  -8.18181801
  35212,  -19.8093548,   62.8944626,  -8.18181801
  35213,  -20.5712528,   63.3904037,  -8.18181801
  35214,   -21.333149,   63.8863411,  -8.18181801
  35215,  -22.0950489,   64.3822861,  -8.18181801
  35216,  -22.8569469,   64.8782272,  -8.18181801
  35217,   -23.618845,   65.3741684,  -8.18181801
  35218,   -24.380743,   65.8701096,  -8.18181801
  35219,  -17.5236607,   61.4066391,    -9.090909
  35220,  -18.2855587,   61.9025803,    -9.090909
  35221,  -19.0474567,   62.3985214,    -9.090909
  35222,  -19.8093548,   62.8944626,    -9.090909
  35223,  -20.5712528,   63.3904037,    -9.090909
  35224,   -21.333149,   63.8863411,    -9.090909
  35225,  -22.0950489,   64.3822861,    -9.090909
  35226,  -22.8569469,   64.8782272,    -9.090909
  35227,   -23.618845,   65.3741684,    -9.090909
  35228,   -24.380743,   65.8701096,    -9.090909
  35229,  -17.8802586,    60.839119, -0.909090936
  35230,  -18.6576595,   61.3103828, -0.909090936
  35231,  -19.4350624,   61.7816505, -0.909090936
  35232,  -20.2124653,   62.2529144, -0.909090936
  35233,  -20.9898682,   62.7241821, -0.909090936
  35234,  -21.7672691,    63.195446, -0.909090936
  35235,  -22.5446701,   63.6667137, -0.909090936
  35236,   -23.322073,   64.1379776, -0.909090936
  35237,  -24.0994759,   64.6092453, -0.909090936
  35238,  -24.8768787,    65.080513, -0.909090936
  35239,  -17.8802586,    60.839119,  -1.81818187
  35240,  -18.6576595,   61.3103828,  -1.81818187
  35241,  -19.4350624,   61.7816505,  -1.81818187
  35242,  -20.2124653,   62.2529144,  -1.81818187
  35243,  -20.9898682,   62.7241821,  -1.81818187
  35244,  -21.7672691,    63.195446,  -1.81818187
  35245,  -22.5446701,   63.6667137,  -1.81818187
  35246,   -23.322073,   64.1379776,  -1.81818187
  35247,  -24.0994759,   64.6092453,  -1.81818187
  35248,  -24.8768787,    65.080513,  -1.81818187
  35249,  -17.8802586,    60.839119,  -2.72727275
  35250,  -18.6576595,   61.3103828,  -2.72727275
  35251,  -19.4350624,   61.7816505,  -2.72727275
  35252,  -20.2124653,   62.2529144,  -2.72727275
  35253,  -20.9898682,   62.7241821,  -2.72727275
  35254,  -21.7672691,    63.195446,  -2.72727275
  35255,  -22.5446701,   63.6667137,  -2.72727275
  35256,   -23.322073,   64.1379776,  -2.72727275
  35257,  -24.0994759,   64.6092453,  -2.72727275
  35258,  -24.8768787,    65.080513,  -2.72727275
  35259,  -17.8802586,    60.839119,  -3.63636374
  35260,  -18.6576595,   61.3103828,  -3.63636374
  35261,  -19.4350624,   61.7816505,  -3.63636374
  35262,  -20.2124653,   62.2529144,  -3.63636374
  35263,  -20.9898682,   62.7241821,  -3.63636374
  35264,  -21.7672691,    63.195446,  -3.63636374
  35265,  -22.5446701,   63.6667137,  -3.63636374
  35266,   -23.322073,   64.1379776,  -3.63636374
  35267,  -24.0994759,   64.6092453,  -3.63636374
  35268,  -24.8768787,    65.080513,  -3.63636374
  35269,  -17.8802586,    60.839119,   -4.5454545
  35270,  -18.6576595,   61.3103828,   -4.5454545
  35271,  -19.4350624,   61.7816505,   -4.5454545
  35272,  -20.2124653,   62.2529144,   -4.5454545
  35273,  -20.9898682,   62.7241821,   -4.5454545
  35274,  -21.7672691,    63.195446,   -4.5454545
  35275,  -22.5446701,   63.6667137,   -4.5454545
  35276,   -23.322073,   64.1379776,   -4.5454545
  35277,  -24.0994759,   64.6092453,   -4.5454545
  35278,  -24.8768787,    65.080513,   -4.5454545
  35279,  -17.8802586,    60.839119,   -5.4545455
  35280,  -18.6576595,   61.3103828,   -5.4545455
  35281,  -19.4350624,   61.7816505,   -5.4545455
  35282,  -20.2124653,   62.2529144,   -5.4545455
  35283,  -20.9898682,   62.7241821,   -5.4545455
  35284,  -21.7672691,    63.195446,   -5.4545455
  35285,  -22.5446701,   63.6667137,   -5.4545455
  35286,   -23.322073,   64.1379776,   -5.4545455
  35287,  -24.0994759,   64.6092453,   -5.4545455
  35288,  -24.8768787,    65.080513,   -5.4545455
  35289,  -17.8802586,    60.839119,  -6.36363649
  35290,  -18.6576595,   61.3103828,  -6.36363649
  35291,  -19.4350624,   61.7816505,  -6.36363649
  35292,  -20.2124653,   62.2529144,  -6.36363649
  35293,  -20.9898682,   62.7241821,  -6.36363649
  35294,  -21.7672691,    63.195446,  -6.36363649
  35295,  -22.5446701,   63.6667137,  -6.36363649
  35296,   -23.322073,   64.1379776,  -6.36363649
  35297,  -24.0994759,   64.6092453,  -6.36363649
  35298,  -24.8768787,    65.080513,  -6.36363649
  35299,  -17.8802586,    60.839119,  -7.27272749
  35300,  -18.6576595,   61.3103828,  -7.27272749
  35301,  -19.4350624,   61.7816505,  -7.27272749
  35302,  -20.2124653,   62.2529144,  -7.27272749
  35303,  -20.9898682,   62.7241821,  -7.27272749
  35304,  -21.7672691,    63.195446,  -7.27272749
  35305,  -22.5446701,   63.6667137,  -7.27272749
  35306,   -23.322073,   64.1379776,  -7.27272749
  35307,  -24.0994759,   64.6092453,  -7.27272749
  35308,  -24.8768787,    65.080513,  -7.27272749
  35309,  -17.8802586,    60.839119,  -8.18181801
  35310,  -18.6576595,   61.3103828,  -8.18181801
  35311,  -19.4350624,   61.7816505,  -8.18181801
  35312,  -20.2124653,   62.2529144,  -8.18181801
  35313,  -20.9898682,   62.7241821,  -8.18181801
  35314,  -21.7672691,    63.195446,  -8.18181801
  35315,  -22.5446701,   63.6667137,  -8.18181801
  35316,   -23.322073,   64.1379776,  -8.18181801
  35317,  -24.0994759,   64.6092453,  -8.18181801
  35318,  -24.8768787,    65.080513,  -8.18181801
  35319,  -17.8802586,    60.839119,    -9.090909
  35320,  -18.6576595,   61.3103828,    -9.090909
  35321,  -19.4350624,   61.7816505,    -9.090909
  35322,  -20.2124653,   62.2529144,    -9.090909
  35323,  -20.9898682,   62.7241821,    -9.090909
  35324,  -21.7672691,    63.195446,    -9.090909
  35325,  -22.5446701,   63.6667137,    -9.090909
  35326,   -23.322073,   64.1379776,    -9.090909
  35327,  -24.0994759,   64.6092453,    -9.090909
  35328,  -24.8768787,    65.080513,    -9.090909
  35329,  -18.2184811,   60.2604561, -0.909090936
  35330,  -19.0105896,   60.7065659, -0.909090936
  35331,  -19.8026981,   61.1526718, -0.909090936
  35332,  -20.5948067,   61.5987778, -0.909090936
  35333,  -21.3869133,   62.0448837, -0.909090936
  35334,  -22.1790218,   62.4909935, -0.909090936
  35335,  -22.9711304,   62.9370995, -0.909090936
  35336,   -23.763237,   63.3832054, -0.909090936
  35337,  -24.5553455,   63.8293114, -0.909090936
  35338,  -25.3474541,   64.2754211, -0.909090936
  35339,  -18.2184811,   60.2604561,  -1.81818187
  35340,  -19.0105896,   60.7065659,  -1.81818187
  35341,  -19.8026981,   61.1526718,  -1.81818187
  35342,  -20.5948067,   61.5987778,  -1.81818187
  35343,  -21.3869133,   62.0448837,  -1.81818187
  35344,  -22.1790218,   62.4909935,  -1.81818187
  35345,  -22.9711304,   62.9370995,  -1.81818187
  35346,   -23.763237,   63.3832054,  -1.81818187
  35347,  -24.5553455,   63.8293114,  -1.81818187
  35348,  -25.3474541,   64.2754211,  -1.81818187
  35349,  -18.2184811,   60.2604561,  -2.72727275
  35350,  -19.0105896,   60.7065659,  -2.72727275
  35351,  -19.8026981,   61.1526718,  -2.72727275
  35352,  -20.5948067,   61.5987778,  -2.72727275
  35353,  -21.3869133,   62.0448837,  -2.72727275
  35354,  -22.1790218,   62.4909935,  -2.72727275
  35355,  -22.9711304,   62.9370995,  -2.72727275
  35356,   -23.763237,   63.3832054,  -2.72727275
  35357,  -24.5553455,   63.8293114,  -2.72727275
  35358,  -25.3474541,   64.2754211,  -2.72727275
  35359,  -18.2184811,   60.2604561,  -3.63636374
  35360,  -19.0105896,   60.7065659,  -3.63636374
  35361,  -19.8026981,   61.1526718,  -3.63636374
  35362,  -20.5948067,   61.5987778,  -3.63636374
  35363,  -21.3869133,   62.0448837,  -3.63636374
  35364,  -22.1790218,   62.4909935,  -3.63636374
  35365,  -22.9711304,   62.9370995,  -3.63636374
  35366,   -23.763237,   63.3832054,  -3.63636374
  35367,  -24.5553455,   63.8293114,  -3.63636374
  35368,  -25.3474541,   64.2754211,  -3.63636374
  35369,  -18.2184811,   60.2604561,   -4.5454545
  35370,  -19.0105896,   60.7065659,   -4.5454545
  35371,  -19.8026981,   61.1526718,   -4.5454545
  35372,  -20.5948067,   61.5987778,   -4.5454545
  35373,  -21.3869133,   62.0448837,   -4.5454545
  35374,  -22.1790218,   62.4909935,   -4.5454545
  35375,  -22.9711304,   62.9370995,   -4.5454545
  35376,   -23.763237,   63.3832054,   -4.5454545
  35377,  -24.5553455,   63.8293114,   -4.5454545
  35378,  -25.3474541,   64.2754211,   -4.5454545
  35379,  -18.2184811,   60.2604561,   -5.4545455
  35380,  -19.0105896,   60.7065659,   -5.4545455
  35381,  -19.8026981,   61.1526718,   -5.4545455
  35382,  -20.5948067,   61.5987778,   -5.4545455
  35383,  -21.3869133,   62.0448837,   -5.4545455
  35384,  -22.1790218,   62.4909935,   -5.4545455
  35385,  -22.9711304,   62.9370995,   -5.4545455
  35386,   -23.763237,   63.3832054,   -5.4545455
  35387,  -24.5553455,   63.8293114,   -5.4545455
  35388,  -25.3474541,   64.2754211,   -5.4545455
  35389,  -18.2184811,   60.2604561,  -6.36363649
  35390,  -19.0105896,   60.7065659,  -6.36363649
  35391,  -19.8026981,   61.1526718,  -6.36363649
  35392,  -20.5948067,   61.5987778,  -6.36363649
  35393,  -21.3869133,   62.0448837,  -6.36363649
  35394,  -22.1790218,   62.4909935,  -6.36363649
  35395,  -22.9711304,   62.9370995,  -6.36363649
  35396,   -23.763237,   63.3832054,  -6.36363649
  35397,  -24.5553455,   63.8293114,  -6.36363649
  35398,  -25.3474541,   64.2754211,  -6.36363649
  35399,  -18.2184811,   60.2604561,  -7.27272749
  35400,  -19.0105896,   60.7065659,  -7.27272749
  35401,  -19.8026981,   61.1526718,  -7.27272749
  35402,  -20.5948067,   61.5987778,  -7.27272749
  35403,  -21.3869133,   62.0448837,  -7.27272749
  35404,  -22.1790218,   62.4909935,  -7.27272749
  35405,  -22.9711304,   62.9370995,  -7.27272749
  35406,   -23.763237,   63.3832054,  -7.27272749
  35407,  -24.5553455,   63.8293114,  -7.27272749
  35408,  -25.3474541,   64.2754211,  -7.27272749
  35409,  -18.2184811,   60.2604561,  -8.18181801
  35410,  -19.0105896,   60.7065659,  -8.18181801
  35411,  -19.8026981,   61.1526718,  -8.18181801
  35412,  -20.5948067,   61.5987778,  -8.18181801
  35413,  -21.3869133,   62.0448837,  -8.18181801
  35414,  -22.1790218,   62.4909935,  -8.18181801
  35415,  -22.9711304,   62.9370995,  -8.18181801
  35416,   -23.763237,   63.3832054,  -8.18181801
  35417,  -24.5553455,   63.8293114,  -8.18181801
  35418,  -25.3474541,   64.2754211,  -8.18181801
  35419,  -18.2184811,   60.2604561,    -9.090909
  35420,  -19.0105896,   60.7065659,    -9.090909
  35421,  -19.8026981,   61.1526718,    -9.090909
  35422,  -20.5948067,   61.5987778,    -9.090909
  35423,  -21.3869133,   62.0448837,    -9.090909
  35424,  -22.1790218,   62.4909935,    -9.090909
  35425,  -22.9711304,   62.9370995,    -9.090909
  35426,   -23.763237,   63.3832054,    -9.090909
  35427,  -24.5553455,   63.8293114,    -9.090909
  35428,  -25.3474541,   64.2754211,    -9.090909
  35429,  -18.5379829,    59.671257, -0.909090936
  35430,  -19.3439827,   60.0917435, -0.909090936
  35431,  -20.1499825,   60.5122337, -0.909090936
  35432,  -20.9559822,    60.932724, -0.909090936
  35433,   -21.761982,   61.3532143, -0.909090936
  35434,  -22.5679817,   61.7737007, -0.909090936
  35435,  -23.3739815,    62.194191, -0.909090936
  35436,  -24.1799812,   62.6146812, -0.909090936
  35437,   -24.985981,   63.0351715, -0.909090936
  35438,  -25.7919807,    63.455658, -0.909090936
  35439,  -18.5379829,    59.671257,  -1.81818187
  35440,  -19.3439827,   60.0917435,  -1.81818187
  35441,  -20.1499825,   60.5122337,  -1.81818187
  35442,  -20.9559822,    60.932724,  -1.81818187
  35443,   -21.761982,   61.3532143,  -1.81818187
  35444,  -22.5679817,   61.7737007,  -1.81818187
  35445,  -23.3739815,    62.194191,  -1.81818187
  35446,  -24.1799812,   62.6146812,  -1.81818187
  35447,   -24.985981,   63.0351715,  -1.81818187
  35448,  -25.7919807,    63.455658,  -1.81818187
  35449,  -18.5379829,    59.671257,  -2.72727275
  35450,  -19.3439827,   60.0917435,  -2.72727275
  35451,  -20.1499825,   60.5122337,  -2.72727275
  35452,  -20.9559822,    60.932724,  -2.72727275
  35453,   -21.761982,   61.3532143,  -2.72727275
  35454,  -22.5679817,   61.7737007,  -2.72727275
  35455,  -23.3739815,    62.194191,  -2.72727275
  35456,  -24.1799812,   62.6146812,  -2.72727275
  35457,   -24.985981,   63.0351715,  -2.72727275
  35458,  -25.7919807,    63.455658,  -2.72727275
  35459,  -18.5379829,    59.671257,  -3.63636374
  35460,  -19.3439827,   60.0917435,  -3.63636374
  35461,  -20.1499825,   60.5122337,  -3.63636374
  35462,  -20.9559822,    60.932724,  -3.63636374
  35463,   -21.761982,   61.3532143,  -3.63636374
  35464,  -22.5679817,   61.7737007,  -3.63636374
  35465,  -23.3739815,    62.194191,  -3.63636374
  35466,  -24.1799812,   62.6146812,  -3.63636374
  35467,   -24.985981,   63.0351715,  -3.63636374
  35468,  -25.7919807,    63.455658,  -3.63636374
  35469,  -18.5379829,    59.671257,   -4.5454545
  35470,  -19.3439827,   60.0917435,   -4.5454545
  35471,  -20.1499825,   60.5122337,   -4.5454545
  35472,  -20.9559822,    60.932724,   -4.5454545
  35473,   -21.761982,   61.3532143,   -4.5454545
  35474,  -22.5679817,   61.7737007,   -4.5454545
  35475,  -23.3739815,    62.194191,   -4.5454545
  35476,  -24.1799812,   62.6146812,   -4.5454545
  35477,   -24.985981,   63.0351715,   -4.5454545
  35478,  -25.7919807,    63.455658,   -4.5454545
  35479,  -18.5379829,    59.671257,   -5.4545455
  35480,  -19.3439827,   60.0917435,   -5.4545455
  35481,  -20.1499825,   60.5122337,   -5.4545455
  35482,  -20.9559822,    60.932724,   -5.4545455
  35483,   -21.761982,   61.3532143,   -5.4545455
  35484,  -22.5679817,   61.7737007,   -5.4545455
  35485,  -23.3739815,    62.194191,   -5.4545455
  35486,  -24.1799812,   62.6146812,   -5.4545455
  35487,   -24.985981,   63.0351715,   -5.4545455
  35488,  -25.7919807,    63.455658,   -5.4545455
  35489,  -18.5379829,    59.671257,  -6.36363649
  35490,  -19.3439827,   60.0917435,  -6.36363649
  35491,  -20.1499825,   60.5122337,  -6.36363649
  35492,  -20.9559822,    60.932724,  -6.36363649
  35493,   -21.761982,   61.3532143,  -6.36363649
  35494,  -22.5679817,   61.7737007,  -6.36363649
  35495,  -23.3739815,    62.194191,  -6.36363649
  35496,  -24.1799812,   62.6146812,  -6.36363649
  35497,   -24.985981,   63.0351715,  -6.36363649
  35498,  -25.7919807,    63.455658,  -6.36363649
  35499,  -18.5379829,    59.671257,  -7.27272749
  35500,  -19.3439827,   60.0917435,  -7.27272749
  35501,  -20.1499825,   60.5122337,  -7.27272749
  35502,  -20.9559822,    60.932724,  -7.27272749
  35503,   -21.761982,   61.3532143,  -7.27272749
  35504,  -22.5679817,   61.7737007,  -7.27272749
  35505,  -23.3739815,    62.194191,  -7.27272749
  35506,  -24.1799812,   62.6146812,  -7.27272749
  35507,   -24.985981,   63.0351715,  -7.27272749
  35508,  -25.7919807,    63.455658,  -7.27272749
  35509,  -18.5379829,    59.671257,  -8.18181801
  35510,  -19.3439827,   60.0917435,  -8.18181801
  35511,  -20.1499825,   60.5122337,  -8.18181801
  35512,  -20.9559822,    60.932724,  -8.18181801
  35513,   -21.761982,   61.3532143,  -8.18181801
  35514,  -22.5679817,   61.7737007,  -8.18181801
  35515,  -23.3739815,    62.194191,  -8.18181801
  35516,  -24.1799812,   62.6146812,  -8.18181801
  35517,   -24.985981,   63.0351715,  -8.18181801
  35518,  -25.7919807,    63.455658,  -8.18181801
  35519,  -18.5379829,    59.671257,    -9.090909
  35520,  -19.3439827,   60.0917435,    -9.090909
  35521,  -20.1499825,   60.5122337,    -9.090909
  35522,  -20.9559822,    60.932724,    -9.090909
  35523,   -21.761982,   61.3532143,    -9.090909
  35524,  -22.5679817,   61.7737007,    -9.090909
  35525,  -23.3739815,    62.194191,    -9.090909
  35526,  -24.1799812,   62.6146812,    -9.090909
  35527,   -24.985981,   63.0351715,    -9.090909
  35528,  -25.7919807,    63.455658,    -9.090909
  35529,  -18.8384418,    59.072113, -0.909090936
  35530,   -19.657505,   59.4665527, -0.909090936
  35531,  -20.4765663,   59.8609924, -0.909090936
  35532,  -21.2956295,   60.2554321, -0.909090936
  35533,  -22.1146927,   60.6498718, -0.909090936
  35534,  -22.9337521,   61.0443115, -0.909090936
  35535,  -23.7528152,   61.4387512, -0.909090936
  35536,  -24.5718784,   61.8331947, -0.909090936
  35537,  -25.3909416,   62.2276344, -0.909090936
  35538,  -26.2100029,   62.6220741, -0.909090936
  35539,  -18.8384418,    59.072113,  -1.81818187
  35540,   -19.657505,   59.4665527,  -1.81818187
  35541,  -20.4765663,   59.8609924,  -1.81818187
  35542,  -21.2956295,   60.2554321,  -1.81818187
  35543,  -22.1146927,   60.6498718,  -1.81818187
  35544,  -22.9337521,   61.0443115,  -1.81818187
  35545,  -23.7528152,   61.4387512,  -1.81818187
  35546,  -24.5718784,   61.8331947,  -1.81818187
  35547,  -25.3909416,   62.2276344,  -1.81818187
  35548,  -26.2100029,   62.6220741,  -1.81818187
  35549,  -18.8384418,    59.072113,  -2.72727275
  35550,   -19.657505,   59.4665527,  -2.72727275
  35551,  -20.4765663,   59.8609924,  -2.72727275
  35552,  -21.2956295,   60.2554321,  -2.72727275
  35553,  -22.1146927,   60.6498718,  -2.72727275
  35554,  -22.9337521,   61.0443115,  -2.72727275
  35555,  -23.7528152,   61.4387512,  -2.72727275
  35556,  -24.5718784,   61.8331947,  -2.72727275
  35557,  -25.3909416,   62.2276344,  -2.72727275
  35558,  -26.2100029,   62.6220741,  -2.72727275
  35559,  -18.8384418,    59.072113,  -3.63636374
  35560,   -19.657505,   59.4665527,  -3.63636374
  35561,  -20.4765663,   59.8609924,  -3.63636374
  35562,  -21.2956295,   60.2554321,  -3.63636374
  35563,  -22.1146927,   60.6498718,  -3.63636374
  35564,  -22.9337521,   61.0443115,  -3.63636374
  35565,  -23.7528152,   61.4387512,  -3.63636374
  35566,  -24.5718784,   61.8331947,  -3.63636374
  35567,  -25.3909416,   62.2276344,  -3.63636374
  35568,  -26.2100029,   62.6220741,  -3.63636374
  35569,  -18.8384418,    59.072113,   -4.5454545
  35570,   -19.657505,   59.4665527,   -4.5454545
  35571,  -20.4765663,   59.8609924,   -4.5454545
  35572,  -21.2956295,   60.2554321,   -4.5454545
  35573,  -22.1146927,   60.6498718,   -4.5454545
  35574,  -22.9337521,   61.0443115,   -4.5454545
  35575,  -23.7528152,   61.4387512,   -4.5454545
  35576,  -24.5718784,   61.8331947,   -4.5454545
  35577,  -25.3909416,   62.2276344,   -4.5454545
  35578,  -26.2100029,   62.6220741,   -4.5454545
  35579,  -18.8384418,    59.072113,   -5.4545455
  35580,   -19.657505,   59.4665527,   -5.4545455
  35581,  -20.4765663,   59.8609924,   -5.4545455
  35582,  -21.2956295,   60.2554321,   -5.4545455
  35583,  -22.1146927,   60.6498718,   -5.4545455
  35584,  -22.9337521,   61.0443115,   -5.4545455
  35585,  -23.7528152,   61.4387512,   -5.4545455
  35586,  -24.5718784,   61.8331947,   -5.4545455
  35587,  -25.3909416,   62.2276344,   -5.4545455
  35588,  -26.2100029,   62.6220741,   -5.4545455
  35589,  -18.8384418,    59.072113,  -6.36363649
  35590,   -19.657505,   59.4665527,  -6.36363649
  35591,  -20.4765663,   59.8609924,  -6.36363649
  35592,  -21.2956295,   60.2554321,  -6.36363649
  35593,  -22.1146927,   60.6498718,  -6.36363649
  35594,  -22.9337521,   61.0443115,  -6.36363649
  35595,  -23.7528152,   61.4387512,  -6.36363649
  35596,  -24.5718784,   61.8331947,  -6.36363649
  35597,  -25.3909416,   62.2276344,  -6.36363649
  35598,  -26.2100029,   62.6220741,  -6.36363649
  35599,  -18.8384418,    59.072113,  -7.27272749
  35600,   -19.657505,   59.4665527,  -7.27272749
  35601,  -20.4765663,   59.8609924,  -7.27272749
  35602,  -21.2956295,   60.2554321,  -7.27272749
  35603,  -22.1146927,   60.6498718,  -7.27272749
  35604,  -22.9337521,   61.0443115,  -7.27272749
  35605,  -23.7528152,   61.4387512,  -7.27272749
  35606,  -24.5718784,   61.8331947,  -7.27272749
  35607,  -25.3909416,   62.2276344,  -7.27272749
  35608,  -26.2100029,   62.6220741,  -7.27272749
  35609,  -18.8384418,    59.072113,  -8.18181801
  35610,   -19.657505,   59.4665527,  -8.18181801
  35611,  -20.4765663,   59.8609924,  -8.18181801
  35612,  -21.2956295,   60.2554321,  -8.18181801
  35613,  -22.1146927,   60.6498718,  -8.18181801
  35614,  -22.9337521,   61.0443115,  -8.18181801
  35615,  -23.7528152,   61.4387512,  -8.18181801
  35616,  -24.5718784,   61.8331947,  -8.18181801
  35617,  -25.3909416,   62.2276344,  -8.18181801
  35618,  -26.2100029,   62.6220741,  -8.18181801
  35619,  -18.8384418,    59.072113,    -9.090909
  35620,   -19.657505,   59.4665527,    -9.090909
  35621,  -20.4765663,   59.8609924,    -9.090909
  35622,  -21.2956295,   60.2554321,    -9.090909
  35623,  -22.1146927,   60.6498718,    -9.090909
  35624,  -22.9337521,   61.0443115,    -9.090909
  35625,  -23.7528152,   61.4387512,    -9.090909
  35626,  -24.5718784,   61.8331947,    -9.090909
  35627,  -25.3909416,   62.2276344,    -9.090909
  35628,  -26.2100029,   62.6220741,    -9.090909
  35629,  -19.1195393,   58.4636536, -0.909090936
  35630,  -19.9508228,   58.8316383, -0.909090936
  35631,  -20.7821064,   59.1996231, -0.909090936
  35632,  -21.6133919,   59.5676079, -0.909090936
  35633,  -22.4446754,   59.9355927, -0.909090936
  35634,  -23.2759571,   60.3035774, -0.909090936
  35635,  -24.1072426,   60.6715622, -0.909090936
  35636,  -24.9385262,    61.039547, -0.909090936
  35637,  -25.7698097,   61.4075317, -0.909090936
  35638,  -26.6010952,   61.7755165, -0.909090936
  35639,  -19.1195393,   58.4636536,  -1.81818187
  35640,  -19.9508228,   58.8316383,  -1.81818187
  35641,  -20.7821064,   59.1996231,  -1.81818187
  35642,  -21.6133919,   59.5676079,  -1.81818187
  35643,  -22.4446754,   59.9355927,  -1.81818187
  35644,  -23.2759571,   60.3035774,  -1.81818187
  35645,  -24.1072426,   60.6715622,  -1.81818187
  35646,  -24.9385262,    61.039547,  -1.81818187
  35647,  -25.7698097,   61.4075317,  -1.81818187
  35648,  -26.6010952,   61.7755165,  -1.81818187
  35649,  -19.1195393,   58.4636536,  -2.72727275
  35650,  -19.9508228,   58.8316383,  -2.72727275
  35651,  -20.7821064,   59.1996231,  -2.72727275
  35652,  -21.6133919,   59.5676079,  -2.72727275
  35653,  -22.4446754,   59.9355927,  -2.72727275
  35654,  -23.2759571,   60.3035774,  -2.72727275
  35655,  -24.1072426,   60.6715622,  -2.72727275
  35656,  -24.9385262,    61.039547,  -2.72727275
  35657,  -25.7698097,   61.4075317,  -2.72727275
  35658,  -26.6010952,   61.7755165,  -2.72727275
  35659,  -19.1195393,   58.4636536,  -3.63636374
  35660,  -19.9508228,   58.8316383,  -3.63636374
  35661,  -20.7821064,   59.1996231,  -3.63636374
  35662,  -21.6133919,   59.5676079,  -3.63636374
  35663,  -22.4446754,   59.9355927,  -3.63636374
  35664,  -23.2759571,   60.3035774,  -3.63636374
  35665,  -24.1072426,   60.6715622,  -3.63636374
  35666,  -24.9385262,    61.039547,  -3.63636374
  35667,  -25.7698097,   61.4075317,  -3.63636374
  35668,  -26.6010952,   61.7755165,  -3.63636374
  35669,  -19.1195393,   58.4636536,   -4.5454545
  35670,  -19.9508228,   58.8316383,   -4.5454545
  35671,  -20.7821064,   59.1996231,   -4.5454545
  35672,  -21.6133919,   59.5676079,   -4.5454545
  35673,  -22.4446754,   59.9355927,   -4.5454545
  35674,  -23.2759571,   60.3035774,   -4.5454545
  35675,  -24.1072426,   60.6715622,   -4.5454545
  35676,  -24.9385262,    61.039547,   -4.5454545
  35677,  -25.7698097,   61.4075317,   -4.5454545
  35678,  -26.6010952,   61.7755165,   -4.5454545
  35679,  -19.1195393,   58.4636536,   -5.4545455
  35680,  -19.9508228,   58.8316383,   -5.4545455
  35681,  -20.7821064,   59.1996231,   -5.4545455
  35682,  -21.6133919,   59.5676079,   -5.4545455
  35683,  -22.4446754,   59.9355927,   -5.4545455
  35684,  -23.2759571,   60.3035774,   -5.4545455
  35685,  -24.1072426,   60.6715622,   -5.4545455
  35686,  -24.9385262,    61.039547,   -5.4545455
  35687,  -25.7698097,   61.4075317,   -5.4545455
  35688,  -26.6010952,   61.7755165,   -5.4545455
  35689,  -19.1195393,   58.4636536,  -6.36363649
  35690,  -19.9508228,   58.8316383,  -6.36363649
  35691,  -20.7821064,   59.1996231,  -6.36363649
  35692,  -21.6133919,   59.5676079,  -6.36363649
  35693,  -22.4446754,   59.9355927,  -6.36363649
  35694,  -23.2759571,   60.3035774,  -6.36363649
  35695,  -24.1072426,   60.6715622,  -6.36363649
  35696,  -24.9385262,    61.039547,  -6.36363649
  35697,  -25.7698097,   61.4075317,  -6.36363649
  35698,  -26.6010952,   61.7755165,  -6.36363649
  35699,  -19.1195393,   58.4636536,  -7.27272749
  35700,  -19.9508228,   58.8316383,  -7.27272749
  35701,  -20.7821064,   59.1996231,  -7.27272749
  35702,  -21.6133919,   59.5676079,  -7.27272749
  35703,  -22.4446754,   59.9355927,  -7.27272749
  35704,  -23.2759571,   60.3035774,  -7.27272749
  35705,  -24.1072426,   60.6715622,  -7.27272749
  35706,  -24.9385262,    61.039547,  -7.27272749
  35707,  -25.7698097,   61.4075317,  -7.27272749
  35708,  -26.6010952,   61.7755165,  -7.27272749
  35709,  -19.1195393,   58.4636536,  -8.18181801
  35710,  -19.9508228,   58.8316383,  -8.18181801
  35711,  -20.7821064,   59.1996231,  -8.18181801
  35712,  -21.6133919,   59.5676079,  -8.18181801
  35713,  -22.4446754,   59.9355927,  -8.18181801
  35714,  -23.2759571,   60.3035774,  -8.18181801
  35715,  -24.1072426,   60.6715622,  -8.18181801
  35716,  -24.9385262,    61.039547,  -8.18181801
  35717,  -25.7698097,   61.4075317,  -8.18181801
  35718,  -26.6010952,   61.7755165,  -8.18181801
  35719,  -19.1195393,   58.4636536,    -9.090909
  35720,  -19.9508228,   58.8316383,    -9.090909
  35721,  -20.7821064,   59.1996231,    -9.090909
  35722,  -21.6133919,   59.5676079,    -9.090909
  35723,  -22.4446754,   59.9355927,    -9.090909
  35724,  -23.2759571,   60.3035774,    -9.090909
  35725,  -24.1072426,   60.6715622,    -9.090909
  35726,  -24.9385262,    61.039547,    -9.090909
  35727,  -25.7698097,   61.4075317,    -9.090909
  35728,  -26.6010952,   61.7755165,    -9.090909
  35729,  -19.3809872,   57.8464928, -0.909090936
  35730,  -20.2236385,    58.187645, -0.909090936
  35731,  -21.0662899,   58.5287971, -0.909090936
  35732,  -21.9089413,   58.8699455, -0.909090936
  35733,  -22.7515926,   59.2110977, -0.909090936
  35734,   -23.594244,   59.5522499, -0.909090936
  35735,  -24.4368973,   59.8934021, -0.909090936
  35736,  -25.2795486,   60.2345543, -0.909090936
  35737,     -26.1222,   60.5757065, -0.909090936
  35738,  -26.9648514,   60.9168587, -0.909090936
  35739,  -19.3809872,   57.8464928,  -1.81818187
  35740,  -20.2236385,    58.187645,  -1.81818187
  35741,  -21.0662899,   58.5287971,  -1.81818187
  35742,  -21.9089413,   58.8699455,  -1.81818187
  35743,  -22.7515926,   59.2110977,  -1.81818187
  35744,   -23.594244,   59.5522499,  -1.81818187
  35745,  -24.4368973,   59.8934021,  -1.81818187
  35746,  -25.2795486,   60.2345543,  -1.81818187
  35747,     -26.1222,   60.5757065,  -1.81818187
  35748,  -26.9648514,   60.9168587,  -1.81818187
  35749,  -19.3809872,   57.8464928,  -2.72727275
  35750,  -20.2236385,    58.187645,  -2.72727275
  35751,  -21.0662899,   58.5287971,  -2.72727275
  35752,  -21.9089413,   58.8699455,  -2.72727275
  35753,  -22.7515926,   59.2110977,  -2.72727275
  35754,   -23.594244,   59.5522499,  -2.72727275
  35755,  -24.4368973,   59.8934021,  -2.72727275
  35756,  -25.2795486,   60.2345543,  -2.72727275
  35757,     -26.1222,   60.5757065,  -2.72727275
  35758,  -26.9648514,   60.9168587,  -2.72727275
  35759,  -19.3809872,   57.8464928,  -3.63636374
  35760,  -20.2236385,    58.187645,  -3.63636374
  35761,  -21.0662899,   58.5287971,  -3.63636374
  35762,  -21.9089413,   58.8699455,  -3.63636374
  35763,  -22.7515926,   59.2110977,  -3.63636374
  35764,   -23.594244,   59.5522499,  -3.63636374
  35765,  -24.4368973,   59.8934021,  -3.63636374
  35766,  -25.2795486,   60.2345543,  -3.63636374
  35767,     -26.1222,   60.5757065,  -3.63636374
  35768,  -26.9648514,   60.9168587,  -3.63636374
  35769,  -19.3809872,   57.8464928,   -4.5454545
  35770,  -20.2236385,    58.187645,   -4.5454545
  35771,  -21.0662899,   58.5287971,   -4.5454545
  35772,  -21.9089413,   58.8699455,   -4.5454545
  35773,  -22.7515926,   59.2110977,   -4.5454545
  35774,   -23.594244,   59.5522499,   -4.5454545
  35775,  -24.4368973,   59.8934021,   -4.5454545
  35776,  -25.2795486,   60.2345543,   -4.5454545
  35777,     -26.1222,   60.5757065,   -4.5454545
  35778,  -26.9648514,   60.9168587,   -4.5454545
  35779,  -19.3809872,   57.8464928,   -5.4545455
  35780,  -20.2236385,    58.187645,   -5.4545455
  35781,  -21.0662899,   58.5287971,   -5.4545455
  35782,  -21.9089413,   58.8699455,   -5.4545455
  35783,  -22.7515926,   59.2110977,   -5.4545455
  35784,   -23.594244,   59.5522499,   -5.4545455
  35785,  -24.4368973,   59.8934021,   -5.4545455
  35786,  -25.2795486,   60.2345543,   -5.4545455
  35787,     -26.1222,   60.5757065,   -5.4545455
  35788,  -26.9648514,   60.9168587,   -5.4545455
  35789,  -19.3809872,   57.8464928,  -6.36363649
  35790,  -20.2236385,    58.187645,  -6.36363649
  35791,  -21.0662899,   58.5287971,  -6.36363649
  35792,  -21.9089413,   58.8699455,  -6.36363649
  35793,  -22.7515926,   59.2110977,  -6.36363649
  35794,   -23.594244,   59.5522499,  -6.36363649
  35795,  -24.4368973,   59.8934021,  -6.36363649
  35796,  -25.2795486,   60.2345543,  -6.36363649
  35797,     -26.1222,   60.5757065,  -6.36363649
  35798,  -26.9648514,   60.9168587,  -6.36363649
  35799,  -19.3809872,   57.8464928,  -7.27272749
  35800,  -20.2236385,    58.187645,  -7.27272749
  35801,  -21.0662899,   58.5287971,  -7.27272749
  35802,  -21.9089413,   58.8699455,  -7.27272749
  35803,  -22.7515926,   59.2110977,  -7.27272749
  35804,   -23.594244,   59.5522499,  -7.27272749
  35805,  -24.4368973,   59.8934021,  -7.27272749
  35806,  -25.2795486,   60.2345543,  -7.27272749
  35807,     -26.1222,   60.5757065,  -7.27272749
  35808,  -26.9648514,   60.9168587,  -7.27272749
  35809,  -19.3809872,   57.8464928,  -8.18181801
  35810,  -20.2236385,    58.187645,  -8.18181801
  35811,  -21.0662899,   58.5287971,  -8.18181801
  35812,  -21.9089413,   58.8699455,  -8.18181801
  35813,  -22.7515926,   59.2110977,  -8.18181801
  35814,   -23.594244,   59.5522499,  -8.18181801
  35815,  -24.4368973,   59.8934021,  -8.18181801
  35816,  -25.2795486,   60.2345543,  -8.18181801
  35817,     -26.1222,   60.5757065,  -8.18181801
  35818,  -26.9648514,   60.9168587,  -8.18181801
  35819,  -19.3809872,   57.8464928,    -9.090909
  35820,  -20.2236385,    58.187645,    -9.090909
  35821,  -21.0662899,   58.5287971,    -9.090909
  35822,  -21.9089413,   58.8699455,    -9.090909
  35823,  -22.7515926,   59.2110977,    -9.090909
  35824,   -23.594244,   59.5522499,    -9.090909
  35825,  -24.4368973,   59.8934021,    -9.090909
  35826,  -25.2795486,   60.2345543,    -9.090909
  35827,     -26.1222,   60.5757065,    -9.090909
  35828,  -26.9648514,   60.9168587,    -9.090909
  35829,  -19.6225204,   57.2212677, -0.909090936
  35830,  -20.4756737,   57.5352364, -0.909090936
  35831,   -21.328825,    57.849205, -0.909090936
  35832,  -22.1819782,   58.1631737, -0.909090936
  35833,  -23.0351315,   58.4771423, -0.909090936
  35834,  -23.8882866,    58.791111, -0.909090936
  35835,  -24.7414398,   59.1050797, -0.909090936
  35836,   -25.594593,   59.4190483, -0.909090936
  35837,  -26.4477463,    59.733017, -0.909090936
  35838,  -27.3008995,   60.0469818, -0.909090936
  35839,  -19.6225204,   57.2212677,  -1.81818187
  35840,  -20.4756737,   57.5352364,  -1.81818187
  35841,   -21.328825,    57.849205,  -1.81818187
  35842,  -22.1819782,   58.1631737,  -1.81818187
  35843,  -23.0351315,   58.4771423,  -1.81818187
  35844,  -23.8882866,    58.791111,  -1.81818187
  35845,  -24.7414398,   59.1050797,  -1.81818187
  35846,   -25.594593,   59.4190483,  -1.81818187
  35847,  -26.4477463,    59.733017,  -1.81818187
  35848,  -27.3008995,   60.0469818,  -1.81818187
  35849,  -19.6225204,   57.2212677,  -2.72727275
  35850,  -20.4756737,   57.5352364,  -2.72727275
  35851,   -21.328825,    57.849205,  -2.72727275
  35852,  -22.1819782,   58.1631737,  -2.72727275
  35853,  -23.0351315,   58.4771423,  -2.72727275
  35854,  -23.8882866,    58.791111,  -2.72727275
  35855,  -24.7414398,   59.1050797,  -2.72727275
  35856,   -25.594593,   59.4190483,  -2.72727275
  35857,  -26.4477463,    59.733017,  -2.72727275
  35858,  -27.3008995,   60.0469818,  -2.72727275
  35859,  -19.6225204,   57.2212677,  -3.63636374
  35860,  -20.4756737,   57.5352364,  -3.63636374
  35861,   -21.328825,    57.849205,  -3.63636374
  35862,  -22.1819782,   58.1631737,  -3.63636374
  35863,  -23.0351315,   58.4771423,  -3.63636374
  35864,  -23.8882866,    58.791111,  -3.63636374
  35865,  -24.7414398,   59.1050797,  -3.63636374
  35866,   -25.594593,   59.4190483,  -3.63636374
  35867,  -26.4477463,    59.733017,  -3.63636374
  35868,  -27.3008995,   60.0469818,  -3.63636374
  35869,  -19.6225204,   57.2212677,   -4.5454545
  35870,  -20.4756737,   57.5352364,   -4.5454545
  35871,   -21.328825,    57.849205,   -4.5454545
  35872,  -22.1819782,   58.1631737,   -4.5454545
  35873,  -23.0351315,   58.4771423,   -4.5454545
  35874,  -23.8882866,    58.791111,   -4.5454545
  35875,  -24.7414398,   59.1050797,   -4.5454545
  35876,   -25.594593,   59.4190483,   -4.5454545
  35877,  -26.4477463,    59.733017,   -4.5454545
  35878,  -27.3008995,   60.0469818,   -4.5454545
  35879,  -19.6225204,   57.2212677,   -5.4545455
  35880,  -20.4756737,   57.5352364,   -5.4545455
  35881,   -21.328825,    57.849205,   -5.4545455
  35882,  -22.1819782,   58.1631737,   -5.4545455
  35883,  -23.0351315,   58.4771423,   -5.4545455
  35884,  -23.8882866,    58.791111,   -5.4545455
  35885,  -24.7414398,   59.1050797,   -5.4545455
  35886,   -25.594593,   59.4190483,   -5.4545455
  35887,  -26.4477463,    59.733017,   -5.4545455
  35888,  -27.3008995,   60.0469818,   -5.4545455
  35889,  -19.6225204,   57.2212677,  -6.36363649
  35890,  -20.4756737,   57.5352364,  -6.36363649
  35891,   -21.328825,    57.849205,  -6.36363649
  35892,  -22.1819782,   58.1631737,  -6.36363649
  35893,  -23.0351315,   58.4771423,  -6.36363649
  35894,  -23.8882866,    58.791111,  -6.36363649
  35895,  -24.7414398,   59.1050797,  -6.36363649
  35896,   -25.594593,   59.4190483,  -6.36363649
  35897,  -26.4477463,    59.733017,  -6.36363649
  35898,  -27.3008995,   60.0469818,  -6.36363649
  35899,  -19.6225204,   57.2212677,  -7.27272749
  35900,  -20.4756737,   57.5352364,  -7.27272749
  35901,   -21.328825,    57.849205,  -7.27272749
  35902,  -22.1819782,   58.1631737,  -7.27272749
  35903,  -23.0351315,   58.4771423,  -7.27272749
  35904,  -23.8882866,    58.791111,  -7.27272749
  35905,  -24.7414398,   59.1050797,  -7.27272749
  35906,   -25.594593,   59.4190483,  -7.27272749
  35907,  -26.4477463,    59.733017,  -7.27272749
  35908,  -27.3008995,   60.0469818,  -7.27272749
  35909,  -19.6225204,   57.2212677,  -8.18181801
  35910,  -20.4756737,   57.5352364,  -8.18181801
  35911,   -21.328825,    57.849205,  -8.18181801
  35912,  -22.1819782,   58.1631737,  -8.18181801
  35913,  -23.0351315,   58.4771423,  -8.18181801
  35914,  -23.8882866,    58.791111,  -8.18181801
  35915,  -24.7414398,   59.1050797,  -8.18181801
  35916,   -25.594593,   59.4190483,  -8.18181801
  35917,  -26.4477463,    59.733017,  -8.18181801
  35918,  -27.3008995,   60.0469818,  -8.18181801
  35919,  -19.6225204,   57.2212677,    -9.090909
  35920,  -20.4756737,   57.5352364,    -9.090909
  35921,   -21.328825,    57.849205,    -9.090909
  35922,  -22.1819782,   58.1631737,    -9.090909
  35923,  -23.0351315,   58.4771423,    -9.090909
  35924,  -23.8882866,    58.791111,    -9.090909
  35925,  -24.7414398,   59.1050797,    -9.090909
  35926,   -25.594593,   59.4190483,    -9.090909
  35927,  -26.4477463,    59.733017,    -9.090909
  35928,  -27.3008995,   60.0469818,    -9.090909
  35929,  -19.8438931,   56.5886269, -0.909090936
  35930,  -20.7066708,   56.8750877, -0.909090936
  35931,  -21.5694485,   57.1615486, -0.909090936
  35932,  -22.4322262,   57.4480133, -0.909090936
  35933,  -23.2950039,   57.7344742, -0.909090936
  35934,  -24.1577835,   58.0209351, -0.909090936
  35935,  -25.0205612,   58.3073997, -0.909090936
  35936,  -25.8833389,   58.5938606, -0.909090936
  35937,  -26.7461166,   58.8803215, -0.909090936
  35938,  -27.6088943,   59.1667862, -0.909090936
  35939,  -19.8438931,   56.5886269,  -1.81818187
  35940,  -20.7066708,   56.8750877,  -1.81818187
  35941,  -21.5694485,   57.1615486,  -1.81818187
  35942,  -22.4322262,   57.4480133,  -1.81818187
  35943,  -23.2950039,   57.7344742,  -1.81818187
  35944,  -24.1577835,   58.0209351,  -1.81818187
  35945,  -25.0205612,   58.3073997,  -1.81818187
  35946,  -25.8833389,   58.5938606,  -1.81818187
  35947,  -26.7461166,   58.8803215,  -1.81818187
  35948,  -27.6088943,   59.1667862,  -1.81818187
  35949,  -19.8438931,   56.5886269,  -2.72727275
  35950,  -20.7066708,   56.8750877,  -2.72727275
  35951,  -21.5694485,   57.1615486,  -2.72727275
  35952,  -22.4322262,   57.4480133,  -2.72727275
  35953,  -23.2950039,   57.7344742,  -2.72727275
  35954,  -24.1577835,   58.0209351,  -2.72727275
  35955,  -25.0205612,   58.3073997,  -2.72727275
  35956,  -25.8833389,   58.5938606,  -2.72727275
  35957,  -26.7461166,   58.8803215,  -2.72727275
  35958,  -27.6088943,   59.1667862,  -2.72727275
  35959,  -19.8438931,   56.5886269,  -3.63636374
  35960,  -20.7066708,   56.8750877,  -3.63636374
  35961,  -21.5694485,   57.1615486,  -3.63636374
  35962,  -22.4322262,   57.4480133,  -3.63636374
  35963,  -23.2950039,   57.7344742,  -3.63636374
  35964,  -24.1577835,   58.0209351,  -3.63636374
  35965,  -25.0205612,   58.3073997,  -3.63636374
  35966,  -25.8833389,   58.5938606,  -3.63636374
  35967,  -26.7461166,   58.8803215,  -3.63636374
  35968,  -27.6088943,   59.1667862,  -3.63636374
  35969,  -19.8438931,   56.5886269,   -4.5454545
  35970,  -20.7066708,   56.8750877,   -4.5454545
  35971,  -21.5694485,   57.1615486,   -4.5454545
  35972,  -22.4322262,   57.4480133,   -4.5454545
  35973,  -23.2950039,   57.7344742,   -4.5454545
  35974,  -24.1577835,   58.0209351,   -4.5454545
  35975,  -25.0205612,   58.3073997,   -4.5454545
  35976,  -25.8833389,   58.5938606,   -4.5454545
  35977,  -26.7461166,   58.8803215,   -4.5454545
  35978,  -27.6088943,   59.1667862,   -4.5454545
  35979,  -19.8438931,   56.5886269,   -5.4545455
  35980,  -20.7066708,   56.8750877,   -5.4545455
  35981,  -21.5694485,   57.1615486,   -5.4545455
  35982,  -22.4322262,   57.4480133,   -5.4545455
  35983,  -23.2950039,   57.7344742,   -5.4545455
  35984,  -24.1577835,   58.0209351,   -5.4545455
  35985,  -25.0205612,   58.3073997,   -5.4545455
  35986,  -25.8833389,   58.5938606,   -5.4545455
  35987,  -26.7461166,   58.8803215,   -5.4545455
  35988,  -27.6088943,   59.1667862,   -5.4545455
  35989,  -19.8438931,   56.5886269,  -6.36363649
  35990,  -20.7066708,   56.8750877,  -6.36363649
  35991,  -21.5694485,   57.1615486,  -6.36363649
  35992,  -22.4322262,   57.4480133,  -6.36363649
  35993,  -23.2950039,   57.7344742,  -6.36363649
  35994,  -24.1577835,   58.0209351,  -6.36363649
