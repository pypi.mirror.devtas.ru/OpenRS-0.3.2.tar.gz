  29995,   16.4374599,   70.6119232,  -6.36363649
  29996,   17.0042686,   71.3226776,  -6.36363649
  29997,   17.5710773,    72.033432,  -6.36363649
  29998,    18.137888,   72.7441864,  -6.36363649
  29999,   13.0366058,   66.3473892,  -7.27272749
  30000,   13.6034145,   67.0581436,  -7.27272749
  30001,   14.1702242,    67.768898,  -7.27272749
  30002,   14.7370329,   68.4796524,  -7.27272749
  30003,   15.3038416,   69.1904068,  -7.27272749
  30004,   15.8706512,   69.9011612,  -7.27272749
  30005,   16.4374599,   70.6119232,  -7.27272749
  30006,   17.0042686,   71.3226776,  -7.27272749
  30007,   17.5710773,    72.033432,  -7.27272749
  30008,    18.137888,   72.7441864,  -7.27272749
  30009,   13.0366058,   66.3473892,  -8.18181801
  30010,   13.6034145,   67.0581436,  -8.18181801
  30011,   14.1702242,    67.768898,  -8.18181801
  30012,   14.7370329,   68.4796524,  -8.18181801
  30013,   15.3038416,   69.1904068,  -8.18181801
  30014,   15.8706512,   69.9011612,  -8.18181801
  30015,   16.4374599,   70.6119232,  -8.18181801
  30016,   17.0042686,   71.3226776,  -8.18181801
  30017,   17.5710773,    72.033432,  -8.18181801
  30018,    18.137888,   72.7441864,  -8.18181801
  30019,   13.0366058,   66.3473892,    -9.090909
  30020,   13.6034145,   67.0581436,    -9.090909
  30021,   14.1702242,    67.768898,    -9.090909
  30022,   14.7370329,   68.4796524,    -9.090909
  30023,   15.3038416,   69.1904068,    -9.090909
  30024,   15.8706512,   69.9011612,    -9.090909
  30025,   16.4374599,   70.6119232,    -9.090909
  30026,   17.0042686,   71.3226776,    -9.090909
  30027,   17.5710773,    72.033432,    -9.090909
  30028,    18.137888,   72.7441864,    -9.090909
  30029,   12.5059462,   66.7568283, -0.909090936
  30030,   13.0496836,   67.4853897, -0.909090936
  30031,     13.59342,   68.2139435, -0.909090936
  30032,   14.1371574,   68.9425049, -0.909090936
  30033,   14.6808939,   69.6710587, -0.909090936
  30034,   15.2246294,   70.3996201, -0.909090936
  30035,   15.7683668,   71.1281738, -0.909090936
  30036,   16.3121033,   71.8567352, -0.909090936
  30037,   16.8558407,   72.5852966, -0.909090936
  30038,   17.3995781,   73.3138504, -0.909090936
  30039,   12.5059462,   66.7568283,  -1.81818187
  30040,   13.0496836,   67.4853897,  -1.81818187
  30041,     13.59342,   68.2139435,  -1.81818187
  30042,   14.1371574,   68.9425049,  -1.81818187
  30043,   14.6808939,   69.6710587,  -1.81818187
  30044,   15.2246294,   70.3996201,  -1.81818187
  30045,   15.7683668,   71.1281738,  -1.81818187
  30046,   16.3121033,   71.8567352,  -1.81818187
  30047,   16.8558407,   72.5852966,  -1.81818187
  30048,   17.3995781,   73.3138504,  -1.81818187
  30049,   12.5059462,   66.7568283,  -2.72727275
  30050,   13.0496836,   67.4853897,  -2.72727275
  30051,     13.59342,   68.2139435,  -2.72727275
  30052,   14.1371574,   68.9425049,  -2.72727275
  30053,   14.6808939,   69.6710587,  -2.72727275
  30054,   15.2246294,   70.3996201,  -2.72727275
  30055,   15.7683668,   71.1281738,  -2.72727275
  30056,   16.3121033,   71.8567352,  -2.72727275
  30057,   16.8558407,   72.5852966,  -2.72727275
  30058,   17.3995781,   73.3138504,  -2.72727275
  30059,   12.5059462,   66.7568283,  -3.63636374
  30060,   13.0496836,   67.4853897,  -3.63636374
  30061,     13.59342,   68.2139435,  -3.63636374
  30062,   14.1371574,   68.9425049,  -3.63636374
  30063,   14.6808939,   69.6710587,  -3.63636374
  30064,   15.2246294,   70.3996201,  -3.63636374
  30065,   15.7683668,   71.1281738,  -3.63636374
  30066,   16.3121033,   71.8567352,  -3.63636374
  30067,   16.8558407,   72.5852966,  -3.63636374
  30068,   17.3995781,   73.3138504,  -3.63636374
  30069,   12.5059462,   66.7568283,   -4.5454545
  30070,   13.0496836,   67.4853897,   -4.5454545
  30071,     13.59342,   68.2139435,   -4.5454545
  30072,   14.1371574,   68.9425049,   -4.5454545
  30073,   14.6808939,   69.6710587,   -4.5454545
  30074,   15.2246294,   70.3996201,   -4.5454545
  30075,   15.7683668,   71.1281738,   -4.5454545
  30076,   16.3121033,   71.8567352,   -4.5454545
  30077,   16.8558407,   72.5852966,   -4.5454545
  30078,   17.3995781,   73.3138504,   -4.5454545
  30079,   12.5059462,   66.7568283,   -5.4545455
  30080,   13.0496836,   67.4853897,   -5.4545455
  30081,     13.59342,   68.2139435,   -5.4545455
  30082,   14.1371574,   68.9425049,   -5.4545455
  30083,   14.6808939,   69.6710587,   -5.4545455
  30084,   15.2246294,   70.3996201,   -5.4545455
  30085,   15.7683668,   71.1281738,   -5.4545455
  30086,   16.3121033,   71.8567352,   -5.4545455
  30087,   16.8558407,   72.5852966,   -5.4545455
  30088,   17.3995781,   73.3138504,   -5.4545455
  30089,   12.5059462,   66.7568283,  -6.36363649
  30090,   13.0496836,   67.4853897,  -6.36363649
  30091,     13.59342,   68.2139435,  -6.36363649
  30092,   14.1371574,   68.9425049,  -6.36363649
  30093,   14.6808939,   69.6710587,  -6.36363649
  30094,   15.2246294,   70.3996201,  -6.36363649
  30095,   15.7683668,   71.1281738,  -6.36363649
  30096,   16.3121033,   71.8567352,  -6.36363649
  30097,   16.8558407,   72.5852966,  -6.36363649
  30098,   17.3995781,   73.3138504,  -6.36363649
  30099,   12.5059462,   66.7568283,  -7.27272749
  30100,   13.0496836,   67.4853897,  -7.27272749
  30101,     13.59342,   68.2139435,  -7.27272749
  30102,   14.1371574,   68.9425049,  -7.27272749
  30103,   14.6808939,   69.6710587,  -7.27272749
  30104,   15.2246294,   70.3996201,  -7.27272749
  30105,   15.7683668,   71.1281738,  -7.27272749
  30106,   16.3121033,   71.8567352,  -7.27272749
  30107,   16.8558407,   72.5852966,  -7.27272749
  30108,   17.3995781,   73.3138504,  -7.27272749
  30109,   12.5059462,   66.7568283,  -8.18181801
  30110,   13.0496836,   67.4853897,  -8.18181801
  30111,     13.59342,   68.2139435,  -8.18181801
  30112,   14.1371574,   68.9425049,  -8.18181801
  30113,   14.6808939,   69.6710587,  -8.18181801
  30114,   15.2246294,   70.3996201,  -8.18181801
  30115,   15.7683668,   71.1281738,  -8.18181801
  30116,   16.3121033,   71.8567352,  -8.18181801
  30117,   16.8558407,   72.5852966,  -8.18181801
  30118,   17.3995781,   73.3138504,  -8.18181801
  30119,   12.5059462,   66.7568283,    -9.090909
  30120,   13.0496836,   67.4853897,    -9.090909
  30121,     13.59342,   68.2139435,    -9.090909
  30122,   14.1371574,   68.9425049,    -9.090909
  30123,   14.6808939,   69.6710587,    -9.090909
  30124,   15.2246294,   70.3996201,    -9.090909
  30125,   15.7683668,   71.1281738,    -9.090909
  30126,   16.3121033,   71.8567352,    -9.090909
  30127,   16.8558407,   72.5852966,    -9.090909
  30128,   17.3995781,   73.3138504,    -9.090909
  30129,   11.9624405,   67.1490555, -0.909090936
  30130,   12.4825449,   67.8946686, -0.909090936
  30131,   13.0026512,   68.6402817, -0.909090936
  30132,   13.5227575,   69.3858871, -0.909090936
  30133,   14.0428638,   70.1315002, -0.909090936
  30134,   14.5629683,   70.8771133, -0.909090936
  30135,   15.0830746,   71.6227264, -0.909090936
  30136,   15.6031809,   72.3683319, -0.909090936
  30137,   16.1232853,    73.113945, -0.909090936
  30138,   16.6433926,   73.8595581, -0.909090936
  30139,   11.9624405,   67.1490555,  -1.81818187
  30140,   12.4825449,   67.8946686,  -1.81818187
  30141,   13.0026512,   68.6402817,  -1.81818187
  30142,   13.5227575,   69.3858871,  -1.81818187
  30143,   14.0428638,   70.1315002,  -1.81818187
  30144,   14.5629683,   70.8771133,  -1.81818187
  30145,   15.0830746,   71.6227264,  -1.81818187
  30146,   15.6031809,   72.3683319,  -1.81818187
  30147,   16.1232853,    73.113945,  -1.81818187
  30148,   16.6433926,   73.8595581,  -1.81818187
  30149,   11.9624405,   67.1490555,  -2.72727275
  30150,   12.4825449,   67.8946686,  -2.72727275
  30151,   13.0026512,   68.6402817,  -2.72727275
  30152,   13.5227575,   69.3858871,  -2.72727275
  30153,   14.0428638,   70.1315002,  -2.72727275
  30154,   14.5629683,   70.8771133,  -2.72727275
  30155,   15.0830746,   71.6227264,  -2.72727275
  30156,   15.6031809,   72.3683319,  -2.72727275
  30157,   16.1232853,    73.113945,  -2.72727275
  30158,   16.6433926,   73.8595581,  -2.72727275
  30159,   11.9624405,   67.1490555,  -3.63636374
  30160,   12.4825449,   67.8946686,  -3.63636374
  30161,   13.0026512,   68.6402817,  -3.63636374
  30162,   13.5227575,   69.3858871,  -3.63636374
  30163,   14.0428638,   70.1315002,  -3.63636374
  30164,   14.5629683,   70.8771133,  -3.63636374
  30165,   15.0830746,   71.6227264,  -3.63636374
  30166,   15.6031809,   72.3683319,  -3.63636374
  30167,   16.1232853,    73.113945,  -3.63636374
  30168,   16.6433926,   73.8595581,  -3.63636374
  30169,   11.9624405,   67.1490555,   -4.5454545
  30170,   12.4825449,   67.8946686,   -4.5454545
  30171,   13.0026512,   68.6402817,   -4.5454545
  30172,   13.5227575,   69.3858871,   -4.5454545
  30173,   14.0428638,   70.1315002,   -4.5454545
  30174,   14.5629683,   70.8771133,   -4.5454545
  30175,   15.0830746,   71.6227264,   -4.5454545
  30176,   15.6031809,   72.3683319,   -4.5454545
  30177,   16.1232853,    73.113945,   -4.5454545
  30178,   16.6433926,   73.8595581,   -4.5454545
  30179,   11.9624405,   67.1490555,   -5.4545455
  30180,   12.4825449,   67.8946686,   -5.4545455
  30181,   13.0026512,   68.6402817,   -5.4545455
  30182,   13.5227575,   69.3858871,   -5.4545455
  30183,   14.0428638,   70.1315002,   -5.4545455
  30184,   14.5629683,   70.8771133,   -5.4545455
  30185,   15.0830746,   71.6227264,   -5.4545455
  30186,   15.6031809,   72.3683319,   -5.4545455
  30187,   16.1232853,    73.113945,   -5.4545455
  30188,   16.6433926,   73.8595581,   -5.4545455
  30189,   11.9624405,   67.1490555,  -6.36363649
  30190,   12.4825449,   67.8946686,  -6.36363649
  30191,   13.0026512,   68.6402817,  -6.36363649
  30192,   13.5227575,   69.3858871,  -6.36363649
  30193,   14.0428638,   70.1315002,  -6.36363649
  30194,   14.5629683,   70.8771133,  -6.36363649
  30195,   15.0830746,   71.6227264,  -6.36363649
  30196,   15.6031809,   72.3683319,  -6.36363649
  30197,   16.1232853,    73.113945,  -6.36363649
  30198,   16.6433926,   73.8595581,  -6.36363649
  30199,   11.9624405,   67.1490555,  -7.27272749
  30200,   12.4825449,   67.8946686,  -7.27272749
  30201,   13.0026512,   68.6402817,  -7.27272749
  30202,   13.5227575,   69.3858871,  -7.27272749
  30203,   14.0428638,   70.1315002,  -7.27272749
  30204,   14.5629683,   70.8771133,  -7.27272749
  30205,   15.0830746,   71.6227264,  -7.27272749
  30206,   15.6031809,   72.3683319,  -7.27272749
  30207,   16.1232853,    73.113945,  -7.27272749
  30208,   16.6433926,   73.8595581,  -7.27272749
  30209,   11.9624405,   67.1490555,  -8.18181801
  30210,   12.4825449,   67.8946686,  -8.18181801
  30211,   13.0026512,   68.6402817,  -8.18181801
  30212,   13.5227575,   69.3858871,  -8.18181801
  30213,   14.0428638,   70.1315002,  -8.18181801
  30214,   14.5629683,   70.8771133,  -8.18181801
  30215,   15.0830746,   71.6227264,  -8.18181801
  30216,   15.6031809,   72.3683319,  -8.18181801
  30217,   16.1232853,    73.113945,  -8.18181801
  30218,   16.6433926,   73.8595581,  -8.18181801
  30219,   11.9624405,   67.1490555,    -9.090909
  30220,   12.4825449,   67.8946686,    -9.090909
  30221,   13.0026512,   68.6402817,    -9.090909
  30222,   13.5227575,   69.3858871,    -9.090909
  30223,   14.0428638,   70.1315002,    -9.090909
  30224,   14.5629683,   70.8771133,    -9.090909
  30225,   15.0830746,   71.6227264,    -9.090909
  30226,   15.6031809,   72.3683319,    -9.090909
  30227,   16.1232853,    73.113945,    -9.090909
  30228,   16.6433926,   73.8595581,    -9.090909
  30229,   11.4066381,   67.5236588, -0.909090936
  30230,   11.9025784,   68.2855606, -0.909090936
  30231,   12.3985195,   69.0474548, -0.909090936
  30232,   12.8944607,   69.8093567, -0.909090936
  30233,   13.3904009,   70.5712509, -0.909090936
  30234,   13.8863411,   71.3331528, -0.909090936
  30235,   14.3822823,    72.095047, -0.909090936
  30236,   14.8782225,   72.8569489, -0.909090936
  30237,   15.3741636,   73.6188431, -0.909090936
  30238,   15.8701038,   74.3807449, -0.909090936
  30239,   11.4066381,   67.5236588,  -1.81818187
  30240,   11.9025784,   68.2855606,  -1.81818187
  30241,   12.3985195,   69.0474548,  -1.81818187
  30242,   12.8944607,   69.8093567,  -1.81818187
  30243,   13.3904009,   70.5712509,  -1.81818187
  30244,   13.8863411,   71.3331528,  -1.81818187
  30245,   14.3822823,    72.095047,  -1.81818187
  30246,   14.8782225,   72.8569489,  -1.81818187
  30247,   15.3741636,   73.6188431,  -1.81818187
  30248,   15.8701038,   74.3807449,  -1.81818187
  30249,   11.4066381,   67.5236588,  -2.72727275
  30250,   11.9025784,   68.2855606,  -2.72727275
  30251,   12.3985195,   69.0474548,  -2.72727275
  30252,   12.8944607,   69.8093567,  -2.72727275
  30253,   13.3904009,   70.5712509,  -2.72727275
  30254,   13.8863411,   71.3331528,  -2.72727275
  30255,   14.3822823,    72.095047,  -2.72727275
  30256,   14.8782225,   72.8569489,  -2.72727275
  30257,   15.3741636,   73.6188431,  -2.72727275
  30258,   15.8701038,   74.3807449,  -2.72727275
  30259,   11.4066381,   67.5236588,  -3.63636374
  30260,   11.9025784,   68.2855606,  -3.63636374
  30261,   12.3985195,   69.0474548,  -3.63636374
  30262,   12.8944607,   69.8093567,  -3.63636374
  30263,   13.3904009,   70.5712509,  -3.63636374
  30264,   13.8863411,   71.3331528,  -3.63636374
  30265,   14.3822823,    72.095047,  -3.63636374
  30266,   14.8782225,   72.8569489,  -3.63636374
  30267,   15.3741636,   73.6188431,  -3.63636374
  30268,   15.8701038,   74.3807449,  -3.63636374
  30269,   11.4066381,   67.5236588,   -4.5454545
  30270,   11.9025784,   68.2855606,   -4.5454545
  30271,   12.3985195,   69.0474548,   -4.5454545
  30272,   12.8944607,   69.8093567,   -4.5454545
  30273,   13.3904009,   70.5712509,   -4.5454545
  30274,   13.8863411,   71.3331528,   -4.5454545
  30275,   14.3822823,    72.095047,   -4.5454545
  30276,   14.8782225,   72.8569489,   -4.5454545
  30277,   15.3741636,   73.6188431,   -4.5454545
  30278,   15.8701038,   74.3807449,   -4.5454545
  30279,   11.4066381,   67.5236588,   -5.4545455
  30280,   11.9025784,   68.2855606,   -5.4545455
  30281,   12.3985195,   69.0474548,   -5.4545455
  30282,   12.8944607,   69.8093567,   -5.4545455
  30283,   13.3904009,   70.5712509,   -5.4545455
  30284,   13.8863411,   71.3331528,   -5.4545455
  30285,   14.3822823,    72.095047,   -5.4545455
  30286,   14.8782225,   72.8569489,   -5.4545455
  30287,   15.3741636,   73.6188431,   -5.4545455
  30288,   15.8701038,   74.3807449,   -5.4545455
  30289,   11.4066381,   67.5236588,  -6.36363649
  30290,   11.9025784,   68.2855606,  -6.36363649
  30291,   12.3985195,   69.0474548,  -6.36363649
  30292,   12.8944607,   69.8093567,  -6.36363649
  30293,   13.3904009,   70.5712509,  -6.36363649
  30294,   13.8863411,   71.3331528,  -6.36363649
  30295,   14.3822823,    72.095047,  -6.36363649
  30296,   14.8782225,   72.8569489,  -6.36363649
  30297,   15.3741636,   73.6188431,  -6.36363649
  30298,   15.8701038,   74.3807449,  -6.36363649
  30299,   11.4066381,   67.5236588,  -7.27272749
  30300,   11.9025784,   68.2855606,  -7.27272749
  30301,   12.3985195,   69.0474548,  -7.27272749
  30302,   12.8944607,   69.8093567,  -7.27272749
  30303,   13.3904009,   70.5712509,  -7.27272749
  30304,   13.8863411,   71.3331528,  -7.27272749
  30305,   14.3822823,    72.095047,  -7.27272749
  30306,   14.8782225,   72.8569489,  -7.27272749
  30307,   15.3741636,   73.6188431,  -7.27272749
  30308,   15.8701038,   74.3807449,  -7.27272749
  30309,   11.4066381,   67.5236588,  -8.18181801
  30310,   11.9025784,   68.2855606,  -8.18181801
  30311,   12.3985195,   69.0474548,  -8.18181801
  30312,   12.8944607,   69.8093567,  -8.18181801
  30313,   13.3904009,   70.5712509,  -8.18181801
  30314,   13.8863411,   71.3331528,  -8.18181801
  30315,   14.3822823,    72.095047,  -8.18181801
  30316,   14.8782225,   72.8569489,  -8.18181801
  30317,   15.3741636,   73.6188431,  -8.18181801
  30318,   15.8701038,   74.3807449,  -8.18181801
  30319,   11.4066381,   67.5236588,    -9.090909
  30320,   11.9025784,   68.2855606,    -9.090909
  30321,   12.3985195,   69.0474548,    -9.090909
  30322,   12.8944607,   69.8093567,    -9.090909
  30323,   13.3904009,   70.5712509,    -9.090909
  30324,   13.8863411,   71.3331528,    -9.090909
  30325,   14.3822823,    72.095047,    -9.090909
  30326,   14.8782225,   72.8569489,    -9.090909
  30327,   15.3741636,   73.6188431,    -9.090909
  30328,   15.8701038,   74.3807449,    -9.090909
  30329,    10.839119,   67.8802567, -0.909090936
  30330,   11.3103848,   68.6576614, -0.909090936
  30331,   11.7816515,   69.4350662, -0.909090936
  30332,   12.2529173,   70.2124634, -0.909090936
  30333,   12.7241831,   70.9898682, -0.909090936
  30334,   13.1954479,   71.7672729, -0.909090936
  30335,   13.6667137,   72.5446701, -0.909090936
  30336,   14.1379805,   73.3220749, -0.909090936
  30337,   14.6092463,   74.0994797, -0.909090936
  30338,    15.080512,   74.8768768, -0.909090936
  30339,    10.839119,   67.8802567,  -1.81818187
  30340,   11.3103848,   68.6576614,  -1.81818187
  30341,   11.7816515,   69.4350662,  -1.81818187
  30342,   12.2529173,   70.2124634,  -1.81818187
  30343,   12.7241831,   70.9898682,  -1.81818187
  30344,   13.1954479,   71.7672729,  -1.81818187
  30345,   13.6667137,   72.5446701,  -1.81818187
  30346,   14.1379805,   73.3220749,  -1.81818187
  30347,   14.6092463,   74.0994797,  -1.81818187
  30348,    15.080512,   74.8768768,  -1.81818187
  30349,    10.839119,   67.8802567,  -2.72727275
  30350,   11.3103848,   68.6576614,  -2.72727275
  30351,   11.7816515,   69.4350662,  -2.72727275
  30352,   12.2529173,   70.2124634,  -2.72727275
  30353,   12.7241831,   70.9898682,  -2.72727275
  30354,   13.1954479,   71.7672729,  -2.72727275
  30355,   13.6667137,   72.5446701,  -2.72727275
  30356,   14.1379805,   73.3220749,  -2.72727275
  30357,   14.6092463,   74.0994797,  -2.72727275
  30358,    15.080512,   74.8768768,  -2.72727275
  30359,    10.839119,   67.8802567,  -3.63636374
  30360,   11.3103848,   68.6576614,  -3.63636374
  30361,   11.7816515,   69.4350662,  -3.63636374
  30362,   12.2529173,   70.2124634,  -3.63636374
  30363,   12.7241831,   70.9898682,  -3.63636374
  30364,   13.1954479,   71.7672729,  -3.63636374
  30365,   13.6667137,   72.5446701,  -3.63636374
  30366,   14.1379805,   73.3220749,  -3.63636374
  30367,   14.6092463,   74.0994797,  -3.63636374
  30368,    15.080512,   74.8768768,  -3.63636374
  30369,    10.839119,   67.8802567,   -4.5454545
  30370,   11.3103848,   68.6576614,   -4.5454545
  30371,   11.7816515,   69.4350662,   -4.5454545
  30372,   12.2529173,   70.2124634,   -4.5454545
  30373,   12.7241831,   70.9898682,   -4.5454545
  30374,   13.1954479,   71.7672729,   -4.5454545
  30375,   13.6667137,   72.5446701,   -4.5454545
  30376,   14.1379805,   73.3220749,   -4.5454545
  30377,   14.6092463,   74.0994797,   -4.5454545
  30378,    15.080512,   74.8768768,   -4.5454545
  30379,    10.839119,   67.8802567,   -5.4545455
  30380,   11.3103848,   68.6576614,   -5.4545455
  30381,   11.7816515,   69.4350662,   -5.4545455
  30382,   12.2529173,   70.2124634,   -5.4545455
  30383,   12.7241831,   70.9898682,   -5.4545455
  30384,   13.1954479,   71.7672729,   -5.4545455
  30385,   13.6667137,   72.5446701,   -5.4545455
  30386,   14.1379805,   73.3220749,   -5.4545455
  30387,   14.6092463,   74.0994797,   -5.4545455
  30388,    15.080512,   74.8768768,   -5.4545455
  30389,    10.839119,   67.8802567,  -6.36363649
  30390,   11.3103848,   68.6576614,  -6.36363649
  30391,   11.7816515,   69.4350662,  -6.36363649
  30392,   12.2529173,   70.2124634,  -6.36363649
  30393,   12.7241831,   70.9898682,  -6.36363649
  30394,   13.1954479,   71.7672729,  -6.36363649
  30395,   13.6667137,   72.5446701,  -6.36363649
  30396,   14.1379805,   73.3220749,  -6.36363649
  30397,   14.6092463,   74.0994797,  -6.36363649
  30398,    15.080512,   74.8768768,  -6.36363649
  30399,    10.839119,   67.8802567,  -7.27272749
  30400,   11.3103848,   68.6576614,  -7.27272749
  30401,   11.7816515,   69.4350662,  -7.27272749
  30402,   12.2529173,   70.2124634,  -7.27272749
  30403,   12.7241831,   70.9898682,  -7.27272749
  30404,   13.1954479,   71.7672729,  -7.27272749
  30405,   13.6667137,   72.5446701,  -7.27272749
  30406,   14.1379805,   73.3220749,  -7.27272749
  30407,   14.6092463,   74.0994797,  -7.27272749
  30408,    15.080512,   74.8768768,  -7.27272749
  30409,    10.839119,   67.8802567,  -8.18181801
  30410,   11.3103848,   68.6576614,  -8.18181801
  30411,   11.7816515,   69.4350662,  -8.18181801
  30412,   12.2529173,   70.2124634,  -8.18181801
  30413,   12.7241831,   70.9898682,  -8.18181801
  30414,   13.1954479,   71.7672729,  -8.18181801
  30415,   13.6667137,   72.5446701,  -8.18181801
  30416,   14.1379805,   73.3220749,  -8.18181801
  30417,   14.6092463,   74.0994797,  -8.18181801
  30418,    15.080512,   74.8768768,  -8.18181801
  30419,    10.839119,   67.8802567,    -9.090909
  30420,   11.3103848,   68.6576614,    -9.090909
  30421,   11.7816515,   69.4350662,    -9.090909
  30422,   12.2529173,   70.2124634,    -9.090909
  30423,   12.7241831,   70.9898682,    -9.090909
  30424,   13.1954479,   71.7672729,    -9.090909
  30425,   13.6667137,   72.5446701,    -9.090909
  30426,   14.1379805,   73.3220749,    -9.090909
  30427,   14.6092463,   74.0994797,    -9.090909
  30428,    15.080512,   74.8768768,    -9.090909
  30429,    10.260457,    68.218483, -0.909090936
  30430,   10.7065639,   69.0105896, -0.909090936
  30431,   11.1526709,   69.8026962, -0.909090936
  30432,   11.5987778,   70.5948029, -0.909090936
  30433,   12.0448847,   71.3869171, -0.909090936
  30434,   12.4909916,   72.1790237, -0.909090936
  30435,   12.9370985,   72.9711304, -0.909090936
  30436,   13.3832054,    73.763237, -0.909090936
  30437,   13.8293123,   74.5553436, -0.909090936
  30438,   14.2754183,   75.3474503, -0.909090936
  30439,    10.260457,    68.218483,  -1.81818187
  30440,   10.7065639,   69.0105896,  -1.81818187
  30441,   11.1526709,   69.8026962,  -1.81818187
  30442,   11.5987778,   70.5948029,  -1.81818187
  30443,   12.0448847,   71.3869171,  -1.81818187
  30444,   12.4909916,   72.1790237,  -1.81818187
  30445,   12.9370985,   72.9711304,  -1.81818187
  30446,   13.3832054,    73.763237,  -1.81818187
  30447,   13.8293123,   74.5553436,  -1.81818187
  30448,   14.2754183,   75.3474503,  -1.81818187
  30449,    10.260457,    68.218483,  -2.72727275
  30450,   10.7065639,   69.0105896,  -2.72727275
  30451,   11.1526709,   69.8026962,  -2.72727275
  30452,   11.5987778,   70.5948029,  -2.72727275
  30453,   12.0448847,   71.3869171,  -2.72727275
  30454,   12.4909916,   72.1790237,  -2.72727275
  30455,   12.9370985,   72.9711304,  -2.72727275
  30456,   13.3832054,    73.763237,  -2.72727275
  30457,   13.8293123,   74.5553436,  -2.72727275
  30458,   14.2754183,   75.3474503,  -2.72727275
  30459,    10.260457,    68.218483,  -3.63636374
  30460,   10.7065639,   69.0105896,  -3.63636374
  30461,   11.1526709,   69.8026962,  -3.63636374
  30462,   11.5987778,   70.5948029,  -3.63636374
  30463,   12.0448847,   71.3869171,  -3.63636374
  30464,   12.4909916,   72.1790237,  -3.63636374
  30465,   12.9370985,   72.9711304,  -3.63636374
  30466,   13.3832054,    73.763237,  -3.63636374
  30467,   13.8293123,   74.5553436,  -3.63636374
  30468,   14.2754183,   75.3474503,  -3.63636374
  30469,    10.260457,    68.218483,   -4.5454545
  30470,   10.7065639,   69.0105896,   -4.5454545
  30471,   11.1526709,   69.8026962,   -4.5454545
  30472,   11.5987778,   70.5948029,   -4.5454545
  30473,   12.0448847,   71.3869171,   -4.5454545
  30474,   12.4909916,   72.1790237,   -4.5454545
  30475,   12.9370985,   72.9711304,   -4.5454545
  30476,   13.3832054,    73.763237,   -4.5454545
  30477,   13.8293123,   74.5553436,   -4.5454545
  30478,   14.2754183,   75.3474503,   -4.5454545
  30479,    10.260457,    68.218483,   -5.4545455
  30480,   10.7065639,   69.0105896,   -5.4545455
  30481,   11.1526709,   69.8026962,   -5.4545455
  30482,   11.5987778,   70.5948029,   -5.4545455
  30483,   12.0448847,   71.3869171,   -5.4545455
  30484,   12.4909916,   72.1790237,   -5.4545455
  30485,   12.9370985,   72.9711304,   -5.4545455
  30486,   13.3832054,    73.763237,   -5.4545455
  30487,   13.8293123,   74.5553436,   -5.4545455
  30488,   14.2754183,   75.3474503,   -5.4545455
  30489,    10.260457,    68.218483,  -6.36363649
  30490,   10.7065639,   69.0105896,  -6.36363649
  30491,   11.1526709,   69.8026962,  -6.36363649
  30492,   11.5987778,   70.5948029,  -6.36363649
  30493,   12.0448847,   71.3869171,  -6.36363649
  30494,   12.4909916,   72.1790237,  -6.36363649
  30495,   12.9370985,   72.9711304,  -6.36363649
  30496,   13.3832054,    73.763237,  -6.36363649
  30497,   13.8293123,   74.5553436,  -6.36363649
  30498,   14.2754183,   75.3474503,  -6.36363649
  30499,    10.260457,    68.218483,  -7.27272749
  30500,   10.7065639,   69.0105896,  -7.27272749
  30501,   11.1526709,   69.8026962,  -7.27272749
  30502,   11.5987778,   70.5948029,  -7.27272749
  30503,   12.0448847,   71.3869171,  -7.27272749
  30504,   12.4909916,   72.1790237,  -7.27272749
  30505,   12.9370985,   72.9711304,  -7.27272749
  30506,   13.3832054,    73.763237,  -7.27272749
  30507,   13.8293123,   74.5553436,  -7.27272749
  30508,   14.2754183,   75.3474503,  -7.27272749
  30509,    10.260457,    68.218483,  -8.18181801
  30510,   10.7065639,   69.0105896,  -8.18181801
  30511,   11.1526709,   69.8026962,  -8.18181801
  30512,   11.5987778,   70.5948029,  -8.18181801
  30513,   12.0448847,   71.3869171,  -8.18181801
  30514,   12.4909916,   72.1790237,  -8.18181801
  30515,   12.9370985,   72.9711304,  -8.18181801
  30516,   13.3832054,    73.763237,  -8.18181801
  30517,   13.8293123,   74.5553436,  -8.18181801
  30518,   14.2754183,   75.3474503,  -8.18181801
  30519,    10.260457,    68.218483,    -9.090909
  30520,   10.7065639,   69.0105896,    -9.090909
  30521,   11.1526709,   69.8026962,    -9.090909
  30522,   11.5987778,   70.5948029,    -9.090909
  30523,   12.0448847,   71.3869171,    -9.090909
  30524,   12.4909916,   72.1790237,    -9.090909
  30525,   12.9370985,   72.9711304,    -9.090909
  30526,   13.3832054,    73.763237,    -9.090909
  30527,   13.8293123,   74.5553436,    -9.090909
  30528,   14.2754183,   75.3474503,    -9.090909
  30529,   9.67125511,   68.5379868, -0.909090936
  30530,   10.0917444,   69.3439865, -0.909090936
  30531,   10.5122337,   70.1499863, -0.909090936
  30532,    10.932723,    70.955986, -0.909090936
  30533,   11.3532124,   71.7619858, -0.909090936
  30534,   11.7737026,   72.5679855, -0.909090936
  30535,   12.1941919,   73.3739853, -0.909090936
  30536,   12.6146812,   74.1799774, -0.909090936
  30537,   13.0351706,   74.9859772, -0.909090936
  30538,   13.4556599,   75.7919769, -0.909090936
  30539,   9.67125511,   68.5379868,  -1.81818187
  30540,   10.0917444,   69.3439865,  -1.81818187
  30541,   10.5122337,   70.1499863,  -1.81818187
  30542,    10.932723,    70.955986,  -1.81818187
  30543,   11.3532124,   71.7619858,  -1.81818187
  30544,   11.7737026,   72.5679855,  -1.81818187
  30545,   12.1941919,   73.3739853,  -1.81818187
  30546,   12.6146812,   74.1799774,  -1.81818187
  30547,   13.0351706,   74.9859772,  -1.81818187
  30548,   13.4556599,   75.7919769,  -1.81818187
  30549,   9.67125511,   68.5379868,  -2.72727275
  30550,   10.0917444,   69.3439865,  -2.72727275
  30551,   10.5122337,   70.1499863,  -2.72727275
  30552,    10.932723,    70.955986,  -2.72727275
  30553,   11.3532124,   71.7619858,  -2.72727275
  30554,   11.7737026,   72.5679855,  -2.72727275
  30555,   12.1941919,   73.3739853,  -2.72727275
  30556,   12.6146812,   74.1799774,  -2.72727275
  30557,   13.0351706,   74.9859772,  -2.72727275
  30558,   13.4556599,   75.7919769,  -2.72727275
  30559,   9.67125511,   68.5379868,  -3.63636374
  30560,   10.0917444,   69.3439865,  -3.63636374
  30561,   10.5122337,   70.1499863,  -3.63636374
  30562,    10.932723,    70.955986,  -3.63636374
  30563,   11.3532124,   71.7619858,  -3.63636374
  30564,   11.7737026,   72.5679855,  -3.63636374
  30565,   12.1941919,   73.3739853,  -3.63636374
  30566,   12.6146812,   74.1799774,  -3.63636374
  30567,   13.0351706,   74.9859772,  -3.63636374
  30568,   13.4556599,   75.7919769,  -3.63636374
  30569,   9.67125511,   68.5379868,   -4.5454545
  30570,   10.0917444,   69.3439865,   -4.5454545
  30571,   10.5122337,   70.1499863,   -4.5454545
  30572,    10.932723,    70.955986,   -4.5454545
  30573,   11.3532124,   71.7619858,   -4.5454545
  30574,   11.7737026,   72.5679855,   -4.5454545
  30575,   12.1941919,   73.3739853,   -4.5454545
  30576,   12.6146812,   74.1799774,   -4.5454545
  30577,   13.0351706,   74.9859772,   -4.5454545
  30578,   13.4556599,   75.7919769,   -4.5454545
  30579,   9.67125511,   68.5379868,   -5.4545455
  30580,   10.0917444,   69.3439865,   -5.4545455
  30581,   10.5122337,   70.1499863,   -5.4545455
  30582,    10.932723,    70.955986,   -5.4545455
  30583,   11.3532124,   71.7619858,   -5.4545455
  30584,   11.7737026,   72.5679855,   -5.4545455
  30585,   12.1941919,   73.3739853,   -5.4545455
  30586,   12.6146812,   74.1799774,   -5.4545455
  30587,   13.0351706,   74.9859772,   -5.4545455
  30588,   13.4556599,   75.7919769,   -5.4545455
  30589,   9.67125511,   68.5379868,  -6.36363649
  30590,   10.0917444,   69.3439865,  -6.36363649
  30591,   10.5122337,   70.1499863,  -6.36363649
  30592,    10.932723,    70.955986,  -6.36363649
  30593,   11.3532124,   71.7619858,  -6.36363649
  30594,   11.7737026,   72.5679855,  -6.36363649
  30595,   12.1941919,   73.3739853,  -6.36363649
  30596,   12.6146812,   74.1799774,  -6.36363649
  30597,   13.0351706,   74.9859772,  -6.36363649
  30598,   13.4556599,   75.7919769,  -6.36363649
  30599,   9.67125511,   68.5379868,  -7.27272749
  30600,   10.0917444,   69.3439865,  -7.27272749
  30601,   10.5122337,   70.1499863,  -7.27272749
  30602,    10.932723,    70.955986,  -7.27272749
  30603,   11.3532124,   71.7619858,  -7.27272749
  30604,   11.7737026,   72.5679855,  -7.27272749
  30605,   12.1941919,   73.3739853,  -7.27272749
  30606,   12.6146812,   74.1799774,  -7.27272749
  30607,   13.0351706,   74.9859772,  -7.27272749
  30608,   13.4556599,   75.7919769,  -7.27272749
  30609,   9.67125511,   68.5379868,  -8.18181801
  30610,   10.0917444,   69.3439865,  -8.18181801
  30611,   10.5122337,   70.1499863,  -8.18181801
  30612,    10.932723,    70.955986,  -8.18181801
  30613,   11.3532124,   71.7619858,  -8.18181801
  30614,   11.7737026,   72.5679855,  -8.18181801
  30615,   12.1941919,   73.3739853,  -8.18181801
  30616,   12.6146812,   74.1799774,  -8.18181801
  30617,   13.0351706,   74.9859772,  -8.18181801
  30618,   13.4556599,   75.7919769,  -8.18181801
  30619,   9.67125511,   68.5379868,    -9.090909
  30620,   10.0917444,   69.3439865,    -9.090909
  30621,   10.5122337,   70.1499863,    -9.090909
  30622,    10.932723,    70.955986,    -9.090909
  30623,   11.3532124,   71.7619858,    -9.090909
  30624,   11.7737026,   72.5679855,    -9.090909
  30625,   12.1941919,   73.3739853,    -9.090909
  30626,   12.6146812,   74.1799774,    -9.090909
  30627,   13.0351706,   74.9859772,    -9.090909
  30628,   13.4556599,   75.7919769,    -9.090909
  30629,   9.07211399,   68.8384399, -0.909090936
  30630,   9.46655369,   69.6575012, -0.909090936
  30631,   9.86099339,   70.4765625, -0.909090936
  30632,   10.2554331,   71.2956314, -0.909090936
  30633,   10.6498728,   72.1146927, -0.909090936
  30634,   11.0443125,    72.933754, -0.909090936
  30635,   11.4387522,   73.7528152, -0.909090936
  30636,   11.8331919,   74.5718765, -0.909090936
  30637,   12.2276316,   75.3909378, -0.909090936
  30638,   12.6220713,   76.2100067, -0.909090936
  30639,   9.07211399,   68.8384399,  -1.81818187
  30640,   9.46655369,   69.6575012,  -1.81818187
  30641,   9.86099339,   70.4765625,  -1.81818187
  30642,   10.2554331,   71.2956314,  -1.81818187
  30643,   10.6498728,   72.1146927,  -1.81818187
  30644,   11.0443125,    72.933754,  -1.81818187
  30645,   11.4387522,   73.7528152,  -1.81818187
  30646,   11.8331919,   74.5718765,  -1.81818187
  30647,   12.2276316,   75.3909378,  -1.81818187
  30648,   12.6220713,   76.2100067,  -1.81818187
  30649,   9.07211399,   68.8384399,  -2.72727275
  30650,   9.46655369,   69.6575012,  -2.72727275
  30651,   9.86099339,   70.4765625,  -2.72727275
  30652,   10.2554331,   71.2956314,  -2.72727275
  30653,   10.6498728,   72.1146927,  -2.72727275
  30654,   11.0443125,    72.933754,  -2.72727275
  30655,   11.4387522,   73.7528152,  -2.72727275
  30656,   11.8331919,   74.5718765,  -2.72727275
  30657,   12.2276316,   75.3909378,  -2.72727275
  30658,   12.6220713,   76.2100067,  -2.72727275
  30659,   9.07211399,   68.8384399,  -3.63636374
  30660,   9.46655369,   69.6575012,  -3.63636374
  30661,   9.86099339,   70.4765625,  -3.63636374
  30662,   10.2554331,   71.2956314,  -3.63636374
  30663,   10.6498728,   72.1146927,  -3.63636374
  30664,   11.0443125,    72.933754,  -3.63636374
  30665,   11.4387522,   73.7528152,  -3.63636374
  30666,   11.8331919,   74.5718765,  -3.63636374
  30667,   12.2276316,   75.3909378,  -3.63636374
  30668,   12.6220713,   76.2100067,  -3.63636374
  30669,   9.07211399,   68.8384399,   -4.5454545
  30670,   9.46655369,   69.6575012,   -4.5454545
  30671,   9.86099339,   70.4765625,   -4.5454545
  30672,   10.2554331,   71.2956314,   -4.5454545
  30673,   10.6498728,   72.1146927,   -4.5454545
  30674,   11.0443125,    72.933754,   -4.5454545
  30675,   11.4387522,   73.7528152,   -4.5454545
  30676,   11.8331919,   74.5718765,   -4.5454545
  30677,   12.2276316,   75.3909378,   -4.5454545
  30678,   12.6220713,   76.2100067,   -4.5454545
  30679,   9.07211399,   68.8384399,   -5.4545455
  30680,   9.46655369,   69.6575012,   -5.4545455
  30681,   9.86099339,   70.4765625,   -5.4545455
  30682,   10.2554331,   71.2956314,   -5.4545455
  30683,   10.6498728,   72.1146927,   -5.4545455
  30684,   11.0443125,    72.933754,   -5.4545455
  30685,   11.4387522,   73.7528152,   -5.4545455
  30686,   11.8331919,   74.5718765,   -5.4545455
  30687,   12.2276316,   75.3909378,   -5.4545455
  30688,   12.6220713,   76.2100067,   -5.4545455
  30689,   9.07211399,   68.8384399,  -6.36363649
  30690,   9.46655369,   69.6575012,  -6.36363649
  30691,   9.86099339,   70.4765625,  -6.36363649
  30692,   10.2554331,   71.2956314,  -6.36363649
  30693,   10.6498728,   72.1146927,  -6.36363649
  30694,   11.0443125,    72.933754,  -6.36363649
  30695,   11.4387522,   73.7528152,  -6.36363649
  30696,   11.8331919,   74.5718765,  -6.36363649
  30697,   12.2276316,   75.3909378,  -6.36363649
  30698,   12.6220713,   76.2100067,  -6.36363649
  30699,   9.07211399,   68.8384399,  -7.27272749
  30700,   9.46655369,   69.6575012,  -7.27272749
  30701,   9.86099339,   70.4765625,  -7.27272749
  30702,   10.2554331,   71.2956314,  -7.27272749
  30703,   10.6498728,   72.1146927,  -7.27272749
  30704,   11.0443125,    72.933754,  -7.27272749
  30705,   11.4387522,   73.7528152,  -7.27272749
  30706,   11.8331919,   74.5718765,  -7.27272749
  30707,   12.2276316,   75.3909378,  -7.27272749
  30708,   12.6220713,   76.2100067,  -7.27272749
  30709,   9.07211399,   68.8384399,  -8.18181801
  30710,   9.46655369,   69.6575012,  -8.18181801
  30711,   9.86099339,   70.4765625,  -8.18181801
  30712,   10.2554331,   71.2956314,  -8.18181801
  30713,   10.6498728,   72.1146927,  -8.18181801
  30714,   11.0443125,    72.933754,  -8.18181801
  30715,   11.4387522,   73.7528152,  -8.18181801
  30716,   11.8331919,   74.5718765,  -8.18181801
  30717,   12.2276316,   75.3909378,  -8.18181801
  30718,   12.6220713,   76.2100067,  -8.18181801
  30719,   9.07211399,   68.8384399,    -9.090909
  30720,   9.46655369,   69.6575012,    -9.090909
  30721,   9.86099339,   70.4765625,    -9.090909
  30722,   10.2554331,   71.2956314,    -9.090909
  30723,   10.6498728,   72.1146927,    -9.090909
  30724,   11.0443125,    72.933754,    -9.090909
  30725,   11.4387522,   73.7528152,    -9.090909
  30726,   11.8331919,   74.5718765,    -9.090909
  30727,   12.2276316,   75.3909378,    -9.090909
  30728,   12.6220713,   76.2100067,    -9.090909
  30729,    8.4636507,   69.1195374, -0.909090936
  30730,   8.83163548,   69.9508209, -0.909090936
  30731,   9.19962025,   70.7821045, -0.909090936
  30732,   9.56760502,   71.6133881, -0.909090936
  30733,   9.93558979,   72.4446716, -0.909090936
  30734,   10.3035755,   73.2759552, -0.909090936
  30735,   10.6715603,   74.1072388, -0.909090936
  30736,   11.0395451,   74.9385223, -0.909090936
  30737,   11.4075298,   75.7698135, -0.909090936
  30738,   11.7755146,   76.6010971, -0.909090936
  30739,    8.4636507,   69.1195374,  -1.81818187
  30740,   8.83163548,   69.9508209,  -1.81818187
  30741,   9.19962025,   70.7821045,  -1.81818187
  30742,   9.56760502,   71.6133881,  -1.81818187
  30743,   9.93558979,   72.4446716,  -1.81818187
  30744,   10.3035755,   73.2759552,  -1.81818187
  30745,   10.6715603,   74.1072388,  -1.81818187
  30746,   11.0395451,   74.9385223,  -1.81818187
  30747,   11.4075298,   75.7698135,  -1.81818187
  30748,   11.7755146,   76.6010971,  -1.81818187
  30749,    8.4636507,   69.1195374,  -2.72727275
  30750,   8.83163548,   69.9508209,  -2.72727275
  30751,   9.19962025,   70.7821045,  -2.72727275
  30752,   9.56760502,   71.6133881,  -2.72727275
  30753,   9.93558979,   72.4446716,  -2.72727275
  30754,   10.3035755,   73.2759552,  -2.72727275
  30755,   10.6715603,   74.1072388,  -2.72727275
  30756,   11.0395451,   74.9385223,  -2.72727275
  30757,   11.4075298,   75.7698135,  -2.72727275
  30758,   11.7755146,   76.6010971,  -2.72727275
  30759,    8.4636507,   69.1195374,  -3.63636374
  30760,   8.83163548,   69.9508209,  -3.63636374
  30761,   9.19962025,   70.7821045,  -3.63636374
  30762,   9.56760502,   71.6133881,  -3.63636374
  30763,   9.93558979,   72.4446716,  -3.63636374
  30764,   10.3035755,   73.2759552,  -3.63636374
  30765,   10.6715603,   74.1072388,  -3.63636374
  30766,   11.0395451,   74.9385223,  -3.63636374
  30767,   11.4075298,   75.7698135,  -3.63636374
  30768,   11.7755146,   76.6010971,  -3.63636374
  30769,    8.4636507,   69.1195374,   -4.5454545
  30770,   8.83163548,   69.9508209,   -4.5454545
  30771,   9.19962025,   70.7821045,   -4.5454545
  30772,   9.56760502,   71.6133881,   -4.5454545
  30773,   9.93558979,   72.4446716,   -4.5454545
  30774,   10.3035755,   73.2759552,   -4.5454545
  30775,   10.6715603,   74.1072388,   -4.5454545
  30776,   11.0395451,   74.9385223,   -4.5454545
  30777,   11.4075298,   75.7698135,   -4.5454545
  30778,   11.7755146,   76.6010971,   -4.5454545
  30779,    8.4636507,   69.1195374,   -5.4545455
  30780,   8.83163548,   69.9508209,   -5.4545455
  30781,   9.19962025,   70.7821045,   -5.4545455
  30782,   9.56760502,   71.6133881,   -5.4545455
  30783,   9.93558979,   72.4446716,   -5.4545455
  30784,   10.3035755,   73.2759552,   -5.4545455
  30785,   10.6715603,   74.1072388,   -5.4545455
  30786,   11.0395451,   74.9385223,   -5.4545455
  30787,   11.4075298,   75.7698135,   -5.4545455
  30788,   11.7755146,   76.6010971,   -5.4545455
  30789,    8.4636507,   69.1195374,  -6.36363649
  30790,   8.83163548,   69.9508209,  -6.36363649
  30791,   9.19962025,   70.7821045,  -6.36363649
  30792,   9.56760502,   71.6133881,  -6.36363649
  30793,   9.93558979,   72.4446716,  -6.36363649
  30794,   10.3035755,   73.2759552,  -6.36363649
  30795,   10.6715603,   74.1072388,  -6.36363649
  30796,   11.0395451,   74.9385223,  -6.36363649
  30797,   11.4075298,   75.7698135,  -6.36363649
  30798,   11.7755146,   76.6010971,  -6.36363649
  30799,    8.4636507,   69.1195374,  -7.27272749
  30800,   8.83163548,   69.9508209,  -7.27272749
  30801,   9.19962025,   70.7821045,  -7.27272749
  30802,   9.56760502,   71.6133881,  -7.27272749
  30803,   9.93558979,   72.4446716,  -7.27272749
  30804,   10.3035755,   73.2759552,  -7.27272749
  30805,   10.6715603,   74.1072388,  -7.27272749
  30806,   11.0395451,   74.9385223,  -7.27272749
  30807,   11.4075298,   75.7698135,  -7.27272749
  30808,   11.7755146,   76.6010971,  -7.27272749
  30809,    8.4636507,   69.1195374,  -8.18181801
  30810,   8.83163548,   69.9508209,  -8.18181801
  30811,   9.19962025,   70.7821045,  -8.18181801
  30812,   9.56760502,   71.6133881,  -8.18181801
  30813,   9.93558979,   72.4446716,  -8.18181801
  30814,   10.3035755,   73.2759552,  -8.18181801
  30815,   10.6715603,   74.1072388,  -8.18181801
  30816,   11.0395451,   74.9385223,  -8.18181801
  30817,   11.4075298,   75.7698135,  -8.18181801
  30818,   11.7755146,   76.6010971,  -8.18181801
  30819,    8.4636507,   69.1195374,    -9.090909
  30820,   8.83163548,   69.9508209,    -9.090909
  30821,   9.19962025,   70.7821045,    -9.090909
  30822,   9.56760502,   71.6133881,    -9.090909
  30823,   9.93558979,   72.4446716,    -9.090909
  30824,   10.3035755,   73.2759552,    -9.090909
  30825,   10.6715603,   74.1072388,    -9.090909
  30826,   11.0395451,   74.9385223,    -9.090909
  30827,   11.4075298,   75.7698135,    -9.090909
  30828,   11.7755146,   76.6010971,    -9.090909
  30829,   7.84649086,   69.3809891, -0.909090936
  30830,   8.18764305,   70.2236404, -0.909090936
  30831,   8.52879429,   71.0662918, -0.909090936
  30832,   8.86994648,   71.9089432, -0.909090936
  30833,   9.21109867,   72.7515945, -0.909090936
  30834,   9.55225086,   73.5942459, -0.909090936
  30835,   9.89340305,   74.4368973, -0.909090936
  30836,   10.2345543,   75.2795486, -0.909090936
  30837,   10.5757065,      76.1222, -0.909090936
  30838,   10.9168587,   76.9648514, -0.909090936
  30839,   7.84649086,   69.3809891,  -1.81818187
  30840,   8.18764305,   70.2236404,  -1.81818187
  30841,   8.52879429,   71.0662918,  -1.81818187
  30842,   8.86994648,   71.9089432,  -1.81818187
  30843,   9.21109867,   72.7515945,  -1.81818187
  30844,   9.55225086,   73.5942459,  -1.81818187
  30845,   9.89340305,   74.4368973,  -1.81818187
  30846,   10.2345543,   75.2795486,  -1.81818187
  30847,   10.5757065,      76.1222,  -1.81818187
  30848,   10.9168587,   76.9648514,  -1.81818187
  30849,   7.84649086,   69.3809891,  -2.72727275
  30850,   8.18764305,   70.2236404,  -2.72727275
  30851,   8.52879429,   71.0662918,  -2.72727275
  30852,   8.86994648,   71.9089432,  -2.72727275
  30853,   9.21109867,   72.7515945,  -2.72727275
  30854,   9.55225086,   73.5942459,  -2.72727275
  30855,   9.89340305,   74.4368973,  -2.72727275
  30856,   10.2345543,   75.2795486,  -2.72727275
  30857,   10.5757065,      76.1222,  -2.72727275
  30858,   10.9168587,   76.9648514,  -2.72727275
  30859,   7.84649086,   69.3809891,  -3.63636374
  30860,   8.18764305,   70.2236404,  -3.63636374
  30861,   8.52879429,   71.0662918,  -3.63636374
  30862,   8.86994648,   71.9089432,  -3.63636374
  30863,   9.21109867,   72.7515945,  -3.63636374
  30864,   9.55225086,   73.5942459,  -3.63636374
  30865,   9.89340305,   74.4368973,  -3.63636374
  30866,   10.2345543,   75.2795486,  -3.63636374
  30867,   10.5757065,      76.1222,  -3.63636374
  30868,   10.9168587,   76.9648514,  -3.63636374
  30869,   7.84649086,   69.3809891,   -4.5454545
  30870,   8.18764305,   70.2236404,   -4.5454545
  30871,   8.52879429,   71.0662918,   -4.5454545
  30872,   8.86994648,   71.9089432,   -4.5454545
  30873,   9.21109867,   72.7515945,   -4.5454545
  30874,   9.55225086,   73.5942459,   -4.5454545
  30875,   9.89340305,   74.4368973,   -4.5454545
  30876,   10.2345543,   75.2795486,   -4.5454545
  30877,   10.5757065,      76.1222,   -4.5454545
  30878,   10.9168587,   76.9648514,   -4.5454545
  30879,   7.84649086,   69.3809891,   -5.4545455
  30880,   8.18764305,   70.2236404,   -5.4545455
  30881,   8.52879429,   71.0662918,   -5.4545455
  30882,   8.86994648,   71.9089432,   -5.4545455
  30883,   9.21109867,   72.7515945,   -5.4545455
  30884,   9.55225086,   73.5942459,   -5.4545455
  30885,   9.89340305,   74.4368973,   -5.4545455
  30886,   10.2345543,   75.2795486,   -5.4545455
  30887,   10.5757065,      76.1222,   -5.4545455
  30888,   10.9168587,   76.9648514,   -5.4545455
  30889,   7.84649086,   69.3809891,  -6.36363649
  30890,   8.18764305,   70.2236404,  -6.36363649
  30891,   8.52879429,   71.0662918,  -6.36363649
  30892,   8.86994648,   71.9089432,  -6.36363649
  30893,   9.21109867,   72.7515945,  -6.36363649
  30894,   9.55225086,   73.5942459,  -6.36363649
  30895,   9.89340305,   74.4368973,  -6.36363649
  30896,   10.2345543,   75.2795486,  -6.36363649
  30897,   10.5757065,      76.1222,  -6.36363649
  30898,   10.9168587,   76.9648514,  -6.36363649
  30899,   7.84649086,   69.3809891,  -7.27272749
  30900,   8.18764305,   70.2236404,  -7.27272749
  30901,   8.52879429,   71.0662918,  -7.27272749
  30902,   8.86994648,   71.9089432,  -7.27272749
  30903,   9.21109867,   72.7515945,  -7.27272749
  30904,   9.55225086,   73.5942459,  -7.27272749
  30905,   9.89340305,   74.4368973,  -7.27272749
  30906,   10.2345543,   75.2795486,  -7.27272749
  30907,   10.5757065,      76.1222,  -7.27272749
  30908,   10.9168587,   76.9648514,  -7.27272749
  30909,   7.84649086,   69.3809891,  -8.18181801
  30910,   8.18764305,   70.2236404,  -8.18181801
  30911,   8.52879429,   71.0662918,  -8.18181801
  30912,   8.86994648,   71.9089432,  -8.18181801
  30913,   9.21109867,   72.7515945,  -8.18181801
  30914,   9.55225086,   73.5942459,  -8.18181801
  30915,   9.89340305,   74.4368973,  -8.18181801
  30916,   10.2345543,   75.2795486,  -8.18181801
  30917,   10.5757065,      76.1222,  -8.18181801
  30918,   10.9168587,   76.9648514,  -8.18181801
  30919,   7.84649086,   69.3809891,    -9.090909
  30920,   8.18764305,   70.2236404,    -9.090909
  30921,   8.52879429,   71.0662918,    -9.090909
  30922,   8.86994648,   71.9089432,    -9.090909
  30923,   9.21109867,   72.7515945,    -9.090909
  30924,   9.55225086,   73.5942459,    -9.090909
  30925,   9.89340305,   74.4368973,    -9.090909
  30926,   10.2345543,   75.2795486,    -9.090909
  30927,   10.5757065,      76.1222,    -9.090909
  30928,   10.9168587,   76.9648514,    -9.090909
  30929,   7.22126818,   69.6225204, -0.909090936
  30930,   7.53523684,   70.4756775, -0.909090936
  30931,   7.84920549,   71.3288269, -0.909090936
  30932,   8.16317272,   72.1819839, -0.909090936
  30933,   8.47714138,   73.0351334, -0.909090936
  30934,   8.79111004,   73.8882904, -0.909090936
  30935,    9.1050787,   74.7414398, -0.909090936
  30936,   9.41904736,   75.5945969, -0.909090936
  30937,   9.73301506,   76.4477463, -0.909090936
  30938,   10.0469837,   77.3009033, -0.909090936
  30939,   7.22126818,   69.6225204,  -1.81818187
  30940,   7.53523684,   70.4756775,  -1.81818187
  30941,   7.84920549,   71.3288269,  -1.81818187
  30942,   8.16317272,   72.1819839,  -1.81818187
  30943,   8.47714138,   73.0351334,  -1.81818187
  30944,   8.79111004,   73.8882904,  -1.81818187
  30945,    9.1050787,   74.7414398,  -1.81818187
  30946,   9.41904736,   75.5945969,  -1.81818187
  30947,   9.73301506,   76.4477463,  -1.81818187
  30948,   10.0469837,   77.3009033,  -1.81818187
  30949,   7.22126818,   69.6225204,  -2.72727275
  30950,   7.53523684,   70.4756775,  -2.72727275
  30951,   7.84920549,   71.3288269,  -2.72727275
  30952,   8.16317272,   72.1819839,  -2.72727275
  30953,   8.47714138,   73.0351334,  -2.72727275
  30954,   8.79111004,   73.8882904,  -2.72727275
  30955,    9.1050787,   74.7414398,  -2.72727275
  30956,   9.41904736,   75.5945969,  -2.72727275
  30957,   9.73301506,   76.4477463,  -2.72727275
  30958,   10.0469837,   77.3009033,  -2.72727275
  30959,   7.22126818,   69.6225204,  -3.63636374
  30960,   7.53523684,   70.4756775,  -3.63636374
  30961,   7.84920549,   71.3288269,  -3.63636374
  30962,   8.16317272,   72.1819839,  -3.63636374
  30963,   8.47714138,   73.0351334,  -3.63636374
  30964,   8.79111004,   73.8882904,  -3.63636374
  30965,    9.1050787,   74.7414398,  -3.63636374
  30966,   9.41904736,   75.5945969,  -3.63636374
  30967,   9.73301506,   76.4477463,  -3.63636374
  30968,   10.0469837,   77.3009033,  -3.63636374
  30969,   7.22126818,   69.6225204,   -4.5454545
  30970,   7.53523684,   70.4756775,   -4.5454545
  30971,   7.84920549,   71.3288269,   -4.5454545
  30972,   8.16317272,   72.1819839,   -4.5454545
  30973,   8.47714138,   73.0351334,   -4.5454545
  30974,   8.79111004,   73.8882904,   -4.5454545
  30975,    9.1050787,   74.7414398,   -4.5454545
  30976,   9.41904736,   75.5945969,   -4.5454545
  30977,   9.73301506,   76.4477463,   -4.5454545
  30978,   10.0469837,   77.3009033,   -4.5454545
  30979,   7.22126818,   69.6225204,   -5.4545455
  30980,   7.53523684,   70.4756775,   -5.4545455
  30981,   7.84920549,   71.3288269,   -5.4545455
  30982,   8.16317272,   72.1819839,   -5.4545455
  30983,   8.47714138,   73.0351334,   -5.4545455
  30984,   8.79111004,   73.8882904,   -5.4545455
  30985,    9.1050787,   74.7414398,   -5.4545455
  30986,   9.41904736,   75.5945969,   -5.4545455
  30987,   9.73301506,   76.4477463,   -5.4545455
  30988,   10.0469837,   77.3009033,   -5.4545455
  30989,   7.22126818,   69.6225204,  -6.36363649
  30990,   7.53523684,   70.4756775,  -6.36363649
  30991,   7.84920549,   71.3288269,  -6.36363649
  30992,   8.16317272,   72.1819839,  -6.36363649
  30993,   8.47714138,   73.0351334,  -6.36363649
  30994,   8.79111004,   73.8882904,  -6.36363649
  30995,    9.1050787,   74.7414398,  -6.36363649
  30996,   9.41904736,   75.5945969,  -6.36363649
  30997,   9.73301506,   76.4477463,  -6.36363649
  30998,   10.0469837,   77.3009033,  -6.36363649
  30999,   7.22126818,   69.6225204,  -7.27272749
  31000,   7.53523684,   70.4756775,  -7.27272749
  31001,   7.84920549,   71.3288269,  -7.27272749
  31002,   8.16317272,   72.1819839,  -7.27272749
  31003,   8.47714138,   73.0351334,  -7.27272749
  31004,   8.79111004,   73.8882904,  -7.27272749
  31005,    9.1050787,   74.7414398,  -7.27272749
  31006,   9.41904736,   75.5945969,  -7.27272749
  31007,   9.73301506,   76.4477463,  -7.27272749
  31008,   10.0469837,   77.3009033,  -7.27272749
  31009,   7.22126818,   69.6225204,  -8.18181801
  31010,   7.53523684,   70.4756775,  -8.18181801
  31011,   7.84920549,   71.3288269,  -8.18181801
  31012,   8.16317272,   72.1819839,  -8.18181801
  31013,   8.47714138,   73.0351334,  -8.18181801
  31014,   8.79111004,   73.8882904,  -8.18181801
  31015,    9.1050787,   74.7414398,  -8.18181801
  31016,   9.41904736,   75.5945969,  -8.18181801
  31017,   9.73301506,   76.4477463,  -8.18181801
  31018,   10.0469837,   77.3009033,  -8.18181801
  31019,   7.22126818,   69.6225204,    -9.090909
  31020,   7.53523684,   70.4756775,    -9.090909
  31021,   7.84920549,   71.3288269,    -9.090909
  31022,   8.16317272,   72.1819839,    -9.090909
  31023,   8.47714138,   73.0351334,    -9.090909
  31024,   8.79111004,   73.8882904,    -9.090909
  31025,    9.1050787,   74.7414398,    -9.090909
  31026,   9.41904736,   75.5945969,    -9.090909
  31027,   9.73301506,   76.4477463,    -9.090909
  31028,   10.0469837,   77.3009033,    -9.090909
  31029,   6.58862591,    69.843895, -0.909090936
  31030,   6.87508774,   70.7066727, -0.909090936
  31031,   7.16155005,   71.5694504, -0.909090936
  31032,   7.44801188,   72.4322281, -0.909090936
  31033,   7.73447418,   73.2950058, -0.909090936
  31034,   8.02093601,   74.1577835, -0.909090936
  31035,    8.3073988,   75.0205612, -0.909090936
  31036,   8.59386063,   75.8833389, -0.909090936
  31037,   8.88032246,   76.7461166, -0.909090936
  31038,   9.16678429,   77.6088943, -0.909090936
  31039,   6.58862591,    69.843895,  -1.81818187
  31040,   6.87508774,   70.7066727,  -1.81818187
  31041,   7.16155005,   71.5694504,  -1.81818187
  31042,   7.44801188,   72.4322281,  -1.81818187
  31043,   7.73447418,   73.2950058,  -1.81818187
  31044,   8.02093601,   74.1577835,  -1.81818187
  31045,    8.3073988,   75.0205612,  -1.81818187
  31046,   8.59386063,   75.8833389,  -1.81818187
  31047,   8.88032246,   76.7461166,  -1.81818187
  31048,   9.16678429,   77.6088943,  -1.81818187
  31049,   6.58862591,    69.843895,  -2.72727275
  31050,   6.87508774,   70.7066727,  -2.72727275
  31051,   7.16155005,   71.5694504,  -2.72727275
  31052,   7.44801188,   72.4322281,  -2.72727275
  31053,   7.73447418,   73.2950058,  -2.72727275
  31054,   8.02093601,   74.1577835,  -2.72727275
  31055,    8.3073988,   75.0205612,  -2.72727275
  31056,   8.59386063,   75.8833389,  -2.72727275
  31057,   8.88032246,   76.7461166,  -2.72727275
  31058,   9.16678429,   77.6088943,  -2.72727275
  31059,   6.58862591,    69.843895,  -3.63636374
  31060,   6.87508774,   70.7066727,  -3.63636374
  31061,   7.16155005,   71.5694504,  -3.63636374
  31062,   7.44801188,   72.4322281,  -3.63636374
  31063,   7.73447418,   73.2950058,  -3.63636374
  31064,   8.02093601,   74.1577835,  -3.63636374
  31065,    8.3073988,   75.0205612,  -3.63636374
  31066,   8.59386063,   75.8833389,  -3.63636374
  31067,   8.88032246,   76.7461166,  -3.63636374
  31068,   9.16678429,   77.6088943,  -3.63636374
  31069,   6.58862591,    69.843895,   -4.5454545
  31070,   6.87508774,   70.7066727,   -4.5454545
  31071,   7.16155005,   71.5694504,   -4.5454545
  31072,   7.44801188,   72.4322281,   -4.5454545
  31073,   7.73447418,   73.2950058,   -4.5454545
  31074,   8.02093601,   74.1577835,   -4.5454545
  31075,    8.3073988,   75.0205612,   -4.5454545
  31076,   8.59386063,   75.8833389,   -4.5454545
  31077,   8.88032246,   76.7461166,   -4.5454545
  31078,   9.16678429,   77.6088943,   -4.5454545
  31079,   6.58862591,    69.843895,   -5.4545455
  31080,   6.87508774,   70.7066727,   -5.4545455
  31081,   7.16155005,   71.5694504,   -5.4545455
  31082,   7.44801188,   72.4322281,   -5.4545455
  31083,   7.73447418,   73.2950058,   -5.4545455
  31084,   8.02093601,   74.1577835,   -5.4545455
  31085,    8.3073988,   75.0205612,   -5.4545455
  31086,   8.59386063,   75.8833389,   -5.4545455
  31087,   8.88032246,   76.7461166,   -5.4545455
  31088,   9.16678429,   77.6088943,   -5.4545455
  31089,   6.58862591,    69.843895,  -6.36363649
  31090,   6.87508774,   70.7066727,  -6.36363649
  31091,   7.16155005,   71.5694504,  -6.36363649
  31092,   7.44801188,   72.4322281,  -6.36363649
  31093,   7.73447418,   73.2950058,  -6.36363649
  31094,   8.02093601,   74.1577835,  -6.36363649
  31095,    8.3073988,   75.0205612,  -6.36363649
  31096,   8.59386063,   75.8833389,  -6.36363649
  31097,   8.88032246,   76.7461166,  -6.36363649
  31098,   9.16678429,   77.6088943,  -6.36363649
  31099,   6.58862591,    69.843895,  -7.27272749
  31100,   6.87508774,   70.7066727,  -7.27272749
  31101,   7.16155005,   71.5694504,  -7.27272749
  31102,   7.44801188,   72.4322281,  -7.27272749
  31103,   7.73447418,   73.2950058,  -7.27272749
  31104,   8.02093601,   74.1577835,  -7.27272749
  31105,    8.3073988,   75.0205612,  -7.27272749
  31106,   8.59386063,   75.8833389,  -7.27272749
  31107,   8.88032246,   76.7461166,  -7.27272749
  31108,   9.16678429,   77.6088943,  -7.27272749
  31109,   6.58862591,    69.843895,  -8.18181801
  31110,   6.87508774,   70.7066727,  -8.18181801
  31111,   7.16155005,   71.5694504,  -8.18181801
  31112,   7.44801188,   72.4322281,  -8.18181801
  31113,   7.73447418,   73.2950058,  -8.18181801
  31114,   8.02093601,   74.1577835,  -8.18181801
  31115,    8.3073988,   75.0205612,  -8.18181801
  31116,   8.59386063,   75.8833389,  -8.18181801
  31117,   8.88032246,   76.7461166,  -8.18181801
  31118,   9.16678429,   77.6088943,  -8.18181801
  31119,   6.58862591,    69.843895,    -9.090909
  31120,   6.87508774,   70.7066727,    -9.090909
  31121,   7.16155005,   71.5694504,    -9.090909
  31122,   7.44801188,   72.4322281,    -9.090909
  31123,   7.73447418,   73.2950058,    -9.090909
  31124,   8.02093601,   74.1577835,    -9.090909
  31125,    8.3073988,   75.0205612,    -9.090909
  31126,   8.59386063,   75.8833389,    -9.090909
  31127,   8.88032246,   76.7461166,    -9.090909
  31128,   9.16678429,   77.6088943,    -9.090909
  31129,    5.9492135,   70.0448761, -0.909090936
  31130,   6.20787525,   70.9163895, -0.909090936
  31131,   6.46653652,   71.7879028, -0.909090936
  31132,   6.72519779,   72.6594238, -0.909090936
  31133,   6.98385954,   73.5309372, -0.909090936
  31134,   7.24252129,   74.4024582, -0.909090936
  31135,   7.50118256,   75.2739716, -0.909090936
  31136,    7.7598443,   76.1454849, -0.909090936
  31137,   8.01850605,   77.0170059, -0.909090936
  31138,   8.27716732,   77.8885193, -0.909090936
  31139,    5.9492135,   70.0448761,  -1.81818187
  31140,   6.20787525,   70.9163895,  -1.81818187
  31141,   6.46653652,   71.7879028,  -1.81818187
  31142,   6.72519779,   72.6594238,  -1.81818187
  31143,   6.98385954,   73.5309372,  -1.81818187
  31144,   7.24252129,   74.4024582,  -1.81818187
  31145,   7.50118256,   75.2739716,  -1.81818187
  31146,    7.7598443,   76.1454849,  -1.81818187
  31147,   8.01850605,   77.0170059,  -1.81818187
  31148,   8.27716732,   77.8885193,  -1.81818187
  31149,    5.9492135,   70.0448761,  -2.72727275
  31150,   6.20787525,   70.9163895,  -2.72727275
  31151,   6.46653652,   71.7879028,  -2.72727275
  31152,   6.72519779,   72.6594238,  -2.72727275
  31153,   6.98385954,   73.5309372,  -2.72727275
  31154,   7.24252129,   74.4024582,  -2.72727275
  31155,   7.50118256,   75.2739716,  -2.72727275
  31156,    7.7598443,   76.1454849,  -2.72727275
  31157,   8.01850605,   77.0170059,  -2.72727275
  31158,   8.27716732,   77.8885193,  -2.72727275
  31159,    5.9492135,   70.0448761,  -3.63636374
  31160,   6.20787525,   70.9163895,  -3.63636374
  31161,   6.46653652,   71.7879028,  -3.63636374
  31162,   6.72519779,   72.6594238,  -3.63636374
  31163,   6.98385954,   73.5309372,  -3.63636374
  31164,   7.24252129,   74.4024582,  -3.63636374
  31165,   7.50118256,   75.2739716,  -3.63636374
  31166,    7.7598443,   76.1454849,  -3.63636374
  31167,   8.01850605,   77.0170059,  -3.63636374
  31168,   8.27716732,   77.8885193,  -3.63636374
  31169,    5.9492135,   70.0448761,   -4.5454545
  31170,   6.20787525,   70.9163895,   -4.5454545
  31171,   6.46653652,   71.7879028,   -4.5454545
  31172,   6.72519779,   72.6594238,   -4.5454545
  31173,   6.98385954,   73.5309372,   -4.5454545
  31174,   7.24252129,   74.4024582,   -4.5454545
  31175,   7.50118256,   75.2739716,   -4.5454545
  31176,    7.7598443,   76.1454849,   -4.5454545
  31177,   8.01850605,   77.0170059,   -4.5454545
  31178,   8.27716732,   77.8885193,   -4.5454545
  31179,    5.9492135,   70.0448761,   -5.4545455
  31180,   6.20787525,   70.9163895,   -5.4545455
  31181,   6.46653652,   71.7879028,   -5.4545455
  31182,   6.72519779,   72.6594238,   -5.4545455
  31183,   6.98385954,   73.5309372,   -5.4545455
  31184,   7.24252129,   74.4024582,   -5.4545455
  31185,   7.50118256,   75.2739716,   -5.4545455
  31186,    7.7598443,   76.1454849,   -5.4545455
  31187,   8.01850605,   77.0170059,   -5.4545455
  31188,   8.27716732,   77.8885193,   -5.4545455
  31189,    5.9492135,   70.0448761,  -6.36363649
  31190,   6.20787525,   70.9163895,  -6.36363649
  31191,   6.46653652,   71.7879028,  -6.36363649
  31192,   6.72519779,   72.6594238,  -6.36363649
  31193,   6.98385954,   73.5309372,  -6.36363649
  31194,   7.24252129,   74.4024582,  -6.36363649
  31195,   7.50118256,   75.2739716,  -6.36363649
  31196,    7.7598443,   76.1454849,  -6.36363649
  31197,   8.01850605,   77.0170059,  -6.36363649
  31198,   8.27716732,   77.8885193,  -6.36363649
  31199,    5.9492135,   70.0448761,  -7.27272749
  31200,   6.20787525,   70.9163895,  -7.27272749
  31201,   6.46653652,   71.7879028,  -7.27272749
  31202,   6.72519779,   72.6594238,  -7.27272749
  31203,   6.98385954,   73.5309372,  -7.27272749
  31204,   7.24252129,   74.4024582,  -7.27272749
  31205,   7.50118256,   75.2739716,  -7.27272749
  31206,    7.7598443,   76.1454849,  -7.27272749
  31207,   8.01850605,   77.0170059,  -7.27272749
  31208,   8.27716732,   77.8885193,  -7.27272749
  31209,    5.9492135,   70.0448761,  -8.18181801
  31210,   6.20787525,   70.9163895,  -8.18181801
  31211,   6.46653652,   71.7879028,  -8.18181801
  31212,   6.72519779,   72.6594238,  -8.18181801
  31213,   6.98385954,   73.5309372,  -8.18181801
  31214,   7.24252129,   74.4024582,  -8.18181801
  31215,   7.50118256,   75.2739716,  -8.18181801
  31216,    7.7598443,   76.1454849,  -8.18181801
  31217,   8.01850605,   77.0170059,  -8.18181801
  31218,   8.27716732,   77.8885193,  -8.18181801
  31219,    5.9492135,   70.0448761,    -9.090909
  31220,   6.20787525,   70.9163895,    -9.090909
  31221,   6.46653652,   71.7879028,    -9.090909
  31222,   6.72519779,   72.6594238,    -9.090909
  31223,   6.98385954,   73.5309372,    -9.090909
  31224,   7.24252129,   74.4024582,    -9.090909
  31225,   7.50118256,   75.2739716,    -9.090909
  31226,    7.7598443,   76.1454849,    -9.090909
  31227,   8.01850605,   77.0170059,    -9.090909
  31228,   8.27716732,   77.8885193,    -9.090909
  31229,   5.30368757,   70.2252579, -0.909090936
  31230,   5.53428268,   71.1046143, -0.909090936
  31231,    5.7648778,   71.9839706, -0.909090936
  31232,   5.99547291,   72.8633347, -0.909090936
  31233,   6.22606802,    73.742691, -0.909090936
  31234,   6.45666265,   74.6220474, -0.909090936
  31235,   6.68725777,   75.5014114, -0.909090936
  31236,   6.91785288,   76.3807678, -0.909090936
  31237,   7.14844799,   77.2601242, -0.909090936
  31238,    7.3790431,   78.1394882, -0.909090936
  31239,   5.30368757,   70.2252579,  -1.81818187
  31240,   5.53428268,   71.1046143,  -1.81818187
  31241,    5.7648778,   71.9839706,  -1.81818187
  31242,   5.99547291,   72.8633347,  -1.81818187
  31243,   6.22606802,    73.742691,  -1.81818187
  31244,   6.45666265,   74.6220474,  -1.81818187
  31245,   6.68725777,   75.5014114,  -1.81818187
  31246,   6.91785288,   76.3807678,  -1.81818187
  31247,   7.14844799,   77.2601242,  -1.81818187
  31248,    7.3790431,   78.1394882,  -1.81818187
  31249,   5.30368757,   70.2252579,  -2.72727275
  31250,   5.53428268,   71.1046143,  -2.72727275
  31251,    5.7648778,   71.9839706,  -2.72727275
  31252,   5.99547291,   72.8633347,  -2.72727275
  31253,   6.22606802,    73.742691,  -2.72727275
  31254,   6.45666265,   74.6220474,  -2.72727275
  31255,   6.68725777,   75.5014114,  -2.72727275
  31256,   6.91785288,   76.3807678,  -2.72727275
  31257,   7.14844799,   77.2601242,  -2.72727275
  31258,    7.3790431,   78.1394882,  -2.72727275
  31259,   5.30368757,   70.2252579,  -3.63636374
  31260,   5.53428268,   71.1046143,  -3.63636374
  31261,    5.7648778,   71.9839706,  -3.63636374
  31262,   5.99547291,   72.8633347,  -3.63636374
  31263,   6.22606802,    73.742691,  -3.63636374
  31264,   6.45666265,   74.6220474,  -3.63636374
  31265,   6.68725777,   75.5014114,  -3.63636374
  31266,   6.91785288,   76.3807678,  -3.63636374
  31267,   7.14844799,   77.2601242,  -3.63636374
  31268,    7.3790431,   78.1394882,  -3.63636374
  31269,   5.30368757,   70.2252579,   -4.5454545
  31270,   5.53428268,   71.1046143,   -4.5454545
  31271,    5.7648778,   71.9839706,   -4.5454545
  31272,   5.99547291,   72.8633347,   -4.5454545
  31273,   6.22606802,    73.742691,   -4.5454545
  31274,   6.45666265,   74.6220474,   -4.5454545
  31275,   6.68725777,   75.5014114,   -4.5454545
  31276,   6.91785288,   76.3807678,   -4.5454545
  31277,   7.14844799,   77.2601242,   -4.5454545
  31278,    7.3790431,   78.1394882,   -4.5454545
  31279,   5.30368757,   70.2252579,   -5.4545455
  31280,   5.53428268,   71.1046143,   -5.4545455
  31281,    5.7648778,   71.9839706,   -5.4545455
  31282,   5.99547291,   72.8633347,   -5.4545455
  31283,   6.22606802,    73.742691,   -5.4545455
  31284,   6.45666265,   74.6220474,   -5.4545455
  31285,   6.68725777,   75.5014114,   -5.4545455
  31286,   6.91785288,   76.3807678,   -5.4545455
  31287,   7.14844799,   77.2601242,   -5.4545455
  31288,    7.3790431,   78.1394882,   -5.4545455
  31289,   5.30368757,   70.2252579,  -6.36363649
  31290,   5.53428268,   71.1046143,  -6.36363649
  31291,    5.7648778,   71.9839706,  -6.36363649
  31292,   5.99547291,   72.8633347,  -6.36363649
  31293,   6.22606802,    73.742691,  -6.36363649
  31294,   6.45666265,   74.6220474,  -6.36363649
  31295,   6.68725777,   75.5014114,  -6.36363649
  31296,   6.91785288,   76.3807678,  -6.36363649
  31297,   7.14844799,   77.2601242,  -6.36363649
  31298,    7.3790431,   78.1394882,  -6.36363649
  31299,   5.30368757,   70.2252579,  -7.27272749
  31300,   5.53428268,   71.1046143,  -7.27272749
  31301,    5.7648778,   71.9839706,  -7.27272749
  31302,   5.99547291,   72.8633347,  -7.27272749
  31303,   6.22606802,    73.742691,  -7.27272749
  31304,   6.45666265,   74.6220474,  -7.27272749
  31305,   6.68725777,   75.5014114,  -7.27272749
  31306,   6.91785288,   76.3807678,  -7.27272749
  31307,   7.14844799,   77.2601242,  -7.27272749
  31308,    7.3790431,   78.1394882,  -7.27272749
  31309,   5.30368757,   70.2252579,  -8.18181801
  31310,   5.53428268,   71.1046143,  -8.18181801
  31311,    5.7648778,   71.9839706,  -8.18181801
  31312,   5.99547291,   72.8633347,  -8.18181801
  31313,   6.22606802,    73.742691,  -8.18181801
  31314,   6.45666265,   74.6220474,  -8.18181801
  31315,   6.68725777,   75.5014114,  -8.18181801
  31316,   6.91785288,   76.3807678,  -8.18181801
  31317,   7.14844799,   77.2601242,  -8.18181801
  31318,    7.3790431,   78.1394882,  -8.18181801
  31319,   5.30368757,   70.2252579,    -9.090909
  31320,   5.53428268,   71.1046143,    -9.090909
  31321,    5.7648778,   71.9839706,    -9.090909
  31322,   5.99547291,   72.8633347,    -9.090909
  31323,   6.22606802,    73.742691,    -9.090909
  31324,   6.45666265,   74.6220474,    -9.090909
  31325,   6.68725777,   75.5014114,    -9.090909
  31326,   6.91785288,   76.3807678,    -9.090909
  31327,   7.14844799,   77.2601242,    -9.090909
  31328,    7.3790431,   78.1394882,    -9.090909
  31329,   4.65271044,   70.3848572, -0.909090936
  31330,    4.8550024,   71.2711563, -0.909090936
  31331,   5.05729342,   72.1574554, -0.909090936
  31332,   5.25958538,   73.0437469, -0.909090936
  31333,   5.46187687,   73.9300461, -0.909090936
  31334,   5.66416883,   74.8163452, -0.909090936
  31335,   5.86646032,   75.7026443, -0.909090936
  31336,   6.06875229,   76.5889435, -0.909090936
  31337,   6.27104378,   77.4752426, -0.909090936
  31338,   6.47333527,   78.3615417, -0.909090936
  31339,   4.65271044,   70.3848572,  -1.81818187
  31340,    4.8550024,   71.2711563,  -1.81818187
  31341,   5.05729342,   72.1574554,  -1.81818187
  31342,   5.25958538,   73.0437469,  -1.81818187
  31343,   5.46187687,   73.9300461,  -1.81818187
  31344,   5.66416883,   74.8163452,  -1.81818187
  31345,   5.86646032,   75.7026443,  -1.81818187
  31346,   6.06875229,   76.5889435,  -1.81818187
  31347,   6.27104378,   77.4752426,  -1.81818187
  31348,   6.47333527,   78.3615417,  -1.81818187
  31349,   4.65271044,   70.3848572,  -2.72727275
  31350,    4.8550024,   71.2711563,  -2.72727275
  31351,   5.05729342,   72.1574554,  -2.72727275
  31352,   5.25958538,   73.0437469,  -2.72727275
  31353,   5.46187687,   73.9300461,  -2.72727275
  31354,   5.66416883,   74.8163452,  -2.72727275
  31355,   5.86646032,   75.7026443,  -2.72727275
  31356,   6.06875229,   76.5889435,  -2.72727275
  31357,   6.27104378,   77.4752426,  -2.72727275
  31358,   6.47333527,   78.3615417,  -2.72727275
  31359,   4.65271044,   70.3848572,  -3.63636374
  31360,    4.8550024,   71.2711563,  -3.63636374
  31361,   5.05729342,   72.1574554,  -3.63636374
  31362,   5.25958538,   73.0437469,  -3.63636374
  31363,   5.46187687,   73.9300461,  -3.63636374
  31364,   5.66416883,   74.8163452,  -3.63636374
  31365,   5.86646032,   75.7026443,  -3.63636374
  31366,   6.06875229,   76.5889435,  -3.63636374
  31367,   6.27104378,   77.4752426,  -3.63636374
  31368,   6.47333527,   78.3615417,  -3.63636374
  31369,   4.65271044,   70.3848572,   -4.5454545
  31370,    4.8550024,   71.2711563,   -4.5454545
  31371,   5.05729342,   72.1574554,   -4.5454545
  31372,   5.25958538,   73.0437469,   -4.5454545
  31373,   5.46187687,   73.9300461,   -4.5454545
  31374,   5.66416883,   74.8163452,   -4.5454545
  31375,   5.86646032,   75.7026443,   -4.5454545
  31376,   6.06875229,   76.5889435,   -4.5454545
  31377,   6.27104378,   77.4752426,   -4.5454545
  31378,   6.47333527,   78.3615417,   -4.5454545
  31379,   4.65271044,   70.3848572,   -5.4545455
  31380,    4.8550024,   71.2711563,   -5.4545455
  31381,   5.05729342,   72.1574554,   -5.4545455
  31382,   5.25958538,   73.0437469,   -5.4545455
  31383,   5.46187687,   73.9300461,   -5.4545455
  31384,   5.66416883,   74.8163452,   -5.4545455
  31385,   5.86646032,   75.7026443,   -5.4545455
  31386,   6.06875229,   76.5889435,   -5.4545455
  31387,   6.27104378,   77.4752426,   -5.4545455
  31388,   6.47333527,   78.3615417,   -5.4545455
  31389,   4.65271044,   70.3848572,  -6.36363649
  31390,    4.8550024,   71.2711563,  -6.36363649
  31391,   5.05729342,   72.1574554,  -6.36363649
  31392,   5.25958538,   73.0437469,  -6.36363649
  31393,   5.46187687,   73.9300461,  -6.36363649
  31394,   5.66416883,   74.8163452,  -6.36363649
  31395,   5.86646032,   75.7026443,  -6.36363649
  31396,   6.06875229,   76.5889435,  -6.36363649
  31397,   6.27104378,   77.4752426,  -6.36363649
  31398,   6.47333527,   78.3615417,  -6.36363649
  31399,   4.65271044,   70.3848572,  -7.27272749
  31400,    4.8550024,   71.2711563,  -7.27272749
  31401,   5.05729342,   72.1574554,  -7.27272749
  31402,   5.25958538,   73.0437469,  -7.27272749
  31403,   5.46187687,   73.9300461,  -7.27272749
  31404,   5.66416883,   74.8163452,  -7.27272749
  31405,   5.86646032,   75.7026443,  -7.27272749
  31406,   6.06875229,   76.5889435,  -7.27272749
  31407,   6.27104378,   77.4752426,  -7.27272749
  31408,   6.47333527,   78.3615417,  -7.27272749
  31409,   4.65271044,   70.3848572,  -8.18181801
  31410,    4.8550024,   71.2711563,  -8.18181801
  31411,   5.05729342,   72.1574554,  -8.18181801
  31412,   5.25958538,   73.0437469,  -8.18181801
  31413,   5.46187687,   73.9300461,  -8.18181801
  31414,   5.66416883,   74.8163452,  -8.18181801
  31415,   5.86646032,   75.7026443,  -8.18181801
  31416,   6.06875229,   76.5889435,  -8.18181801
  31417,   6.27104378,   77.4752426,  -8.18181801
  31418,   6.47333527,   78.3615417,  -8.18181801
  31419,   4.65271044,   70.3848572,    -9.090909
  31420,    4.8550024,   71.2711563,    -9.090909
  31421,   5.05729342,   72.1574554,    -9.090909
  31422,   5.25958538,   73.0437469,    -9.090909
  31423,   5.46187687,   73.9300461,    -9.090909
  31424,   5.66416883,   74.8163452,    -9.090909
  31425,   5.86646032,   75.7026443,    -9.090909
  31426,   6.06875229,   76.5889435,    -9.090909
  31427,   6.27104378,   77.4752426,    -9.090909
  31428,   6.47333527,   78.3615417,    -9.090909
  31429,   3.99695396,   70.5235062, -0.909090936
  31430,   4.17073441,   71.4158325, -0.909090936
  31431,   4.34451485,   72.3081589, -0.909090936
  31432,   4.51829529,   73.2004929, -0.909090936
  31433,   4.69207525,   74.0928192, -0.909090936
  31434,   4.86585617,   74.9851456, -0.909090936
  31435,   5.03963661,   75.8774719, -0.909090936
  31436,   5.21341705,   76.7697983, -0.909090936
  31437,   5.38719702,   77.6621246, -0.909090936
  31438,   5.56097794,    78.554451, -0.909090936
  31439,   3.99695396,   70.5235062,  -1.81818187
  31440,   4.17073441,   71.4158325,  -1.81818187
  31441,   4.34451485,   72.3081589,  -1.81818187
  31442,   4.51829529,   73.2004929,  -1.81818187
  31443,   4.69207525,   74.0928192,  -1.81818187
  31444,   4.86585617,   74.9851456,  -1.81818187
  31445,   5.03963661,   75.8774719,  -1.81818187
  31446,   5.21341705,   76.7697983,  -1.81818187
  31447,   5.38719702,   77.6621246,  -1.81818187
  31448,   5.56097794,    78.554451,  -1.81818187
  31449,   3.99695396,   70.5235062,  -2.72727275
  31450,   4.17073441,   71.4158325,  -2.72727275
  31451,   4.34451485,   72.3081589,  -2.72727275
  31452,   4.51829529,   73.2004929,  -2.72727275
  31453,   4.69207525,   74.0928192,  -2.72727275
  31454,   4.86585617,   74.9851456,  -2.72727275
  31455,   5.03963661,   75.8774719,  -2.72727275
  31456,   5.21341705,   76.7697983,  -2.72727275
  31457,   5.38719702,   77.6621246,  -2.72727275
  31458,   5.56097794,    78.554451,  -2.72727275
  31459,   3.99695396,   70.5235062,  -3.63636374
  31460,   4.17073441,   71.4158325,  -3.63636374
  31461,   4.34451485,   72.3081589,  -3.63636374
  31462,   4.51829529,   73.2004929,  -3.63636374
  31463,   4.69207525,   74.0928192,  -3.63636374
  31464,   4.86585617,   74.9851456,  -3.63636374
  31465,   5.03963661,   75.8774719,  -3.63636374
  31466,   5.21341705,   76.7697983,  -3.63636374
  31467,   5.38719702,   77.6621246,  -3.63636374
  31468,   5.56097794,    78.554451,  -3.63636374
  31469,   3.99695396,   70.5235062,   -4.5454545
  31470,   4.17073441,   71.4158325,   -4.5454545
  31471,   4.34451485,   72.3081589,   -4.5454545
  31472,   4.51829529,   73.2004929,   -4.5454545
  31473,   4.69207525,   74.0928192,   -4.5454545
  31474,   4.86585617,   74.9851456,   -4.5454545
  31475,   5.03963661,   75.8774719,   -4.5454545
  31476,   5.21341705,   76.7697983,   -4.5454545
  31477,   5.38719702,   77.6621246,   -4.5454545
  31478,   5.56097794,    78.554451,   -4.5454545
  31479,   3.99695396,   70.5235062,   -5.4545455
  31480,   4.17073441,   71.4158325,   -5.4545455
  31481,   4.34451485,   72.3081589,   -5.4545455
  31482,   4.51829529,   73.2004929,   -5.4545455
  31483,   4.69207525,   74.0928192,   -5.4545455
  31484,   4.86585617,   74.9851456,   -5.4545455
  31485,   5.03963661,   75.8774719,   -5.4545455
  31486,   5.21341705,   76.7697983,   -5.4545455
  31487,   5.38719702,   77.6621246,   -5.4545455
  31488,   5.56097794,    78.554451,   -5.4545455
  31489,   3.99695396,   70.5235062,  -6.36363649
  31490,   4.17073441,   71.4158325,  -6.36363649
  31491,   4.34451485,   72.3081589,  -6.36363649
  31492,   4.51829529,   73.2004929,  -6.36363649
  31493,   4.69207525,   74.0928192,  -6.36363649
  31494,   4.86585617,   74.9851456,  -6.36363649
  31495,   5.03963661,   75.8774719,  -6.36363649
  31496,   5.21341705,   76.7697983,  -6.36363649
  31497,   5.38719702,   77.6621246,  -6.36363649
  31498,   5.56097794,    78.554451,  -6.36363649
  31499,   3.99695396,   70.5235062,  -7.27272749
  31500,   4.17073441,   71.4158325,  -7.27272749
  31501,   4.34451485,   72.3081589,  -7.27272749
  31502,   4.51829529,   73.2004929,  -7.27272749
  31503,   4.69207525,   74.0928192,  -7.27272749
  31504,   4.86585617,   74.9851456,  -7.27272749
  31505,   5.03963661,   75.8774719,  -7.27272749
  31506,   5.21341705,   76.7697983,  -7.27272749
  31507,   5.38719702,   77.6621246,  -7.27272749
  31508,   5.56097794,    78.554451,  -7.27272749
  31509,   3.99695396,   70.5235062,  -8.18181801
  31510,   4.17073441,   71.4158325,  -8.18181801
  31511,   4.34451485,   72.3081589,  -8.18181801
  31512,   4.51829529,   73.2004929,  -8.18181801
  31513,   4.69207525,   74.0928192,  -8.18181801
  31514,   4.86585617,   74.9851456,  -8.18181801
  31515,   5.03963661,   75.8774719,  -8.18181801
  31516,   5.21341705,   76.7697983,  -8.18181801
  31517,   5.38719702,   77.6621246,  -8.18181801
  31518,   5.56097794,    78.554451,  -8.18181801
  31519,   3.99695396,   70.5235062,    -9.090909
  31520,   4.17073441,   71.4158325,    -9.090909
  31521,   4.34451485,   72.3081589,    -9.090909
  31522,   4.51829529,   73.2004929,    -9.090909
  31523,   4.69207525,   74.0928192,    -9.090909
  31524,   4.86585617,   74.9851456,    -9.090909
  31525,   5.03963661,   75.8774719,    -9.090909
  31526,   5.21341705,   76.7697983,    -9.090909
  31527,   5.38719702,   77.6621246,    -9.090909
  31528,   5.56097794,    78.554451,    -9.090909
  31529,   3.33708858,   70.6410751, -0.909090936
  31530,    3.4821794,   71.5385132, -0.909090936
  31531,   3.62727022,   72.4359512, -0.909090936
  31532,    3.7723608,   73.3333893, -0.909090936
  31533,   3.91745162,   74.2308273, -0.909090936
  31534,   4.06254244,   75.1282654, -0.909090936
  31535,   4.20763302,   76.0257034, -0.909090936
  31536,   4.35272408,   76.9231415, -0.909090936
  31537,   4.49781466,   77.8205795, -0.909090936
  31538,   4.64290571,   78.7180176, -0.909090936
  31539,   3.33708858,   70.6410751,  -1.81818187
  31540,    3.4821794,   71.5385132,  -1.81818187
  31541,   3.62727022,   72.4359512,  -1.81818187
  31542,    3.7723608,   73.3333893,  -1.81818187
  31543,   3.91745162,   74.2308273,  -1.81818187
  31544,   4.06254244,   75.1282654,  -1.81818187
  31545,   4.20763302,   76.0257034,  -1.81818187
  31546,   4.35272408,   76.9231415,  -1.81818187
  31547,   4.49781466,   77.8205795,  -1.81818187
  31548,   4.64290571,   78.7180176,  -1.81818187
  31549,   3.33708858,   70.6410751,  -2.72727275
  31550,    3.4821794,   71.5385132,  -2.72727275
  31551,   3.62727022,   72.4359512,  -2.72727275
  31552,    3.7723608,   73.3333893,  -2.72727275
  31553,   3.91745162,   74.2308273,  -2.72727275
  31554,   4.06254244,   75.1282654,  -2.72727275
  31555,   4.20763302,   76.0257034,  -2.72727275
  31556,   4.35272408,   76.9231415,  -2.72727275
  31557,   4.49781466,   77.8205795,  -2.72727275
  31558,   4.64290571,   78.7180176,  -2.72727275
  31559,   3.33708858,   70.6410751,  -3.63636374
  31560,    3.4821794,   71.5385132,  -3.63636374
  31561,   3.62727022,   72.4359512,  -3.63636374
  31562,    3.7723608,   73.3333893,  -3.63636374
  31563,   3.91745162,   74.2308273,  -3.63636374
  31564,   4.06254244,   75.1282654,  -3.63636374
  31565,   4.20763302,   76.0257034,  -3.63636374
  31566,   4.35272408,   76.9231415,  -3.63636374
  31567,   4.49781466,   77.8205795,  -3.63636374
  31568,   4.64290571,   78.7180176,  -3.63636374
  31569,   3.33708858,   70.6410751,   -4.5454545
  31570,    3.4821794,   71.5385132,   -4.5454545
  31571,   3.62727022,   72.4359512,   -4.5454545
  31572,    3.7723608,   73.3333893,   -4.5454545
  31573,   3.91745162,   74.2308273,   -4.5454545
  31574,   4.06254244,   75.1282654,   -4.5454545
  31575,   4.20763302,   76.0257034,   -4.5454545
  31576,   4.35272408,   76.9231415,   -4.5454545
  31577,   4.49781466,   77.8205795,   -4.5454545
  31578,   4.64290571,   78.7180176,   -4.5454545
  31579,   3.33708858,   70.6410751,   -5.4545455
  31580,    3.4821794,   71.5385132,   -5.4545455
  31581,   3.62727022,   72.4359512,   -5.4545455
  31582,    3.7723608,   73.3333893,   -5.4545455
  31583,   3.91745162,   74.2308273,   -5.4545455
  31584,   4.06254244,   75.1282654,   -5.4545455
  31585,   4.20763302,   76.0257034,   -5.4545455
  31586,   4.35272408,   76.9231415,   -5.4545455
  31587,   4.49781466,   77.8205795,   -5.4545455
  31588,   4.64290571,   78.7180176,   -5.4545455
  31589,   3.33708858,   70.6410751,  -6.36363649
  31590,    3.4821794,   71.5385132,  -6.36363649
  31591,   3.62727022,   72.4359512,  -6.36363649
  31592,    3.7723608,   73.3333893,  -6.36363649
  31593,   3.91745162,   74.2308273,  -6.36363649
  31594,   4.06254244,   75.1282654,  -6.36363649
  31595,   4.20763302,   76.0257034,  -6.36363649
  31596,   4.35272408,   76.9231415,  -6.36363649
  31597,   4.49781466,   77.8205795,  -6.36363649
  31598,   4.64290571,   78.7180176,  -6.36363649
  31599,   3.33708858,   70.6410751,  -7.27272749
  31600,    3.4821794,   71.5385132,  -7.27272749
  31601,   3.62727022,   72.4359512,  -7.27272749
  31602,    3.7723608,   73.3333893,  -7.27272749
  31603,   3.91745162,   74.2308273,  -7.27272749
  31604,   4.06254244,   75.1282654,  -7.27272749
  31605,   4.20763302,   76.0257034,  -7.27272749
  31606,   4.35272408,   76.9231415,  -7.27272749
  31607,   4.49781466,   77.8205795,  -7.27272749
  31608,   4.64290571,   78.7180176,  -7.27272749
  31609,   3.33708858,   70.6410751,  -8.18181801
  31610,    3.4821794,   71.5385132,  -8.18181801
  31611,   3.62727022,   72.4359512,  -8.18181801
  31612,    3.7723608,   73.3333893,  -8.18181801
  31613,   3.91745162,   74.2308273,  -8.18181801
  31614,   4.06254244,   75.1282654,  -8.18181801
  31615,   4.20763302,   76.0257034,  -8.18181801
  31616,   4.35272408,   76.9231415,  -8.18181801
  31617,   4.49781466,   77.8205795,  -8.18181801
  31618,   4.64290571,   78.7180176,  -8.18181801
  31619,   3.33708858,   70.6410751,    -9.090909
  31620,    3.4821794,   71.5385132,    -9.090909
  31621,   3.62727022,   72.4359512,    -9.090909
  31622,    3.7723608,   73.3333893,    -9.090909
  31623,   3.91745162,   74.2308273,    -9.090909
  31624,   4.06254244,   75.1282654,    -9.090909
  31625,   4.20763302,   76.0257034,    -9.090909
  31626,   4.35272408,   76.9231415,    -9.090909
  31627,   4.49781466,   77.8205795,    -9.090909
  31628,   4.64290571,   78.7180176,    -9.090909
  31629,   2.67379522,   70.7374268, -0.909090936
  31630,   2.79004717,   71.6390533, -0.909090936
  31631,   2.90629911,   72.5406799, -0.909090936
  31632,   3.02255106,   73.4423065, -0.909090936
  31633,   3.13880301,   74.3439331, -0.909090936
  31634,   3.25505495,   75.2455673, -0.909090936
  31635,    3.3713069,   76.1471939, -0.909090936
  31636,   3.48755884,   77.0488205, -0.909090936
  31637,   3.60381103,   77.9504471, -0.909090936
  31638,   3.72006297,   78.8520737, -0.909090936
  31639,   2.67379522,   70.7374268,  -1.81818187
  31640,   2.79004717,   71.6390533,  -1.81818187
  31641,   2.90629911,   72.5406799,  -1.81818187
  31642,   3.02255106,   73.4423065,  -1.81818187
  31643,   3.13880301,   74.3439331,  -1.81818187
  31644,   3.25505495,   75.2455673,  -1.81818187
  31645,    3.3713069,   76.1471939,  -1.81818187
  31646,   3.48755884,   77.0488205,  -1.81818187
  31647,   3.60381103,   77.9504471,  -1.81818187
  31648,   3.72006297,   78.8520737,  -1.81818187
  31649,   2.67379522,   70.7374268,  -2.72727275
  31650,   2.79004717,   71.6390533,  -2.72727275
  31651,   2.90629911,   72.5406799,  -2.72727275
  31652,   3.02255106,   73.4423065,  -2.72727275
  31653,   3.13880301,   74.3439331,  -2.72727275
  31654,   3.25505495,   75.2455673,  -2.72727275
  31655,    3.3713069,   76.1471939,  -2.72727275
  31656,   3.48755884,   77.0488205,  -2.72727275
  31657,   3.60381103,   77.9504471,  -2.72727275
  31658,   3.72006297,   78.8520737,  -2.72727275
  31659,   2.67379522,   70.7374268,  -3.63636374
  31660,   2.79004717,   71.6390533,  -3.63636374
  31661,   2.90629911,   72.5406799,  -3.63636374
  31662,   3.02255106,   73.4423065,  -3.63636374
  31663,   3.13880301,   74.3439331,  -3.63636374
  31664,   3.25505495,   75.2455673,  -3.63636374
  31665,    3.3713069,   76.1471939,  -3.63636374
  31666,   3.48755884,   77.0488205,  -3.63636374
  31667,   3.60381103,   77.9504471,  -3.63636374
  31668,   3.72006297,   78.8520737,  -3.63636374
  31669,   2.67379522,   70.7374268,   -4.5454545
  31670,   2.79004717,   71.6390533,   -4.5454545
  31671,   2.90629911,   72.5406799,   -4.5454545
  31672,   3.02255106,   73.4423065,   -4.5454545
  31673,   3.13880301,   74.3439331,   -4.5454545
  31674,   3.25505495,   75.2455673,   -4.5454545
  31675,    3.3713069,   76.1471939,   -4.5454545
  31676,   3.48755884,   77.0488205,   -4.5454545
  31677,   3.60381103,   77.9504471,   -4.5454545
  31678,   3.72006297,   78.8520737,   -4.5454545
  31679,   2.67379522,   70.7374268,   -5.4545455
  31680,   2.79004717,   71.6390533,   -5.4545455
  31681,   2.90629911,   72.5406799,   -5.4545455
  31682,   3.02255106,   73.4423065,   -5.4545455
  31683,   3.13880301,   74.3439331,   -5.4545455
  31684,   3.25505495,   75.2455673,   -5.4545455
  31685,    3.3713069,   76.1471939,   -5.4545455
  31686,   3.48755884,   77.0488205,   -5.4545455
  31687,   3.60381103,   77.9504471,   -5.4545455
  31688,   3.72006297,   78.8520737,   -5.4545455
  31689,   2.67379522,   70.7374268,  -6.36363649
  31690,   2.79004717,   71.6390533,  -6.36363649
  31691,   2.90629911,   72.5406799,  -6.36363649
  31692,   3.02255106,   73.4423065,  -6.36363649
  31693,   3.13880301,   74.3439331,  -6.36363649
  31694,   3.25505495,   75.2455673,  -6.36363649
  31695,    3.3713069,   76.1471939,  -6.36363649
  31696,   3.48755884,   77.0488205,  -6.36363649
  31697,   3.60381103,   77.9504471,  -6.36363649
  31698,   3.72006297,   78.8520737,  -6.36363649
  31699,   2.67379522,   70.7374268,  -7.27272749
  31700,   2.79004717,   71.6390533,  -7.27272749
  31701,   2.90629911,   72.5406799,  -7.27272749
  31702,   3.02255106,   73.4423065,  -7.27272749
  31703,   3.13880301,   74.3439331,  -7.27272749
  31704,   3.25505495,   75.2455673,  -7.27272749
  31705,    3.3713069,   76.1471939,  -7.27272749
  31706,   3.48755884,   77.0488205,  -7.27272749
  31707,   3.60381103,   77.9504471,  -7.27272749
  31708,   3.72006297,   78.8520737,  -7.27272749
  31709,   2.67379522,   70.7374268,  -8.18181801
  31710,   2.79004717,   71.6390533,  -8.18181801
  31711,   2.90629911,   72.5406799,  -8.18181801
  31712,   3.02255106,   73.4423065,  -8.18181801
  31713,   3.13880301,   74.3439331,  -8.18181801
  31714,   3.25505495,   75.2455673,  -8.18181801
  31715,    3.3713069,   76.1471939,  -8.18181801
  31716,   3.48755884,   77.0488205,  -8.18181801
  31717,   3.60381103,   77.9504471,  -8.18181801
  31718,   3.72006297,   78.8520737,  -8.18181801
  31719,   2.67379522,   70.7374268,    -9.090909
  31720,   2.79004717,   71.6390533,    -9.090909
  31721,   2.90629911,   72.5406799,    -9.090909
  31722,   3.02255106,   73.4423065,    -9.090909
  31723,   3.13880301,   74.3439331,    -9.090909
  31724,   3.25505495,   75.2455673,    -9.090909
  31725,    3.3713069,   76.1471939,    -9.090909
  31726,   3.48755884,   77.0488205,    -9.090909
  31727,   3.60381103,   77.9504471,    -9.090909
  31728,   3.72006297,   78.8520737,    -9.090909
  31729,   2.00775385,   70.8124695, -0.909090936
  31730,   2.09504771,   71.7173615, -0.909090936
  31731,   2.18234134,   72.6222534, -0.909090936
  31732,   2.26963496,   73.5271454, -0.909090936
  31733,   2.35692859,   74.4320297, -0.909090936
  31734,   2.44422245,   75.3369217, -0.909090936
  31735,   2.53151608,   76.2418137, -0.909090936
  31736,    2.6188097,   77.1467056, -0.909090936
  31737,   2.70610356,     78.05159, -0.909090936
  31738,   2.79339719,   78.9564819, -0.909090936
  31739,   2.00775385,   70.8124695,  -1.81818187
  31740,   2.09504771,   71.7173615,  -1.81818187
  31741,   2.18234134,   72.6222534,  -1.81818187
  31742,   2.26963496,   73.5271454,  -1.81818187
  31743,   2.35692859,   74.4320297,  -1.81818187
  31744,   2.44422245,   75.3369217,  -1.81818187
  31745,   2.53151608,   76.2418137,  -1.81818187
  31746,    2.6188097,   77.1467056,  -1.81818187
  31747,   2.70610356,     78.05159,  -1.81818187
  31748,   2.79339719,   78.9564819,  -1.81818187
  31749,   2.00775385,   70.8124695,  -2.72727275
  31750,   2.09504771,   71.7173615,  -2.72727275
  31751,   2.18234134,   72.6222534,  -2.72727275
  31752,   2.26963496,   73.5271454,  -2.72727275
  31753,   2.35692859,   74.4320297,  -2.72727275
  31754,   2.44422245,   75.3369217,  -2.72727275
  31755,   2.53151608,   76.2418137,  -2.72727275
  31756,    2.6188097,   77.1467056,  -2.72727275
  31757,   2.70610356,     78.05159,  -2.72727275
  31758,   2.79339719,   78.9564819,  -2.72727275
  31759,   2.00775385,   70.8124695,  -3.63636374
  31760,   2.09504771,   71.7173615,  -3.63636374
  31761,   2.18234134,   72.6222534,  -3.63636374
  31762,   2.26963496,   73.5271454,  -3.63636374
  31763,   2.35692859,   74.4320297,  -3.63636374
  31764,   2.44422245,   75.3369217,  -3.63636374
  31765,   2.53151608,   76.2418137,  -3.63636374
  31766,    2.6188097,   77.1467056,  -3.63636374
  31767,   2.70610356,     78.05159,  -3.63636374
  31768,   2.79339719,   78.9564819,  -3.63636374
  31769,   2.00775385,   70.8124695,   -4.5454545
  31770,   2.09504771,   71.7173615,   -4.5454545
  31771,   2.18234134,   72.6222534,   -4.5454545
  31772,   2.26963496,   73.5271454,   -4.5454545
  31773,   2.35692859,   74.4320297,   -4.5454545
  31774,   2.44422245,   75.3369217,   -4.5454545
  31775,   2.53151608,   76.2418137,   -4.5454545
  31776,    2.6188097,   77.1467056,   -4.5454545
  31777,   2.70610356,     78.05159,   -4.5454545
  31778,   2.79339719,   78.9564819,   -4.5454545
  31779,   2.00775385,   70.8124695,   -5.4545455
  31780,   2.09504771,   71.7173615,   -5.4545455
  31781,   2.18234134,   72.6222534,   -5.4545455
  31782,   2.26963496,   73.5271454,   -5.4545455
  31783,   2.35692859,   74.4320297,   -5.4545455
  31784,   2.44422245,   75.3369217,   -5.4545455
  31785,   2.53151608,   76.2418137,   -5.4545455
  31786,    2.6188097,   77.1467056,   -5.4545455
  31787,   2.70610356,     78.05159,   -5.4545455
  31788,   2.79339719,   78.9564819,   -5.4545455
  31789,   2.00775385,   70.8124695,  -6.36363649
  31790,   2.09504771,   71.7173615,  -6.36363649
  31791,   2.18234134,   72.6222534,  -6.36363649
  31792,   2.26963496,   73.5271454,  -6.36363649
  31793,   2.35692859,   74.4320297,  -6.36363649
  31794,   2.44422245,   75.3369217,  -6.36363649
  31795,   2.53151608,   76.2418137,  -6.36363649
  31796,    2.6188097,   77.1467056,  -6.36363649
  31797,   2.70610356,     78.05159,  -6.36363649
  31798,   2.79339719,   78.9564819,  -6.36363649
  31799,   2.00775385,   70.8124695,  -7.27272749
  31800,   2.09504771,   71.7173615,  -7.27272749
  31801,   2.18234134,   72.6222534,  -7.27272749
  31802,   2.26963496,   73.5271454,  -7.27272749
  31803,   2.35692859,   74.4320297,  -7.27272749
  31804,   2.44422245,   75.3369217,  -7.27272749
  31805,   2.53151608,   76.2418137,  -7.27272749
  31806,    2.6188097,   77.1467056,  -7.27272749
  31807,   2.70610356,     78.05159,  -7.27272749
  31808,   2.79339719,   78.9564819,  -7.27272749
  31809,   2.00775385,   70.8124695,  -8.18181801
  31810,   2.09504771,   71.7173615,  -8.18181801
  31811,   2.18234134,   72.6222534,  -8.18181801
  31812,   2.26963496,   73.5271454,  -8.18181801
  31813,   2.35692859,   74.4320297,  -8.18181801
  31814,   2.44422245,   75.3369217,  -8.18181801
  31815,   2.53151608,   76.2418137,  -8.18181801
  31816,    2.6188097,   77.1467056,  -8.18181801
  31817,   2.70610356,     78.05159,  -8.18181801
  31818,   2.79339719,   78.9564819,  -8.18181801
  31819,   2.00775385,   70.8124695,    -9.090909
  31820,   2.09504771,   71.7173615,    -9.090909
  31821,   2.18234134,   72.6222534,    -9.090909
  31822,   2.26963496,   73.5271454,    -9.090909
  31823,   2.35692859,   74.4320297,    -9.090909
  31824,   2.44422245,   75.3369217,    -9.090909
  31825,   2.53151608,   76.2418137,    -9.090909
  31826,    2.6188097,   77.1467056,    -9.090909
  31827,   2.70610356,     78.05159,    -9.090909
  31828,   2.79339719,   78.9564819,    -9.090909
  31829,   1.33965003,   70.8661346, -0.909090936
  31830,   1.39789569,   71.7733536, -0.909090936
  31831,   1.45614135,   72.6805801, -0.909090936
  31832,   1.51438701,   73.5877991, -0.909090936
  31833,   1.57263267,   74.4950256, -0.909090936
  31834,   1.63087833,   75.4022446, -0.909090936
  31835,   1.68912399,   76.3094711, -0.909090936
  31836,   1.74736965,   77.2166901, -0.909090936
  31837,   1.80561531,   78.1239166, -0.909090936
  31838,   1.86386096,   79.0311356, -0.909090936
  31839,   1.33965003,   70.8661346,  -1.81818187
  31840,   1.39789569,   71.7733536,  -1.81818187
  31841,   1.45614135,   72.6805801,  -1.81818187
  31842,   1.51438701,   73.5877991,  -1.81818187
  31843,   1.57263267,   74.4950256,  -1.81818187
  31844,   1.63087833,   75.4022446,  -1.81818187
  31845,   1.68912399,   76.3094711,  -1.81818187
  31846,   1.74736965,   77.2166901,  -1.81818187
  31847,   1.80561531,   78.1239166,  -1.81818187
  31848,   1.86386096,   79.0311356,  -1.81818187
  31849,   1.33965003,   70.8661346,  -2.72727275
  31850,   1.39789569,   71.7733536,  -2.72727275
  31851,   1.45614135,   72.6805801,  -2.72727275
  31852,   1.51438701,   73.5877991,  -2.72727275
  31853,   1.57263267,   74.4950256,  -2.72727275
  31854,   1.63087833,   75.4022446,  -2.72727275
  31855,   1.68912399,   76.3094711,  -2.72727275
  31856,   1.74736965,   77.2166901,  -2.72727275
  31857,   1.80561531,   78.1239166,  -2.72727275
  31858,   1.86386096,   79.0311356,  -2.72727275
  31859,   1.33965003,   70.8661346,  -3.63636374
  31860,   1.39789569,   71.7733536,  -3.63636374
  31861,   1.45614135,   72.6805801,  -3.63636374
  31862,   1.51438701,   73.5877991,  -3.63636374
  31863,   1.57263267,   74.4950256,  -3.63636374
  31864,   1.63087833,   75.4022446,  -3.63636374
  31865,   1.68912399,   76.3094711,  -3.63636374
  31866,   1.74736965,   77.2166901,  -3.63636374
  31867,   1.80561531,   78.1239166,  -3.63636374
  31868,   1.86386096,   79.0311356,  -3.63636374
  31869,   1.33965003,   70.8661346,   -4.5454545
  31870,   1.39789569,   71.7733536,   -4.5454545
  31871,   1.45614135,   72.6805801,   -4.5454545
  31872,   1.51438701,   73.5877991,   -4.5454545
  31873,   1.57263267,   74.4950256,   -4.5454545
  31874,   1.63087833,   75.4022446,   -4.5454545
  31875,   1.68912399,   76.3094711,   -4.5454545
  31876,   1.74736965,   77.2166901,   -4.5454545
  31877,   1.80561531,   78.1239166,   -4.5454545
  31878,   1.86386096,   79.0311356,   -4.5454545
  31879,   1.33965003,   70.8661346,   -5.4545455
  31880,   1.39789569,   71.7733536,   -5.4545455
  31881,   1.45614135,   72.6805801,   -5.4545455
  31882,   1.51438701,   73.5877991,   -5.4545455
  31883,   1.57263267,   74.4950256,   -5.4545455
  31884,   1.63087833,   75.4022446,   -5.4545455
  31885,   1.68912399,   76.3094711,   -5.4545455
  31886,   1.74736965,   77.2166901,   -5.4545455
  31887,   1.80561531,   78.1239166,   -5.4545455
  31888,   1.86386096,   79.0311356,   -5.4545455
  31889,   1.33965003,   70.8661346,  -6.36363649
  31890,   1.39789569,   71.7733536,  -6.36363649
  31891,   1.45614135,   72.6805801,  -6.36363649
  31892,   1.51438701,   73.5877991,  -6.36363649
  31893,   1.57263267,   74.4950256,  -6.36363649
  31894,   1.63087833,   75.4022446,  -6.36363649
  31895,   1.68912399,   76.3094711,  -6.36363649
  31896,   1.74736965,   77.2166901,  -6.36363649
  31897,   1.80561531,   78.1239166,  -6.36363649
  31898,   1.86386096,   79.0311356,  -6.36363649
  31899,   1.33965003,   70.8661346,  -7.27272749
  31900,   1.39789569,   71.7733536,  -7.27272749
  31901,   1.45614135,   72.6805801,  -7.27272749
  31902,   1.51438701,   73.5877991,  -7.27272749
  31903,   1.57263267,   74.4950256,  -7.27272749
  31904,   1.63087833,   75.4022446,  -7.27272749
  31905,   1.68912399,   76.3094711,  -7.27272749
  31906,   1.74736965,   77.2166901,  -7.27272749
  31907,   1.80561531,   78.1239166,  -7.27272749
  31908,   1.86386096,   79.0311356,  -7.27272749
  31909,   1.33965003,   70.8661346,  -8.18181801
  31910,   1.39789569,   71.7733536,  -8.18181801
  31911,   1.45614135,   72.6805801,  -8.18181801
  31912,   1.51438701,   73.5877991,  -8.18181801
  31913,   1.57263267,   74.4950256,  -8.18181801
  31914,   1.63087833,   75.4022446,  -8.18181801
  31915,   1.68912399,   76.3094711,  -8.18181801
  31916,   1.74736965,   77.2166901,  -8.18181801
  31917,   1.80561531,   78.1239166,  -8.18181801
  31918,   1.86386096,   79.0311356,  -8.18181801
  31919,   1.33965003,   70.8661346,    -9.090909
  31920,   1.39789569,   71.7733536,    -9.090909
  31921,   1.45614135,   72.6805801,    -9.090909
  31922,   1.51438701,   73.5877991,    -9.090909
  31923,   1.57263267,   74.4950256,    -9.090909
  31924,   1.63087833,   75.4022446,    -9.090909
  31925,   1.68912399,   76.3094711,    -9.090909
  31926,   1.74736965,   77.2166901,    -9.090909
  31927,   1.80561531,   78.1239166,    -9.090909
  31928,   1.86386096,   79.0311356,    -9.090909
  31929,  0.670169413,   70.8983459, -0.909090936
  31930,  0.699307203,   71.8069687, -0.909090936
  31931,  0.728444934,   72.7155991, -0.909090936
  31932,  0.757582724,   73.6242218, -0.909090936
  31933,  0.786720514,   74.5328445, -0.909090936
  31934,  0.815858364,   75.4414673, -0.909090936
  31935,  0.844996154,     76.35009, -0.909090936
  31936,  0.874133945,   77.2587128, -0.909090936
  31937,  0.903271675,   78.1673355, -0.909090936
  31938,  0.932409465,   79.0759659, -0.909090936
  31939,  0.670169413,   70.8983459,  -1.81818187
  31940,  0.699307203,   71.8069687,  -1.81818187
  31941,  0.728444934,   72.7155991,  -1.81818187
  31942,  0.757582724,   73.6242218,  -1.81818187
  31943,  0.786720514,   74.5328445,  -1.81818187
  31944,  0.815858364,   75.4414673,  -1.81818187
  31945,  0.844996154,     76.35009,  -1.81818187
  31946,  0.874133945,   77.2587128,  -1.81818187
  31947,  0.903271675,   78.1673355,  -1.81818187
  31948,  0.932409465,   79.0759659,  -1.81818187
  31949,  0.670169413,   70.8983459,  -2.72727275
  31950,  0.699307203,   71.8069687,  -2.72727275
  31951,  0.728444934,   72.7155991,  -2.72727275
  31952,  0.757582724,   73.6242218,  -2.72727275
  31953,  0.786720514,   74.5328445,  -2.72727275
  31954,  0.815858364,   75.4414673,  -2.72727275
  31955,  0.844996154,     76.35009,  -2.72727275
  31956,  0.874133945,   77.2587128,  -2.72727275
  31957,  0.903271675,   78.1673355,  -2.72727275
  31958,  0.932409465,   79.0759659,  -2.72727275
  31959,  0.670169413,   70.8983459,  -3.63636374
  31960,  0.699307203,   71.8069687,  -3.63636374
  31961,  0.728444934,   72.7155991,  -3.63636374
  31962,  0.757582724,   73.6242218,  -3.63636374
  31963,  0.786720514,   74.5328445,  -3.63636374
  31964,  0.815858364,   75.4414673,  -3.63636374
  31965,  0.844996154,     76.35009,  -3.63636374
  31966,  0.874133945,   77.2587128,  -3.63636374
  31967,  0.903271675,   78.1673355,  -3.63636374
  31968,  0.932409465,   79.0759659,  -3.63636374
  31969,  0.670169413,   70.8983459,   -4.5454545
  31970,  0.699307203,   71.8069687,   -4.5454545
  31971,  0.728444934,   72.7155991,   -4.5454545
  31972,  0.757582724,   73.6242218,   -4.5454545
  31973,  0.786720514,   74.5328445,   -4.5454545
  31974,  0.815858364,   75.4414673,   -4.5454545
  31975,  0.844996154,     76.35009,   -4.5454545
  31976,  0.874133945,   77.2587128,   -4.5454545
  31977,  0.903271675,   78.1673355,   -4.5454545
  31978,  0.932409465,   79.0759659,   -4.5454545
  31979,  0.670169413,   70.8983459,   -5.4545455
  31980,  0.699307203,   71.8069687,   -5.4545455
  31981,  0.728444934,   72.7155991,   -5.4545455
  31982,  0.757582724,   73.6242218,   -5.4545455
  31983,  0.786720514,   74.5328445,   -5.4545455
  31984,  0.815858364,   75.4414673,   -5.4545455
  31985,  0.844996154,     76.35009,   -5.4545455
  31986,  0.874133945,   77.2587128,   -5.4545455
  31987,  0.903271675,   78.1673355,   -5.4545455
  31988,  0.932409465,   79.0759659,   -5.4545455
  31989,  0.670169413,   70.8983459,  -6.36363649
  31990,  0.699307203,   71.8069687,  -6.36363649
  31991,  0.728444934,   72.7155991,  -6.36363649
  31992,  0.757582724,   73.6242218,  -6.36363649
  31993,  0.786720514,   74.5328445,  -6.36363649
  31994,  0.815858364,   75.4414673,  -6.36363649
