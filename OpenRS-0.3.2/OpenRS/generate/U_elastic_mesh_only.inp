55093, 63632, 63633, 63643, 63642, 63562, 63563, 63573, 63572
55094, 63633, 63634, 63644, 63643, 63563, 63564, 63574, 63573
55095, 63634, 63635, 63645, 63644, 63564, 63565, 63575, 63574
55096, 63635, 63636, 63646, 63645, 63565, 63566, 63576, 63575
55097, 63636, 63637, 63647, 63646, 63566, 63567, 63577, 63576
55098, 63637, 63638, 63648, 63647, 63567, 63568, 63578, 63577
55099, 63638, 19809, 19810, 63648, 63568, 19802, 19803, 63578
55100, 19740, 63639, 63649, 19741, 19733, 63569, 63579, 19734
55101, 63639, 63640, 63650, 63649, 63569, 63570, 63580, 63579
55102, 63640, 63641, 63651, 63650, 63570, 63571, 63581, 63580
55103, 63641, 63642, 63652, 63651, 63571, 63572, 63582, 63581
55104, 63642, 63643, 63653, 63652, 63572, 63573, 63583, 63582
55105, 63643, 63644, 63654, 63653, 63573, 63574, 63584, 63583
55106, 63644, 63645, 63655, 63654, 63574, 63575, 63585, 63584
55107, 63645, 63646, 63656, 63655, 63575, 63576, 63586, 63585
55108, 63646, 63647, 63657, 63656, 63576, 63577, 63587, 63586
55109, 63647, 63648, 63658, 63657, 63577, 63578, 63588, 63587
55110, 63648, 19810, 19811, 63658, 63578, 19803, 19804, 63588
55111, 19741, 63649, 63659, 19742, 19734, 63579, 63589, 19735
55112, 63649, 63650, 63660, 63659, 63579, 63580, 63590, 63589
55113, 63650, 63651, 63661, 63660, 63580, 63581, 63591, 63590
55114, 63651, 63652, 63662, 63661, 63581, 63582, 63592, 63591
55115, 63652, 63653, 63663, 63662, 63582, 63583, 63593, 63592
55116, 63653, 63654, 63664, 63663, 63583, 63584, 63594, 63593
55117, 63654, 63655, 63665, 63664, 63584, 63585, 63595, 63594
55118, 63655, 63656, 63666, 63665, 63585, 63586, 63596, 63595
55119, 63656, 63657, 63667, 63666, 63586, 63587, 63597, 63596
55120, 63657, 63658, 63668, 63667, 63587, 63588, 63598, 63597
55121, 63658, 19811, 19812, 63668, 63588, 19804, 19805, 63598
55122, 19742, 63659, 63669, 19743, 19735, 63589, 63599, 19736
55123, 63659, 63660, 63670, 63669, 63589, 63590, 63600, 63599
55124, 63660, 63661, 63671, 63670, 63590, 63591, 63601, 63600
55125, 63661, 63662, 63672, 63671, 63591, 63592, 63602, 63601
55126, 63662, 63663, 63673, 63672, 63592, 63593, 63603, 63602
55127, 63663, 63664, 63674, 63673, 63593, 63594, 63604, 63603
55128, 63664, 63665, 63675, 63674, 63594, 63595, 63605, 63604
55129, 63665, 63666, 63676, 63675, 63595, 63596, 63606, 63605
55130, 63666, 63667, 63677, 63676, 63596, 63597, 63607, 63606
55131, 63667, 63668, 63678, 63677, 63597, 63598, 63608, 63607
55132, 63668, 19812, 19813, 63678, 63598, 19805, 19806, 63608
55133, 19743, 63669, 63679, 19744, 19736, 63599, 63609, 19737
55134, 63669, 63670, 63680, 63679, 63599, 63600, 63610, 63609
55135, 63670, 63671, 63681, 63680, 63600, 63601, 63611, 63610
55136, 63671, 63672, 63682, 63681, 63601, 63602, 63612, 63611
55137, 63672, 63673, 63683, 63682, 63602, 63603, 63613, 63612
55138, 63673, 63674, 63684, 63683, 63603, 63604, 63614, 63613
55139, 63674, 63675, 63685, 63684, 63604, 63605, 63615, 63614
55140, 63675, 63676, 63686, 63685, 63605, 63606, 63616, 63615
55141, 63676, 63677, 63687, 63686, 63606, 63607, 63617, 63616
55142, 63677, 63678, 63688, 63687, 63607, 63608, 63618, 63617
55143, 63678, 19813, 19814, 63688, 63608, 19806, 19807, 63618
55144, 19744, 63679, 19469,  2191, 19737, 63609, 19479,  2192
55145, 63679, 63680, 19470, 19469, 63609, 63610, 19480, 19479
55146, 63680, 63681, 19471, 19470, 63610, 63611, 19481, 19480
55147, 63681, 63682, 19472, 19471, 63611, 63612, 19482, 19481
55148, 63682, 63683, 19473, 19472, 63612, 63613, 19483, 19482
55149, 63683, 63684, 19474, 19473, 63613, 63614, 19484, 19483
55150, 63684, 63685, 19475, 19474, 63614, 63615, 19485, 19484
55151, 63685, 63686, 19476, 19475, 63615, 63616, 19486, 19485
55152, 63686, 63687, 19477, 19476, 63616, 63617, 19487, 19486
55153, 63687, 63688, 19478, 19477, 63617, 63618, 19488, 19487
55154, 63688, 19814,  2216, 19478, 63618, 19807,  2215, 19488
55155,  1789, 16729, 63689, 19745,  1788, 16719, 63619, 19738
55156, 16729, 16730, 63690, 63689, 16719, 16720, 63620, 63619
55157, 16730, 16731, 63691, 63690, 16720, 16721, 63621, 63620
55158, 16731, 16732, 63692, 63691, 16721, 16722, 63622, 63621
55159, 16732, 16733, 63693, 63692, 16722, 16723, 63623, 63622
55160, 16733, 16734, 63694, 63693, 16723, 16724, 63624, 63623
55161, 16734, 16735, 63695, 63694, 16724, 16725, 63625, 63624
55162, 16735, 16736, 63696, 63695, 16725, 16726, 63626, 63625
55163, 16736, 16737, 63697, 63696, 16726, 16727, 63627, 63626
55164, 16737, 16738, 63698, 63697, 16727, 16728, 63628, 63627
55165, 16738,  1792, 19815, 63698, 16728,  1793, 19808, 63628
55166, 19745, 63689, 63699, 19746, 19738, 63619, 63629, 19739
55167, 63689, 63690, 63700, 63699, 63619, 63620, 63630, 63629
55168, 63690, 63691, 63701, 63700, 63620, 63621, 63631, 63630
55169, 63691, 63692, 63702, 63701, 63621, 63622, 63632, 63631
55170, 63692, 63693, 63703, 63702, 63622, 63623, 63633, 63632
55171, 63693, 63694, 63704, 63703, 63623, 63624, 63634, 63633
55172, 63694, 63695, 63705, 63704, 63624, 63625, 63635, 63634
55173, 63695, 63696, 63706, 63705, 63625, 63626, 63636, 63635
55174, 63696, 63697, 63707, 63706, 63626, 63627, 63637, 63636
55175, 63697, 63698, 63708, 63707, 63627, 63628, 63638, 63637
55176, 63698, 19815, 19816, 63708, 63628, 19808, 19809, 63638
55177, 19746, 63699, 63709, 19747, 19739, 63629, 63639, 19740
55178, 63699, 63700, 63710, 63709, 63629, 63630, 63640, 63639
55179, 63700, 63701, 63711, 63710, 63630, 63631, 63641, 63640
55180, 63701, 63702, 63712, 63711, 63631, 63632, 63642, 63641
55181, 63702, 63703, 63713, 63712, 63632, 63633, 63643, 63642
55182, 63703, 63704, 63714, 63713, 63633, 63634, 63644, 63643
55183, 63704, 63705, 63715, 63714, 63634, 63635, 63645, 63644
55184, 63705, 63706, 63716, 63715, 63635, 63636, 63646, 63645
55185, 63706, 63707, 63717, 63716, 63636, 63637, 63647, 63646
55186, 63707, 63708, 63718, 63717, 63637, 63638, 63648, 63647
55187, 63708, 19816, 19817, 63718, 63638, 19809, 19810, 63648
55188, 19747, 63709, 63719, 19748, 19740, 63639, 63649, 19741
55189, 63709, 63710, 63720, 63719, 63639, 63640, 63650, 63649
55190, 63710, 63711, 63721, 63720, 63640, 63641, 63651, 63650
55191, 63711, 63712, 63722, 63721, 63641, 63642, 63652, 63651
55192, 63712, 63713, 63723, 63722, 63642, 63643, 63653, 63652
55193, 63713, 63714, 63724, 63723, 63643, 63644, 63654, 63653
55194, 63714, 63715, 63725, 63724, 63644, 63645, 63655, 63654
55195, 63715, 63716, 63726, 63725, 63645, 63646, 63656, 63655
55196, 63716, 63717, 63727, 63726, 63646, 63647, 63657, 63656
55197, 63717, 63718, 63728, 63727, 63647, 63648, 63658, 63657
55198, 63718, 19817, 19818, 63728, 63648, 19810, 19811, 63658
55199, 19748, 63719, 63729, 19749, 19741, 63649, 63659, 19742
55200, 63719, 63720, 63730, 63729, 63649, 63650, 63660, 63659
55201, 63720, 63721, 63731, 63730, 63650, 63651, 63661, 63660
55202, 63721, 63722, 63732, 63731, 63651, 63652, 63662, 63661
55203, 63722, 63723, 63733, 63732, 63652, 63653, 63663, 63662
55204, 63723, 63724, 63734, 63733, 63653, 63654, 63664, 63663
55205, 63724, 63725, 63735, 63734, 63654, 63655, 63665, 63664
55206, 63725, 63726, 63736, 63735, 63655, 63656, 63666, 63665
55207, 63726, 63727, 63737, 63736, 63656, 63657, 63667, 63666
55208, 63727, 63728, 63738, 63737, 63657, 63658, 63668, 63667
55209, 63728, 19818, 19819, 63738, 63658, 19811, 19812, 63668
55210, 19749, 63729, 63739, 19750, 19742, 63659, 63669, 19743
55211, 63729, 63730, 63740, 63739, 63659, 63660, 63670, 63669
55212, 63730, 63731, 63741, 63740, 63660, 63661, 63671, 63670
55213, 63731, 63732, 63742, 63741, 63661, 63662, 63672, 63671
55214, 63732, 63733, 63743, 63742, 63662, 63663, 63673, 63672
55215, 63733, 63734, 63744, 63743, 63663, 63664, 63674, 63673
55216, 63734, 63735, 63745, 63744, 63664, 63665, 63675, 63674
55217, 63735, 63736, 63746, 63745, 63665, 63666, 63676, 63675
55218, 63736, 63737, 63747, 63746, 63666, 63667, 63677, 63676
55219, 63737, 63738, 63748, 63747, 63667, 63668, 63678, 63677
55220, 63738, 19819, 19820, 63748, 63668, 19812, 19813, 63678
55221, 19750, 63739, 63749, 19751, 19743, 63669, 63679, 19744
55222, 63739, 63740, 63750, 63749, 63669, 63670, 63680, 63679
55223, 63740, 63741, 63751, 63750, 63670, 63671, 63681, 63680
55224, 63741, 63742, 63752, 63751, 63671, 63672, 63682, 63681
55225, 63742, 63743, 63753, 63752, 63672, 63673, 63683, 63682
55226, 63743, 63744, 63754, 63753, 63673, 63674, 63684, 63683
55227, 63744, 63745, 63755, 63754, 63674, 63675, 63685, 63684
55228, 63745, 63746, 63756, 63755, 63675, 63676, 63686, 63685
55229, 63746, 63747, 63757, 63756, 63676, 63677, 63687, 63686
55230, 63747, 63748, 63758, 63757, 63677, 63678, 63688, 63687
55231, 63748, 19820, 19821, 63758, 63678, 19813, 19814, 63688
55232, 19751, 63749, 19459,  2190, 19744, 63679, 19469,  2191
55233, 63749, 63750, 19460, 19459, 63679, 63680, 19470, 19469
55234, 63750, 63751, 19461, 19460, 63680, 63681, 19471, 19470
55235, 63751, 63752, 19462, 19461, 63681, 63682, 19472, 19471
55236, 63752, 63753, 19463, 19462, 63682, 63683, 19473, 19472
55237, 63753, 63754, 19464, 19463, 63683, 63684, 19474, 19473
55238, 63754, 63755, 19465, 19464, 63684, 63685, 19475, 19474
55239, 63755, 63756, 19466, 19465, 63685, 63686, 19476, 19475
55240, 63756, 63757, 19467, 19466, 63686, 63687, 19477, 19476
55241, 63757, 63758, 19468, 19467, 63687, 63688, 19478, 19477
55242, 63758, 19821,  2217, 19468, 63688, 19814,  2216, 19478
55243,  1790, 16739, 63759, 19752,  1789, 16729, 63689, 19745
55244, 16739, 16740, 63760, 63759, 16729, 16730, 63690, 63689
55245, 16740, 16741, 63761, 63760, 16730, 16731, 63691, 63690
55246, 16741, 16742, 63762, 63761, 16731, 16732, 63692, 63691
55247, 16742, 16743, 63763, 63762, 16732, 16733, 63693, 63692
55248, 16743, 16744, 63764, 63763, 16733, 16734, 63694, 63693
55249, 16744, 16745, 63765, 63764, 16734, 16735, 63695, 63694
55250, 16745, 16746, 63766, 63765, 16735, 16736, 63696, 63695
55251, 16746, 16747, 63767, 63766, 16736, 16737, 63697, 63696
55252, 16747, 16748, 63768, 63767, 16737, 16738, 63698, 63697
55253, 16748,  1791, 19822, 63768, 16738,  1792, 19815, 63698
55254, 19752, 63759, 63769, 19753, 19745, 63689, 63699, 19746
55255, 63759, 63760, 63770, 63769, 63689, 63690, 63700, 63699
55256, 63760, 63761, 63771, 63770, 63690, 63691, 63701, 63700
55257, 63761, 63762, 63772, 63771, 63691, 63692, 63702, 63701
55258, 63762, 63763, 63773, 63772, 63692, 63693, 63703, 63702
55259, 63763, 63764, 63774, 63773, 63693, 63694, 63704, 63703
55260, 63764, 63765, 63775, 63774, 63694, 63695, 63705, 63704
55261, 63765, 63766, 63776, 63775, 63695, 63696, 63706, 63705
55262, 63766, 63767, 63777, 63776, 63696, 63697, 63707, 63706
55263, 63767, 63768, 63778, 63777, 63697, 63698, 63708, 63707
55264, 63768, 19822, 19823, 63778, 63698, 19815, 19816, 63708
55265, 19753, 63769, 63779, 19754, 19746, 63699, 63709, 19747
55266, 63769, 63770, 63780, 63779, 63699, 63700, 63710, 63709
55267, 63770, 63771, 63781, 63780, 63700, 63701, 63711, 63710
55268, 63771, 63772, 63782, 63781, 63701, 63702, 63712, 63711
55269, 63772, 63773, 63783, 63782, 63702, 63703, 63713, 63712
55270, 63773, 63774, 63784, 63783, 63703, 63704, 63714, 63713
55271, 63774, 63775, 63785, 63784, 63704, 63705, 63715, 63714
55272, 63775, 63776, 63786, 63785, 63705, 63706, 63716, 63715
55273, 63776, 63777, 63787, 63786, 63706, 63707, 63717, 63716
55274, 63777, 63778, 63788, 63787, 63707, 63708, 63718, 63717
55275, 63778, 19823, 19824, 63788, 63708, 19816, 19817, 63718
55276, 19754, 63779, 63789, 19755, 19747, 63709, 63719, 19748
55277, 63779, 63780, 63790, 63789, 63709, 63710, 63720, 63719
55278, 63780, 63781, 63791, 63790, 63710, 63711, 63721, 63720
55279, 63781, 63782, 63792, 63791, 63711, 63712, 63722, 63721
55280, 63782, 63783, 63793, 63792, 63712, 63713, 63723, 63722
55281, 63783, 63784, 63794, 63793, 63713, 63714, 63724, 63723
55282, 63784, 63785, 63795, 63794, 63714, 63715, 63725, 63724
55283, 63785, 63786, 63796, 63795, 63715, 63716, 63726, 63725
55284, 63786, 63787, 63797, 63796, 63716, 63717, 63727, 63726
55285, 63787, 63788, 63798, 63797, 63717, 63718, 63728, 63727
55286, 63788, 19824, 19825, 63798, 63718, 19817, 19818, 63728
55287, 19755, 63789, 63799, 19756, 19748, 63719, 63729, 19749
55288, 63789, 63790, 63800, 63799, 63719, 63720, 63730, 63729
55289, 63790, 63791, 63801, 63800, 63720, 63721, 63731, 63730
55290, 63791, 63792, 63802, 63801, 63721, 63722, 63732, 63731
55291, 63792, 63793, 63803, 63802, 63722, 63723, 63733, 63732
55292, 63793, 63794, 63804, 63803, 63723, 63724, 63734, 63733
55293, 63794, 63795, 63805, 63804, 63724, 63725, 63735, 63734
55294, 63795, 63796, 63806, 63805, 63725, 63726, 63736, 63735
55295, 63796, 63797, 63807, 63806, 63726, 63727, 63737, 63736
55296, 63797, 63798, 63808, 63807, 63727, 63728, 63738, 63737
55297, 63798, 19825, 19826, 63808, 63728, 19818, 19819, 63738
55298, 19756, 63799, 63809, 19757, 19749, 63729, 63739, 19750
55299, 63799, 63800, 63810, 63809, 63729, 63730, 63740, 63739
55300, 63800, 63801, 63811, 63810, 63730, 63731, 63741, 63740
55301, 63801, 63802, 63812, 63811, 63731, 63732, 63742, 63741
55302, 63802, 63803, 63813, 63812, 63732, 63733, 63743, 63742
55303, 63803, 63804, 63814, 63813, 63733, 63734, 63744, 63743
55304, 63804, 63805, 63815, 63814, 63734, 63735, 63745, 63744
55305, 63805, 63806, 63816, 63815, 63735, 63736, 63746, 63745
55306, 63806, 63807, 63817, 63816, 63736, 63737, 63747, 63746
55307, 63807, 63808, 63818, 63817, 63737, 63738, 63748, 63747
55308, 63808, 19826, 19827, 63818, 63738, 19819, 19820, 63748
55309, 19757, 63809, 63819, 19758, 19750, 63739, 63749, 19751
55310, 63809, 63810, 63820, 63819, 63739, 63740, 63750, 63749
55311, 63810, 63811, 63821, 63820, 63740, 63741, 63751, 63750
55312, 63811, 63812, 63822, 63821, 63741, 63742, 63752, 63751
55313, 63812, 63813, 63823, 63822, 63742, 63743, 63753, 63752
55314, 63813, 63814, 63824, 63823, 63743, 63744, 63754, 63753
55315, 63814, 63815, 63825, 63824, 63744, 63745, 63755, 63754
55316, 63815, 63816, 63826, 63825, 63745, 63746, 63756, 63755
55317, 63816, 63817, 63827, 63826, 63746, 63747, 63757, 63756
55318, 63817, 63818, 63828, 63827, 63747, 63748, 63758, 63757
55319, 63818, 19827, 19828, 63828, 63748, 19820, 19821, 63758
55320, 19758, 63819, 19449,  2189, 19751, 63749, 19459,  2190
55321, 63819, 63820, 19450, 19449, 63749, 63750, 19460, 19459
55322, 63820, 63821, 19451, 19450, 63750, 63751, 19461, 19460
55323, 63821, 63822, 19452, 19451, 63751, 63752, 19462, 19461
55324, 63822, 63823, 19453, 19452, 63752, 63753, 19463, 19462
55325, 63823, 63824, 19454, 19453, 63753, 63754, 19464, 19463
55326, 63824, 63825, 19455, 19454, 63754, 63755, 19465, 19464
55327, 63825, 63826, 19456, 19455, 63755, 63756, 19466, 19465
55328, 63826, 63827, 19457, 19456, 63756, 63757, 19467, 19466
55329, 63827, 63828, 19458, 19457, 63757, 63758, 19468, 19467
55330, 63828, 19828,  2218, 19458, 63758, 19821,  2217, 19468
55331,    58,  1764, 19619,  2250,  1790, 16739, 63759, 19752
55332,  1764,  1765, 19620, 19619, 16739, 16740, 63760, 63759
55333,  1765,  1766, 19621, 19620, 16740, 16741, 63761, 63760
55334,  1766,  1767, 19622, 19621, 16741, 16742, 63762, 63761
55335,  1767,  1768, 19623, 19622, 16742, 16743, 63763, 63762
55336,  1768,  1769, 19624, 19623, 16743, 16744, 63764, 63763
55337,  1769,  1770, 19625, 19624, 16744, 16745, 63765, 63764
55338,  1770,  1771, 19626, 19625, 16745, 16746, 63766, 63765
55339,  1771,  1772, 19627, 19626, 16746, 16747, 63767, 63766
55340,  1772,  1773, 19628, 19627, 16747, 16748, 63768, 63767
55341,  1773,    57,  2249, 19628, 16748,  1791, 19822, 63768
55342,  2250, 19619, 19629,  2251, 19752, 63759, 63769, 19753
55343, 19619, 19620, 19630, 19629, 63759, 63760, 63770, 63769
55344, 19620, 19621, 19631, 19630, 63760, 63761, 63771, 63770
55345, 19621, 19622, 19632, 19631, 63761, 63762, 63772, 63771
55346, 19622, 19623, 19633, 19632, 63762, 63763, 63773, 63772
55347, 19623, 19624, 19634, 19633, 63763, 63764, 63774, 63773
55348, 19624, 19625, 19635, 19634, 63764, 63765, 63775, 63774
55349, 19625, 19626, 19636, 19635, 63765, 63766, 63776, 63775
55350, 19626, 19627, 19637, 19636, 63766, 63767, 63777, 63776
55351, 19627, 19628, 19638, 19637, 63767, 63768, 63778, 63777
55352, 19628,  2249,  2248, 19638, 63768, 19822, 19823, 63778
55353,  2251, 19629, 19639,  2252, 19753, 63769, 63779, 19754
55354, 19629, 19630, 19640, 19639, 63769, 63770, 63780, 63779
55355, 19630, 19631, 19641, 19640, 63770, 63771, 63781, 63780
55356, 19631, 19632, 19642, 19641, 63771, 63772, 63782, 63781
55357, 19632, 19633, 19643, 19642, 63772, 63773, 63783, 63782
55358, 19633, 19634, 19644, 19643, 63773, 63774, 63784, 63783
55359, 19634, 19635, 19645, 19644, 63774, 63775, 63785, 63784
55360, 19635, 19636, 19646, 19645, 63775, 63776, 63786, 63785
55361, 19636, 19637, 19647, 19646, 63776, 63777, 63787, 63786
55362, 19637, 19638, 19648, 19647, 63777, 63778, 63788, 63787
55363, 19638,  2248,  2247, 19648, 63778, 19823, 19824, 63788
55364,  2252, 19639, 19649,  2253, 19754, 63779, 63789, 19755
55365, 19639, 19640, 19650, 19649, 63779, 63780, 63790, 63789
55366, 19640, 19641, 19651, 19650, 63780, 63781, 63791, 63790
55367, 19641, 19642, 19652, 19651, 63781, 63782, 63792, 63791
55368, 19642, 19643, 19653, 19652, 63782, 63783, 63793, 63792
55369, 19643, 19644, 19654, 19653, 63783, 63784, 63794, 63793
55370, 19644, 19645, 19655, 19654, 63784, 63785, 63795, 63794
55371, 19645, 19646, 19656, 19655, 63785, 63786, 63796, 63795
55372, 19646, 19647, 19657, 19656, 63786, 63787, 63797, 63796
55373, 19647, 19648, 19658, 19657, 63787, 63788, 63798, 63797
55374, 19648,  2247,  2246, 19658, 63788, 19824, 19825, 63798
55375,  2253, 19649, 19659,  2254, 19755, 63789, 63799, 19756
55376, 19649, 19650, 19660, 19659, 63789, 63790, 63800, 63799
55377, 19650, 19651, 19661, 19660, 63790, 63791, 63801, 63800
55378, 19651, 19652, 19662, 19661, 63791, 63792, 63802, 63801
55379, 19652, 19653, 19663, 19662, 63792, 63793, 63803, 63802
55380, 19653, 19654, 19664, 19663, 63793, 63794, 63804, 63803
55381, 19654, 19655, 19665, 19664, 63794, 63795, 63805, 63804
55382, 19655, 19656, 19666, 19665, 63795, 63796, 63806, 63805
55383, 19656, 19657, 19667, 19666, 63796, 63797, 63807, 63806
55384, 19657, 19658, 19668, 19667, 63797, 63798, 63808, 63807
55385, 19658,  2246,  2245, 19668, 63798, 19825, 19826, 63808
55386,  2254, 19659, 19669,  2255, 19756, 63799, 63809, 19757
55387, 19659, 19660, 19670, 19669, 63799, 63800, 63810, 63809
55388, 19660, 19661, 19671, 19670, 63800, 63801, 63811, 63810
55389, 19661, 19662, 19672, 19671, 63801, 63802, 63812, 63811
55390, 19662, 19663, 19673, 19672, 63802, 63803, 63813, 63812
55391, 19663, 19664, 19674, 19673, 63803, 63804, 63814, 63813
55392, 19664, 19665, 19675, 19674, 63804, 63805, 63815, 63814
55393, 19665, 19666, 19676, 19675, 63805, 63806, 63816, 63815
55394, 19666, 19667, 19677, 19676, 63806, 63807, 63817, 63816
55395, 19667, 19668, 19678, 19677, 63807, 63808, 63818, 63817
55396, 19668,  2245,  2244, 19678, 63808, 19826, 19827, 63818
55397,  2255, 19669, 19679,  2256, 19757, 63809, 63819, 19758
55398, 19669, 19670, 19680, 19679, 63809, 63810, 63820, 63819
55399, 19670, 19671, 19681, 19680, 63810, 63811, 63821, 63820
55400, 19671, 19672, 19682, 19681, 63811, 63812, 63822, 63821
55401, 19672, 19673, 19683, 19682, 63812, 63813, 63823, 63822
55402, 19673, 19674, 19684, 19683, 63813, 63814, 63824, 63823
55403, 19674, 19675, 19685, 19684, 63814, 63815, 63825, 63824
55404, 19675, 19676, 19686, 19685, 63815, 63816, 63826, 63825
55405, 19676, 19677, 19687, 19686, 63816, 63817, 63827, 63826
55406, 19677, 19678, 19688, 19687, 63817, 63818, 63828, 63827
55407, 19678,  2244,  2243, 19688, 63818, 19827, 19828, 63828
55408,  2256, 19679,  1868,    61, 19758, 63819, 19449,  2189
55409, 19679, 19680,  1867,  1868, 63819, 63820, 19450, 19449
55410, 19680, 19681,  1866,  1867, 63820, 63821, 19451, 19450
55411, 19681, 19682,  1865,  1866, 63821, 63822, 19452, 19451
55412, 19682, 19683,  1864,  1865, 63822, 63823, 19453, 19452
55413, 19683, 19684,  1863,  1864, 63823, 63824, 19454, 19453
55414, 19684, 19685,  1862,  1863, 63824, 63825, 19455, 19454
55415, 19685, 19686,  1861,  1862, 63825, 63826, 19456, 19455
55416, 19686, 19687,  1860,  1861, 63826, 63827, 19457, 19456
55417, 19687, 19688,  1859,  1860, 63827, 63828, 19458, 19457
55418, 19688,  2243,    60,  1859, 63828, 19828,  2218, 19458
*System
*Nset, nset=all, generate
     1,  63828,      1
*Elset, elset=all, generate
     1,  55418,      1
*Nset, nset=left
   44,   45,   56,   58, 1543, 1544, 1545, 1546, 1547, 1548, 1549, 1550, 1551, 1552, 1781, 1782
 1783, 1784, 1785, 1786, 1787, 1788, 1789, 1790
*Elset, elset=left
 42966, 42977, 42988, 42999, 43010, 43021, 43032, 43043, 43054, 43065, 43076, 45816, 45904, 45992, 46080, 46168
 46256, 46344, 46432, 46520, 46608, 46696, 47664, 47665, 47666, 47667, 47668, 47669, 47670, 47671, 47672, 47673
 47674, 54451, 54539, 54627, 54715, 54803, 54891, 54979, 55067, 55155, 55243, 55331
*Nset, nset=left_lower_datum
  25,  27, 575, 576, 577
*Elset, elset=left_lower_datum
  5442,  5443,  5444,  5445,  5563,  5564,  5565,  5566, 38424, 38425, 38426, 38427, 38435, 38436, 38437, 38438
*Nset, nset=left_upper_datum
  26,  28, 608, 609, 610
*Elset, elset=left_upper_datum
  8467,  8468,  8469,  8470,  8588,  8589,  8590,  8591, 38699, 38700, 38701, 38702, 38710, 38711, 38712, 38713
*Nset, nset=midplane_xy
    9,   10,   21,   22,   29,   30,  196,  197,  198,  199,  200,  201,  202,  203,  204,  205
  405,  406,  407,  408,  409,  410,  411,  412,  413,  414,  708,  709,  710,  711,  712,  713
  714,  715,  716,  717,  718,  719,  720,  721,  722,  723,  724,  725,  726,  727,  728,  729
  730,  731,  732,  733,  734,  735,  736,  737,  738,  739,  740,  741,  742,  743,  744,  745
  746,  747,  748,  749,  750,  751,  752,  753,  754,  755,  756,  757,  758,  759,  760,  761
  762,  763,  764,  765,  766,  767,  768,  769,  770,  771,  772,  773,  774,  775,  776,  777
  778,  779,  780,  781,  782,  783,  784,  785,  786,  787,  788,  789,  790,  791,  792,  793
  794,  795,  796,  797,  798,  799,  800,  801,  802,  803,  901,  902,  903,  904,  905,  906
  907,  908,  909,  910,  911,  912,  913,  914,  915,  916,  917,  918,  919,  920,  921,  922
  923,  924,  925,  926,  927,  928,  929,  930,  931,  932,  933,  934,  935,  936,  937,  938
  939,  940,  941,  942,  943,  944,  945,  946,  947,  948,  949,  950,  951,  952,  953,  954
  955,  956,  957,  958,  959,  960,  961,  962,  963,  964,  965,  966,  967,  968,  969,  970
  971,  972,  973,  974,  975,  976,  977,  978,  979,  980,  981,  982,  983,  984,  985,  986
  987,  988,  989,  990,  991,  992,  993,  994,  995,  996,  997,  998,  999, 1000, 1001, 1002
 1003, 1004, 1005, 1006, 7469, 7470, 7471, 7472, 7473, 7474, 7475, 7476, 7477, 7478, 7479, 7480
 7481, 7482, 7483, 7484, 7485, 7486, 7487, 7488, 7489, 7490, 7491, 7492, 7493, 7494, 7495, 7496
 7497, 7498, 7499, 7500, 7501, 7502, 7503, 7504, 7505, 7506, 7507, 7508, 7509, 7510, 7511, 7512
 7513, 7514, 7515, 7516, 7517, 7518, 7519, 7520, 7521, 7522, 7523, 7524, 7525, 7526, 7527, 7528
 7529, 7530, 7531, 7532, 7533, 7534, 7535, 7536, 7537, 7538, 7539, 7540, 7541, 7542, 7543, 7544
 7545, 7546, 7547, 7548, 7549, 7550, 7551, 7552, 7553, 7554, 7555, 7556, 7557, 7558, 7559, 7560
 7561, 7562, 7563, 7564, 7565, 7566, 7567, 7568, 7569, 7570, 7571, 7572, 7573, 7574, 7575, 7576
 7577, 7578, 7579, 7580, 7581, 7582, 7583, 7584, 7585, 7586, 7587, 7588, 7589, 7590, 7591, 7592
 7593, 7594, 7595, 7596, 7597, 7598, 7599, 7600, 7601, 7602, 7603, 7604, 7605, 7606, 7607, 7608
 7609, 7610, 7611, 7612, 7613, 7614, 7615, 7616, 7617, 7618, 7619, 7620, 7621, 7622, 7623, 7624
 7625, 7626, 7627, 7628, 7629, 7630, 7631, 7632, 7633, 7634, 7635, 7636, 7637, 7638, 7639, 7640
 7641, 7642, 7643, 7644, 7645, 7646, 7647, 7648, 7649, 7650, 7651, 7652, 7653, 7654, 7655, 7656
 7657, 7658, 7659, 7660, 7661, 7662, 7663, 7664, 7665, 7666, 7667, 7668, 7669, 7670, 7671, 7672
 7673, 7674, 7675, 7676, 7677, 7678, 7679, 7680, 7681, 7682, 7683, 7684, 7685, 7686, 7687, 7688
 7689, 7690, 7691, 7692, 7693, 7694, 7695, 7696, 7697, 7698, 7699, 7700, 7701, 7702, 7703, 7704
 7705, 7706, 7707, 7708, 7709, 7710, 7711, 7712, 7713, 7714, 7715, 7716, 7717, 7718, 7719, 7720
 7721, 7722, 7723, 7724, 7725, 7726, 7727, 7728, 7729, 7730, 7731, 7732, 7733, 7734, 7735, 7736
 7737, 7738, 7739, 7740, 7741, 7742, 7743, 7744, 7745, 7746, 7747, 7748, 7749, 7750, 7751, 7752
 7753, 7754, 7755, 7756, 7757, 7758, 7759, 7760, 7761, 7762, 7763, 7764, 7765, 7766, 7767, 7768
 7769, 7770, 7771, 7772, 7773, 7774, 7775, 7776, 7777, 7778, 7779, 7780, 7781, 7782, 7783, 7784
 7785, 7786, 7787, 7788, 7789, 7790, 7791, 7792, 7793, 7794, 7795, 7796, 7797, 7798, 7799, 7800
 7801, 7802, 7803, 7804, 7805, 7806, 7807, 7808, 7809, 7810, 7811, 7812, 7813, 7814, 7815, 7816
 7817, 7818, 7819, 7820, 7821, 7822, 7823, 7824, 7825, 7826, 7827, 7828, 7829, 7830, 7831, 7832
 7833, 7834, 7835, 7836, 7837, 7838, 7839, 7840, 7841, 7842, 7843, 7844, 7845, 7846, 7847, 7848
 7849, 7850, 7851, 7852, 7853, 7854, 7855, 7856, 7857, 7858, 7859, 7860, 7861, 7862, 7863, 7864
 7865, 7866, 7867, 7868, 7869, 7870, 7871, 7872, 7873, 7874, 7875, 7876, 7877, 7878, 7879, 7880
 7881, 7882, 7883, 7884, 7885, 7886, 7887, 7888, 7889, 7890, 7891, 7892, 7893, 7894, 7895, 7896
 7897, 7898, 7899, 7900, 7901, 7902, 7903, 7904, 7905, 7906, 7907, 7908, 7909, 7910, 7911, 7912
 7913, 7914, 7915, 7916, 7917, 7918, 7919, 7920, 7921, 7922, 7923, 7924, 7925, 7926, 7927, 7928
 7929, 7930, 7931, 7932, 7933, 7934, 7935, 7936, 7937, 7938, 7939, 7940, 7941, 7942, 7943, 7944
 7945, 7946, 7947, 7948, 7949, 7950, 7951, 7952, 7953, 7954, 7955, 7956, 7957, 7958, 7959, 7960
 7961, 7962, 7963, 7964, 7965, 7966, 7967, 7968, 7969, 7970, 7971, 7972, 7973, 7974, 7975, 7976
 7977, 7978, 7979, 7980, 7981, 7982, 7983, 7984, 7985, 7986, 7987, 7988, 7989, 7990, 7991, 7992
 7993, 7994, 7995, 7996, 7997, 7998, 7999, 8000, 8001, 8002, 8003, 8004, 8005, 8006, 8007, 8008
 8009, 8010, 8011, 8012, 8013, 8014, 8015, 8016, 8017, 8018, 8019, 8020, 8021, 8022, 8023, 8024
 8025, 8026, 8027, 8028, 8029, 8030, 8031, 8032, 8033, 8034, 8035, 8036, 8037, 8038, 8039, 8040
 8041, 8042, 8043, 8044, 8045, 8046, 8047, 8048, 8049, 8050, 8051, 8052, 8053, 8054, 8055, 8056
 8057, 8058, 8059, 8060, 8061, 8062, 8063, 8064, 8065, 8066, 8067, 8068, 8069, 8070, 8071, 8072
 8073, 8074, 8075, 8076, 8077, 8078, 8079, 8080, 8081, 8082, 8083, 8084, 8085, 8086, 8087, 8088
 8089, 8090, 8091, 8092, 8093, 8094, 8095, 8096, 8097, 8098, 8099, 8100, 8101, 8102, 8103, 8104
 8105, 8106, 8107, 8108, 8109, 8110, 8111, 8112, 8113, 8114, 8115, 8116, 8117, 8118, 8119, 8120
 8121, 8122, 8123, 8124, 8125, 8126, 8127, 8128, 8129, 8130, 8131, 8132, 8133, 8134, 8135, 8136
 8137, 8138, 8139, 8140, 8141, 8142, 8143, 8144, 8145, 8146, 8147, 8148, 8149, 8150, 8151, 8152
 8153, 8154, 8155, 8156, 8157, 8158, 8159, 8160, 8161, 8162, 8163, 8164, 8165, 8166, 8167, 8168
 8169, 8170, 8171, 8172, 8173, 8174, 8175, 8176, 8177, 8178, 8179, 8180, 8181, 8182, 8183, 8184
 8185, 8186, 8187, 8188, 8189, 8190, 8191, 8192, 8193, 8194, 8195, 8196, 8197, 8198, 8199, 8200
 8201, 8202, 8203, 8204, 8205, 8206, 8207, 8208, 8209, 8210, 8211, 8212, 8213, 8214, 8215, 8216
 8217, 8218, 8219, 8220, 8221, 8222, 8223, 8224, 8225, 8226, 8227, 8228, 8229, 8230, 8231, 8232
 8233, 8234, 8235, 8236, 8237, 8238, 8239, 8240, 8241, 8242, 8243, 8244, 8245, 8246, 8247, 8248
 8249, 8250, 8251, 8252, 8253, 8254, 8255, 8256, 8257, 8258, 8259, 8260, 8261, 8262, 8263, 8264
 8265, 8266, 8267, 8268, 8269, 8270, 8271, 8272, 8273, 8274, 8275, 8276, 8277, 8278, 8279, 8280
 8281, 8282, 8283, 8284, 8285, 8286, 8287, 8288, 8289, 8290, 8291, 8292, 8293, 8294, 8295, 8296
 8297, 8298, 8299, 8300, 8301, 8302, 8303, 8304, 8305, 8306, 8307, 8308, 8309, 8310, 8311, 8312
 8313, 8314, 8315, 8316, 8317, 8318, 8319, 8320, 8321, 8322, 8323, 8324, 8325, 8326, 8327, 8328
 8329, 8330, 8331, 8332, 8333, 8334, 8335, 8336, 8337, 8338, 8339, 8340, 8341, 8342, 8343, 8344
 8345, 8346, 8347, 8348, 8349, 8350, 8351, 8352, 8353, 8354, 8355, 8356, 8357, 8358, 8359, 8360
 8361, 8362, 8363, 8364, 8365, 8366, 8367, 8368, 8369, 8370, 8371, 8372, 8373, 8374, 8375, 8376
 8377, 8378, 8379, 8380, 8381, 8382, 8383, 8384, 8385, 8386, 8387, 8388, 8389, 8390, 8391, 8392
 8393, 8394, 8395, 8396, 8397, 8398, 8399, 8400, 8401, 8402, 8403, 8404, 8405, 8406, 8407, 8408
 8409, 8410, 8411, 8412, 8413, 8414, 8415, 8416, 8417, 8418, 8419, 8420, 8421, 8422, 8423, 8424
 8425, 8426, 8427, 8428
*Elset, elset=midplane_xy
  9197,  9198,  9199,  9200,  9201,  9202,  9203,  9204,  9205,  9206,  9207,  9318,  9319,  9320,  9321,  9322
  9323,  9324,  9325,  9326,  9327,  9328,  9439,  9440,  9441,  9442,  9443,  9444,  9445,  9446,  9447,  9448
  9449,  9560,  9561,  9562,  9563,  9564,  9565,  9566,  9567,  9568,  9569,  9570,  9681,  9682,  9683,  9684
  9685,  9686,  9687,  9688,  9689,  9690,  9691,  9802,  9803,  9804,  9805,  9806,  9807,  9808,  9809,  9810
  9811,  9812,  9923,  9924,  9925,  9926,  9927,  9928,  9929,  9930,  9931,  9932,  9933, 10044, 10045, 10046
 10047, 10048, 10049, 10050, 10051, 10052, 10053, 10054, 10165, 10166, 10167, 10168, 10169, 10170, 10171, 10172
 10173, 10174, 10175, 10286, 10287, 10288, 10289, 10290, 10291, 10292, 10293, 10294, 10295, 10296, 10407, 10408
 10409, 10410, 10411, 10412, 10413, 10414, 10415, 10416, 10417, 10528, 10529, 10530, 10531, 10532, 10533, 10534
 10535, 10536, 10537, 10538, 10649, 10650, 10651, 10652, 10653, 10654, 10655, 10656, 10657, 10658, 10659, 10770
 10771, 10772, 10773, 10774, 10775, 10776, 10777, 10778, 10779, 10780, 10891, 10892, 10893, 10894, 10895, 10896
 10897, 10898, 10899, 10900, 10901, 11012, 11013, 11014, 11015, 11016, 11017, 11018, 11019, 11020, 11021, 11022
 11133, 11134, 11135, 11136, 11137, 11138, 11139, 11140, 11141, 11142, 11143, 11254, 11255, 11256, 11257, 11258
 11259, 11260, 11261, 11262, 11263, 11264, 11375, 11376, 11377, 11378, 11379, 11380, 11381, 11382, 11383, 11384
 11385, 11496, 11497, 11498, 11499, 11500, 11501, 11502, 11503, 11504, 11505, 11506, 11617, 11618, 11619, 11620
 11621, 11622, 11623, 11624, 11625, 11626, 11627, 11738, 11739, 11740, 11741, 11742, 11743, 11744, 11745, 11746
 11747, 11748, 11859, 11860, 11861, 11862, 11863, 11864, 11865, 11866, 11867, 11868, 11869, 11980, 11981, 11982
 11983, 11984, 11985, 11986, 11987, 11988, 11989, 11990, 12101, 12102, 12103, 12104, 12105, 12106, 12107, 12108
 12109, 12110, 12111, 12222, 12223, 12224, 12225, 12226, 12227, 12228, 12229, 12230, 12231, 12232, 12343, 12344
 12345, 12346, 12347, 12348, 12349, 12350, 12351, 12352, 12353, 12464, 12465, 12466, 12467, 12468, 12469, 12470
 12471, 12472, 12473, 12474, 12585, 12586, 12587, 12588, 12589, 12590, 12591, 12592, 12593, 12594, 12595, 12706
 12707, 12708, 12709, 12710, 12711, 12712, 12713, 12714, 12715, 12716, 12827, 12828, 12829, 12830, 12831, 12832
 12833, 12834, 12835, 12836, 12837, 12948, 12949, 12950, 12951, 12952, 12953, 12954, 12955, 12956, 12957, 12958
 13069, 13070, 13071, 13072, 13073, 13074, 13075, 13076, 13077, 13078, 13079, 13190, 13191, 13192, 13193, 13194
 13195, 13196, 13197, 13198, 13199, 13200, 13311, 13312, 13313, 13314, 13315, 13316, 13317, 13318, 13319, 13320
 13321, 13432, 13433, 13434, 13435, 13436, 13437, 13438, 13439, 13440, 13441, 13442, 13553, 13554, 13555, 13556
 13557, 13558, 13559, 13560, 13561, 13562, 13563, 13674, 13675, 13676, 13677, 13678, 13679, 13680, 13681, 13682
 13683, 13684, 13795, 13796, 13797, 13798, 13799, 13800, 13801, 13802, 13803, 13804, 13805, 13916, 13917, 13918
 13919, 13920, 13921, 13922, 13923, 13924, 13925, 13926, 14037, 14038, 14039, 14040, 14041, 14042, 14043, 14044
 14045, 14046, 14047, 14158, 14159, 14160, 14161, 14162, 14163, 14164, 14165, 14166, 14167, 14168, 14279, 14280
 14281, 14282, 14283, 14284, 14285, 14286, 14287, 14288, 14289, 14400, 14401, 14402, 14403, 14404, 14405, 14406
 14407, 14408, 14409, 14410, 14521, 14522, 14523, 14524, 14525, 14526, 14527, 14528, 14529, 14530, 14531, 14642
 14643, 14644, 14645, 14646, 14647, 14648, 14649, 14650, 14651, 14652, 14763, 14764, 14765, 14766, 14767, 14768
 14769, 14770, 14771, 14772, 14773, 14884, 14885, 14886, 14887, 14888, 14889, 14890, 14891, 14892, 14893, 14894
 15005, 15006, 15007, 15008, 15009, 15010, 15011, 15012, 15013, 15014, 15015, 15126, 15127, 15128, 15129, 15130
 15131, 15132, 15133, 15134, 15135, 15136, 15247, 15248, 15249, 15250, 15251, 15252, 15253, 15254, 15255, 15256
 15257, 15368, 15369, 15370, 15371, 15372, 15373, 15374, 15375, 15376, 15377, 15378, 15489, 15490, 15491, 15492
 15493, 15494, 15495, 15496, 15497, 15498, 15499, 15610, 15611, 15612, 15613, 15614, 15615, 15616, 15617, 15618
 15619, 15620, 15731, 15732, 15733, 15734, 15735, 15736, 15737, 15738, 15739, 15740, 15741, 15852, 15853, 15854
 15855, 15856, 15857, 15858, 15859, 15860, 15861, 15862, 15973, 15974, 15975, 15976, 15977, 15978, 15979, 15980
 15981, 15982, 15983, 16094, 16095, 16096, 16097, 16098, 16099, 16100, 16101, 16102, 16103, 16104, 16215, 16216
 16217, 16218, 16219, 16220, 16221, 16222, 16223, 16224, 16225, 16336, 16337, 16338, 16339, 16340, 16341, 16342
 16343, 16344, 16345, 16346, 16457, 16458, 16459, 16460, 16461, 16462, 16463, 16464, 16465, 16466, 16467, 16578
 16579, 16580, 16581, 16582, 16583, 16584, 16585, 16586, 16587, 16588, 16699, 16700, 16701, 16702, 16703, 16704
 16705, 16706, 16707, 16708, 16709, 16820, 16821, 16822, 16823, 16824, 16825, 16826, 16827, 16828, 16829, 16830
 16941, 16942, 16943, 16944, 16945, 16946, 16947, 16948, 16949, 16950, 16951, 17062, 17063, 17064, 17065, 17066
 17067, 17068, 17069, 17070, 17071, 17072, 17183, 17184, 17185, 17186, 17187, 17188, 17189, 17190, 17191, 17192
 17193, 17304, 17305, 17306, 17307, 17308, 17309, 17310, 17311, 17312, 17313, 17314, 17425, 17426, 17427, 17428
 17429, 17430, 17431, 17432, 17433, 17434, 17435, 17546, 17547, 17548, 17549, 17550, 17551, 17552, 17553, 17554
 17555, 17556, 17667, 17668, 17669, 17670, 17671, 17672, 17673, 17674, 17675, 17676, 17677, 17788, 17789, 17790
 17791, 17792, 17793, 17794, 17795, 17796, 17797, 17798, 17909, 17910, 17911, 17912, 17913, 17914, 17915, 17916
 17917, 17918, 17919, 18030, 18031, 18032, 18033, 18034, 18035, 18036, 18037, 18038, 18039, 18040, 18151, 18152
 18153, 18154, 18155, 18156, 18157, 18158, 18159, 18160, 18161, 18272, 18273, 18274, 18275, 18276, 18277, 18278
 18279, 18280, 18281, 18282, 18393, 18394, 18395, 18396, 18397, 18398, 18399, 18400, 18401, 18402, 18403, 18514
 18515, 18516, 18517, 18518, 18519, 18520, 18521, 18522, 18523, 18524, 18635, 18636, 18637, 18638, 18639, 18640
 18641, 18642, 18643, 18644, 18645, 18756, 18757, 18758, 18759, 18760, 18761, 18762, 18763, 18764, 18765, 18766
 18877, 18878, 18879, 18880, 18881, 18882, 18883, 18884, 18885, 18886, 18887, 18998, 18999, 19000, 19001, 19002
 19003, 19004, 19005, 19006, 19007, 19008, 19119, 19120, 19121, 19122, 19123, 19124, 19125, 19126, 19127, 19128
 19129, 19240, 19241, 19242, 19243, 19244, 19245, 19246, 19247, 19248, 19249, 19250, 19361, 19362, 19363, 19364
 19365, 19366, 19367, 19368, 19369, 19370, 19371, 19482, 19483, 19484, 19485, 19486, 19487, 19488, 19489, 19490
 19491, 19492, 19603, 19604, 19605, 19606, 19607, 19608, 19609, 19610, 19611, 19612, 19613, 19724, 19725, 19726
 19727, 19728, 19729, 19730, 19731, 19732, 19733, 19734, 19845, 19846, 19847, 19848, 19849, 19850, 19851, 19852
 19853, 19854, 19855, 19966, 19967, 19968, 19969, 19970, 19971, 19972, 19973, 19974, 19975, 19976, 20087, 20088
 20089, 20090, 20091, 20092, 20093, 20094, 20095, 20096, 20097, 20208, 20209, 20210, 20211, 20212, 20213, 20214
 20215, 20216, 20217, 20218, 20329, 20330, 20331, 20332, 20333, 20334, 20335, 20336, 20337, 20338, 20339, 20450
 20451, 20452, 20453, 20454, 20455, 20456, 20457, 20458, 20459, 20460, 20571, 20572, 20573, 20574, 20575, 20576
 20577, 20578, 20579, 20580, 20581, 20692, 20693, 20694, 20695, 20696, 20697, 20698, 20699, 20700, 20701, 20702
 20813, 20814, 20815, 20816, 20817, 20818, 20819, 20820, 20821, 20822, 20823, 20934, 20935, 20936, 20937, 20938
 20939, 20940, 20941, 20942, 20943, 20944, 21055, 21056, 21057, 21058, 21059, 21060, 21061, 21062, 21063, 21064
 21065, 21066, 21067, 21068, 21069, 21070, 21071, 21072, 21073, 21074, 21075, 21076, 21077, 21078, 21079, 21080
 21081, 21082, 21083, 21084, 21085, 21086, 21087, 21088, 21089, 21090, 21091, 21092, 21093, 21094, 21095, 21096
 21097, 21098, 21099, 21100, 21101, 21102, 21103, 21104, 21105, 21106, 21107, 21108, 21109, 21110, 21111, 21112
 21113, 21114, 21115, 21116, 21117, 21118, 21119, 21120, 21121, 21122, 21123, 21124, 21125, 21126, 21127, 21128
 21129, 21130, 21131, 21132, 21133, 21134, 21135, 21136, 21137, 21138, 21139, 21140, 21141, 21142, 21143, 21144
 21145, 21146, 21147, 21148, 21149, 21150, 21151, 21152, 22133, 22134, 22135, 22136, 22137, 22138, 22139, 22140
 22141, 22142, 22143, 22144, 22145, 22146, 22147, 22148, 22149, 22150, 22151, 22152, 22153, 22154, 22155, 22156
 22157, 22158, 22159, 22160, 22161, 22162, 22163, 22164, 22165, 22166, 22167, 22168, 22169, 22170, 22171, 22172
 22173, 22174, 22175, 22176, 22177, 22178, 22179, 22180, 22181, 22182, 22183, 22184, 22185, 22186, 22187, 22188
 22189, 22190, 22191, 22192, 22193, 22194, 22195, 22196, 22197, 22198, 22199, 22200, 22201, 22202, 22203, 22204
 22205, 22206, 22207, 22208, 22209, 22210, 22211, 22212, 22213, 22214, 22215, 22216, 22217, 22218, 22219, 22220
 22221, 22222, 22223, 22224, 22225, 22226, 22227, 22228, 22229, 22230, 23211, 23212, 23213, 23214, 23215, 23216
 23217, 23218, 23219, 23220, 23221, 23222, 23223, 23224, 23225, 23226, 23227, 23228, 23229, 23230, 23231, 23232
 23233, 23234, 23235, 23236, 23237, 23238, 23239, 23240, 23241, 23242, 23243, 23244, 23245, 23246, 23247, 23248
 23249, 23250, 23251, 23252, 23253, 23254, 23255, 23256, 23257, 23258, 23259, 23260, 23261, 23262, 23263, 23264
 23265, 23266, 23267, 23268, 23269, 23270, 23271, 23272, 23273, 23274, 23275, 23276, 23277, 23278, 23279, 23280
 23281, 23282, 23283, 23284, 23285, 23286, 23287, 23288, 23289, 23290, 23291, 23292, 23293, 23294, 23295, 23296
 23297, 23298, 23299, 23300, 23301, 23302, 23303, 23304, 23305, 23306, 23307, 23308, 24289, 24290, 24291, 24292
 24293, 24294, 24295, 24296, 24297, 24298, 24299, 24300, 24301, 24302, 24303, 24304, 24305, 24306, 24307, 24308
 24309, 24310, 24311, 24312, 24313, 24314, 24315, 24316, 24317, 24318, 24319, 24320, 24321, 24322, 24323, 24324
 24325, 24326, 24327, 24328, 24329, 24330, 24331, 24332, 24333, 24334, 24335, 24336, 24337, 24338, 24339, 24340
 24341, 24342, 24343, 24344, 24345, 24346, 24347, 24348, 24349, 24350, 24351, 24352, 24353, 24354, 24355, 24356
 24357, 24358, 24359, 24360, 24361, 24362, 24363, 24364, 24365, 24366, 24367, 24368, 24369, 24370, 24371, 24372
 24373, 24374, 24375, 24376, 24377, 24378, 24379, 24380, 24381, 24382, 24383, 24384, 24385, 24386, 25367, 25368
 25369, 25370, 25371, 25372, 25373, 25374, 25375, 25376, 25377, 25378, 25379, 25380, 25381, 25382, 25383, 25384
 25385, 25386, 25387, 25388, 25389, 25390, 25391, 25392, 25393, 25394, 25395, 25396, 25397, 25398, 25399, 25400
 25401, 25402, 25403, 25404, 25405, 25406, 25407, 25408, 25409, 25410, 25411, 25412, 25413, 25414, 25415, 25416
 25417, 25418, 25419, 25420, 25421, 25422, 25423, 25424, 25425, 25426, 25427, 25428, 25429, 25430, 25431, 25432
 25433, 25434, 25435, 25436, 25437, 25438, 25439, 25440, 25441, 25442, 25443, 25444, 25445, 25446, 25447, 25448
 25449, 25450, 25451, 25452, 25453, 25454, 25455, 25456, 25457, 25458, 25459, 25460, 25461, 25462, 25463, 25464
 26445, 26446, 26447, 26448, 26449, 26450, 26451, 26452, 26453, 26454, 26455, 26456, 26457, 26458, 26459, 26460
 26461, 26462, 26463, 26464, 26465, 26466, 26467, 26468, 26469, 26470, 26471, 26472, 26473, 26474, 26475, 26476
 26477, 26478, 26479, 26480, 26481, 26482, 26483, 26484, 26485, 26486, 26487, 26488, 26489, 26490, 26491, 26492
 26493, 26494, 26495, 26496, 26497, 26498, 26499, 26500, 26501, 26502, 26503, 26504, 26505, 26506, 26507, 26508
 26509, 26510, 26511, 26512, 26513, 26514, 26515, 26516, 26517, 26518, 26519, 26520, 26521, 26522, 26523, 26524
 26525, 26526, 26527, 26528, 26529, 26530, 26531, 26532, 26533, 26534, 26535, 26536, 26537, 26538, 26539, 26540
 26541, 26542, 27523, 27524, 27525, 27526, 27527, 27528, 27529, 27530, 27531, 27532, 27533, 27534, 27535, 27536
 27537, 27538, 27539, 27540, 27541, 27542, 27543, 27544, 27545, 27546, 27547, 27548, 27549, 27550, 27551, 27552
 27553, 27554, 27555, 27556, 27557, 27558, 27559, 27560, 27561, 27562, 27563, 27564, 27565, 27566, 27567, 27568
 27569, 27570, 27571, 27572, 27573, 27574, 27575, 27576, 27577, 27578, 27579, 27580, 27581, 27582, 27583, 27584
 27585, 27586, 27587, 27588, 27589, 27590, 27591, 27592, 27593, 27594, 27595, 27596, 27597, 27598, 27599, 27600
 27601, 27602, 27603, 27604, 27605, 27606, 27607, 27608, 27609, 27610, 27611, 27612, 27613, 27614, 27615, 27616
 27617, 27618, 27619, 27620, 28601, 28602, 28603, 28604, 28605, 28606, 28607, 28608, 28609, 28610, 28611, 28612
 28613, 28614, 28615, 28616, 28617, 28618, 28619, 28620, 28621, 28622, 28623, 28624, 28625, 28626, 28627, 28628
 28629, 28630, 28631, 28632, 28633, 28634, 28635, 28636, 28637, 28638, 28639, 28640, 28641, 28642, 28643, 28644
 28645, 28646, 28647, 28648, 28649, 28650, 28651, 28652, 28653, 28654, 28655, 28656, 28657, 28658, 28659, 28660
 28661, 28662, 28663, 28664, 28665, 28666, 28667, 28668, 28669, 28670, 28671, 28672, 28673, 28674, 28675, 28676
 28677, 28678, 28679, 28680, 28681, 28682, 28683, 28684, 28685, 28686, 28687, 28688, 28689, 28690, 28691, 28692
 28693, 28694, 28695, 28696, 28697, 28698, 29679, 29680, 29681, 29682, 29683, 29684, 29685, 29686, 29687, 29688
 29689, 29690, 29691, 29692, 29693, 29694, 29695, 29696, 29697, 29698, 29699, 29700, 29701, 29702, 29703, 29704
 29705, 29706, 29707, 29708, 29709, 29710, 29711, 29712, 29713, 29714, 29715, 29716, 29717, 29718, 29719, 29720
 29721, 29722, 29723, 29724, 29725, 29726, 29727, 29728, 29729, 29730, 29731, 29732, 29733, 29734, 29735, 29736
 29737, 29738, 29739, 29740, 29741, 29742, 29743, 29744, 29745, 29746, 29747, 29748, 29749, 29750, 29751, 29752
 29753, 29754, 29755, 29756, 29757, 29758, 29759, 29760, 29761, 29762, 29763, 29764, 29765, 29766, 29767, 29768
 29769, 29770, 29771, 29772, 29773, 29774, 29775, 29776, 30757, 30758, 30759, 30760, 30761, 30762, 30763, 30764
 30765, 30766, 30767, 30768, 30769, 30770, 30771, 30772, 30773, 30774, 30775, 30776, 30777, 30778, 30779, 30780
 30781, 30782, 30783, 30784, 30785, 30786, 30787, 30788, 30789, 30790, 30791, 30792, 30793, 30794, 30795, 30796
 30797, 30798, 30799, 30800, 30801, 30802, 30803, 30804, 30805, 30806, 30807, 30808, 30809, 30810, 30811, 30812
 30813, 30814, 30815, 30816, 30817, 30818, 30819, 30820, 30821, 30822, 30823, 30824, 30825, 30826, 30827, 30828
 30829, 30830, 30831, 30832, 30833, 30834, 30835, 30836, 30837, 30838, 30839, 30840, 30841, 30842, 30843, 30844
 30845, 30846, 30847, 30848, 30849, 30850, 30851, 30852, 30853, 30854, 31835, 31836, 31837, 31838, 31839, 31840
 31841, 31842, 31843, 31844, 31845, 31846, 31847, 31848, 31849, 31850, 31851, 31852, 31853, 31854, 31855, 31856
 31857, 31858, 31859, 31860, 31861, 31862, 31863, 31864, 31865, 31866, 31867, 31868, 31869, 31870, 31871, 31872
 31873, 31874, 31875, 31876, 31877, 31878, 31879, 31880, 31881, 31882, 31883, 31884, 31885, 31886, 31887, 31888
 31889, 31890, 31891, 31892, 31893, 31894, 31895, 31896, 31897, 31898, 31899, 31900, 31901, 31902, 31903, 31904
 31905, 31906, 31907, 31908, 31909, 31910, 31911, 31912, 31913, 31914, 31915, 31916, 31917, 31918, 31919, 31920
 31921, 31922, 31923, 31924, 31925, 31926, 31927, 31928, 31929, 31930, 31931, 31932
*Nset, nset=right
   38,   39,   47,   48, 1375, 1376, 1377, 1378, 1379, 1380, 1381, 1382, 1383, 1384, 1608, 1609
 1610, 1611, 1612, 1613, 1614, 1615, 1616, 1617
*Elset, elset=right
 37521, 37532, 37543, 37554, 37565, 37576, 37587, 37598, 37609, 37620, 37631, 44001, 44002, 44003, 44004, 44005
 44006, 44007, 44008, 44009, 44010, 44011, 44968, 45045, 45122, 45199, 45276, 45353, 45430, 45507, 45584, 45661
 45738, 51459, 51460, 51461, 51462, 51463, 51464, 51465, 51466, 51467, 51468, 51469
*Nset, nset=right_lower_datum
   3,   4, 100, 101, 102, 103
*Elset, elset=right_lower_datum
    73,    74,    75,    76,    77,    84,    85,    86,    87,    88, 37423, 37424, 37425, 37426, 37427, 37434
 37435, 37436, 37437, 37438
*Nset, nset=right_upper_datum
   6,   8, 187, 188, 189, 190
*Elset, elset=right_upper_datum
   348,   349,   350,   351,   352,   359,   360,   361,   362,   363, 37148, 37149, 37150, 37151, 37152, 37159
 37160, 37161, 37162, 37163
*Nset, nset=xy_outer
   9,  21,  30, 901, 902, 903, 904, 905, 906, 907, 908, 909, 910, 911, 912, 913
 914, 915, 916, 917, 918, 919, 920, 921, 922, 923, 924, 925, 926, 927, 928, 929
 930, 931, 932, 933, 934, 935, 936, 937, 938, 939, 940, 941, 942, 943, 944, 945
 946, 947, 948, 949, 950, 951, 952, 953, 954, 955, 956, 957, 958, 959, 960, 961
 962, 963, 964, 965, 966, 967, 968, 969, 970, 971, 972, 973, 974, 975, 976, 977
 978, 979, 980, 981, 982, 983, 984, 985, 986, 987, 988, 989, 990, 991, 992, 993
 994, 995, 996
*Elset, elset=xy_outer
  9207,  9328,  9449,  9570,  9691,  9812,  9933, 10054, 10175, 10296, 10417, 10538, 10659, 10780, 10901, 11022
 11143, 11264, 11385, 11506, 11627, 11748, 11869, 11990, 12111, 12232, 12353, 12474, 12595, 12716, 12837, 12958
 13079, 13200, 13321, 13442, 13563, 13684, 13805, 13926, 14047, 14168, 14289, 14410, 14531, 14652, 14773, 14894
 15015, 15136, 15257, 15378, 15499, 15620, 15741, 15862, 15983, 16104, 16225, 16346, 16467, 16588, 16709, 16830
 16951, 17072, 17193, 17314, 17435, 17556, 17677, 17798, 17919, 18040, 18161, 18282, 18403, 18524, 18645, 18766
 18887, 19008, 19129, 19250, 19371, 19492, 19613, 19734, 19855, 19976, 20097, 20218, 20339, 20460, 20581, 20702
 20823, 20944, 21055, 21056, 21057, 21058, 21059, 21060, 21061, 21062, 21063, 21064, 21065, 21066, 21067, 21068
 21069, 21070, 21071, 21072, 21073, 21074, 21075, 21076, 21077, 21078, 21079, 21080, 21081, 21082, 21083, 21084
 21085, 21086, 21087, 21088, 21089, 21090, 21091, 21092, 21093, 21094, 21095, 21096, 21097, 21098, 21099, 21100
 21101, 21102, 21103, 21104, 21105, 21106, 21107, 21108, 21109, 21110, 21111, 21112, 21113, 21114, 21115, 21116
 21117, 21118, 21119, 21120, 21121, 21122, 21123, 21124, 21125, 21126, 21127, 21128, 21129, 21130, 21131, 21132
 21133, 21134, 21135, 21136, 21137, 21138, 21139, 21140, 21141, 21142, 21143, 21144, 21145, 21146, 21147, 21148
 21149, 21150, 21151, 21152
*Elset, elset=_left_inner_S2, generate
 46707,  46794,      1
*Elset, elset=_left_inner_S6, generate
 42956,  43913,     11
*Surface, type=ELEMENT, name=left_inner
_left_inner_S2, S2
_left_inner_S6, S6
*Elset, elset=_left_outer_S1, generate
 47587,  47674,      1
*Elset, elset=_left_outer_S4, generate
 42966,  43923,     11
*Surface, type=ELEMENT, name=left_outer
_left_outer_S1, S1
_left_outer_S4, S4
*Elset, elset=_right_inner_S2, generate
 50579,  50666,      1
*Elset, elset=_right_inner_S6, generate
 37511,  38347,     11
*Surface, type=ELEMENT, name=right_inner
_right_inner_S2, S2
_right_inner_S6, S6
*Elset, elset=_right_outer_S1, generate
 51459,  51546,      1
*Elset, elset=_right_outer_S4, generate
 37521,  38357,     11
*Surface, type=ELEMENT, name=right_outer
_right_outer_S1, S1
_right_outer_S4, S4
