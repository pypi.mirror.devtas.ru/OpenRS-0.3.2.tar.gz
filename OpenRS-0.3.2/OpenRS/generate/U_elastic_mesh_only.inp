8331, 26511, 26512, 26522, 26521, 26611, 26612, 26622, 26621
8332, 26512, 26513, 26523, 26522, 26612, 26613, 26623, 26622
8333, 26513, 26514, 26524, 26523, 26613, 26614, 26624, 26623
8334, 26514, 26515, 26525, 26524, 26614, 26615, 26625, 26624
8335, 26515, 26516, 26526, 26525, 26615, 26616, 26626, 26625
8336, 26516, 26517, 26527, 26526, 26616, 26617, 26627, 26626
8337, 26517, 26518, 26528, 26527, 26617, 26618, 26628, 26627
8338, 26518,  4761,  4762, 26528, 26618,  4771,  4772, 26628
8339,  4392, 26519,  5384,   432,  4402, 26619,  5383,   431
8340, 26519, 26520,  5360,  5384, 26619, 26620,  5359,  5383
8341, 26520, 26521,  5336,  5360, 26620, 26621,  5335,  5359
8342, 26521, 26522,  5312,  5336, 26621, 26622,  5311,  5335
8343, 26522, 26523,  5288,  5312, 26622, 26623,  5287,  5311
8344, 26523, 26524,  5264,  5288, 26623, 26624,  5263,  5287
8345, 26524, 26525,   579,  5264, 26624, 26625,   578,  5263
8346, 26525, 26526,  5429,   579, 26625, 26626,  5430,   578
8347, 26526, 26527,  5453,  5429, 26626, 26627,  5454,  5430
8348, 26527, 26528,  5477,  5453, 26627, 26628,  5478,  5454
8349, 26528,  4762,   525,  5477, 26628,  4772,   526,  5478
8350,   490,  5133, 26529,  4393,   491,  5143, 26629,  4403
8351,  5133,  5134, 26530, 26529,  5143,  5144, 26630, 26629
8352,  5134,  5135, 26531, 26530,  5144,  5145, 26631, 26630
8353,  5135,  5136, 26532, 26531,  5145,  5146, 26632, 26631
8354,  5136,  5137, 26533, 26532,  5146,  5147, 26633, 26632
8355,  5137,  5138, 26534, 26533,  5147,  5148, 26634, 26633
8356,  5138,  5139, 26535, 26534,  5148,  5149, 26635, 26634
8357,  5139,  5140, 26536, 26535,  5149,  5150, 26636, 26635
8358,  5140,  5141, 26537, 26536,  5150,  5151, 26637, 26636
8359,  5141,  5142, 26538, 26537,  5151,  5152, 26638, 26637
8360,  5142,   538,  4763, 26538,  5152,   537,  4773, 26638
8361,  4393, 26529, 26539,  4394,  4403, 26629, 26639,  4404
8362, 26529, 26530, 26540, 26539, 26629, 26630, 26640, 26639
8363, 26530, 26531, 26541, 26540, 26630, 26631, 26641, 26640
8364, 26531, 26532, 26542, 26541, 26631, 26632, 26642, 26641
8365, 26532, 26533, 26543, 26542, 26632, 26633, 26643, 26642
8366, 26533, 26534, 26544, 26543, 26633, 26634, 26644, 26643
8367, 26534, 26535, 26545, 26544, 26634, 26635, 26645, 26644
8368, 26535, 26536, 26546, 26545, 26635, 26636, 26646, 26645
8369, 26536, 26537, 26547, 26546, 26636, 26637, 26647, 26646
8370, 26537, 26538, 26548, 26547, 26637, 26638, 26648, 26647
8371, 26538,  4763,  4764, 26548, 26638,  4773,  4774, 26648
8372,  4394, 26539, 26549,  4395,  4404, 26639, 26649,  4405
8373, 26539, 26540, 26550, 26549, 26639, 26640, 26650, 26649
8374, 26540, 26541, 26551, 26550, 26640, 26641, 26651, 26650
8375, 26541, 26542, 26552, 26551, 26641, 26642, 26652, 26651
8376, 26542, 26543, 26553, 26552, 26642, 26643, 26653, 26652
8377, 26543, 26544, 26554, 26553, 26643, 26644, 26654, 26653
8378, 26544, 26545, 26555, 26554, 26644, 26645, 26655, 26654
8379, 26545, 26546, 26556, 26555, 26645, 26646, 26656, 26655
8380, 26546, 26547, 26557, 26556, 26646, 26647, 26657, 26656
8381, 26547, 26548, 26558, 26557, 26647, 26648, 26658, 26657
8382, 26548,  4764,  4765, 26558, 26648,  4774,  4775, 26658
8383,  4395, 26549, 26559,  4396,  4405, 26649, 26659,  4406
8384, 26549, 26550, 26560, 26559, 26649, 26650, 26660, 26659
8385, 26550, 26551, 26561, 26560, 26650, 26651, 26661, 26660
8386, 26551, 26552, 26562, 26561, 26651, 26652, 26662, 26661
8387, 26552, 26553, 26563, 26562, 26652, 26653, 26663, 26662
8388, 26553, 26554, 26564, 26563, 26653, 26654, 26664, 26663
8389, 26554, 26555, 26565, 26564, 26654, 26655, 26665, 26664
8390, 26555, 26556, 26566, 26565, 26655, 26656, 26666, 26665
8391, 26556, 26557, 26567, 26566, 26656, 26657, 26667, 26666
8392, 26557, 26558, 26568, 26567, 26657, 26658, 26668, 26667
8393, 26558,  4765,  4766, 26568, 26658,  4775,  4776, 26668
8394,  4396, 26559, 26569,  4397,  4406, 26659, 26669,  4407
8395, 26559, 26560, 26570, 26569, 26659, 26660, 26670, 26669
8396, 26560, 26561, 26571, 26570, 26660, 26661, 26671, 26670
8397, 26561, 26562, 26572, 26571, 26661, 26662, 26672, 26671
8398, 26562, 26563, 26573, 26572, 26662, 26663, 26673, 26672
8399, 26563, 26564, 26574, 26573, 26663, 26664, 26674, 26673
8400, 26564, 26565, 26575, 26574, 26664, 26665, 26675, 26674
8401, 26565, 26566, 26576, 26575, 26665, 26666, 26676, 26675
8402, 26566, 26567, 26577, 26576, 26666, 26667, 26677, 26676
8403, 26567, 26568, 26578, 26577, 26667, 26668, 26678, 26677
8404, 26568,  4766,  4767, 26578, 26668,  4776,  4777, 26678
8405,  4397, 26569, 26579,  4398,  4407, 26669, 26679,  4408
8406, 26569, 26570, 26580, 26579, 26669, 26670, 26680, 26679
8407, 26570, 26571, 26581, 26580, 26670, 26671, 26681, 26680
8408, 26571, 26572, 26582, 26581, 26671, 26672, 26682, 26681
8409, 26572, 26573, 26583, 26582, 26672, 26673, 26683, 26682
8410, 26573, 26574, 26584, 26583, 26673, 26674, 26684, 26683
8411, 26574, 26575, 26585, 26584, 26674, 26675, 26685, 26684
8412, 26575, 26576, 26586, 26585, 26675, 26676, 26686, 26685
8413, 26576, 26577, 26587, 26586, 26676, 26677, 26687, 26686
8414, 26577, 26578, 26588, 26587, 26677, 26678, 26688, 26687
8415, 26578,  4767,  4768, 26588, 26678,  4777,  4778, 26688
8416,  4398, 26579, 26589,  4399,  4408, 26679, 26689,  4409
8417, 26579, 26580, 26590, 26589, 26679, 26680, 26690, 26689
8418, 26580, 26581, 26591, 26590, 26680, 26681, 26691, 26690
8419, 26581, 26582, 26592, 26591, 26681, 26682, 26692, 26691
8420, 26582, 26583, 26593, 26592, 26682, 26683, 26693, 26692
8421, 26583, 26584, 26594, 26593, 26683, 26684, 26694, 26693
8422, 26584, 26585, 26595, 26594, 26684, 26685, 26695, 26694
8423, 26585, 26586, 26596, 26595, 26685, 26686, 26696, 26695
8424, 26586, 26587, 26597, 26596, 26686, 26687, 26697, 26696
8425, 26587, 26588, 26598, 26597, 26687, 26688, 26698, 26697
8426, 26588,  4768,  4769, 26598, 26688,  4778,  4779, 26698
8427,  4399, 26589, 26599,  4400,  4409, 26689, 26699,  4410
8428, 26589, 26590, 26600, 26599, 26689, 26690, 26700, 26699
8429, 26590, 26591, 26601, 26600, 26690, 26691, 26701, 26700
8430, 26591, 26592, 26602, 26601, 26691, 26692, 26702, 26701
8431, 26592, 26593, 26603, 26602, 26692, 26693, 26703, 26702
8432, 26593, 26594, 26604, 26603, 26693, 26694, 26704, 26703
8433, 26594, 26595, 26605, 26604, 26694, 26695, 26705, 26704
8434, 26595, 26596, 26606, 26605, 26695, 26696, 26706, 26705
8435, 26596, 26597, 26607, 26606, 26696, 26697, 26707, 26706
8436, 26597, 26598, 26608, 26607, 26697, 26698, 26708, 26707
8437, 26598,  4769,  4770, 26608, 26698,  4779,  4780, 26708
8438,  4400, 26599, 26609,  4401,  4410, 26699, 26709,  4411
8439, 26599, 26600, 26610, 26609, 26699, 26700, 26710, 26709
8440, 26600, 26601, 26611, 26610, 26700, 26701, 26711, 26710
8441, 26601, 26602, 26612, 26611, 26701, 26702, 26712, 26711
8442, 26602, 26603, 26613, 26612, 26702, 26703, 26713, 26712
8443, 26603, 26604, 26614, 26613, 26703, 26704, 26714, 26713
8444, 26604, 26605, 26615, 26614, 26704, 26705, 26715, 26714
8445, 26605, 26606, 26616, 26615, 26705, 26706, 26716, 26715
8446, 26606, 26607, 26617, 26616, 26706, 26707, 26717, 26716
8447, 26607, 26608, 26618, 26617, 26707, 26708, 26718, 26717
8448, 26608,  4770,  4771, 26618, 26708,  4780,  4781, 26718
8449,  4401, 26609, 26619,  4402,  4411, 26709, 26719,  4412
8450, 26609, 26610, 26620, 26619, 26709, 26710, 26720, 26719
8451, 26610, 26611, 26621, 26620, 26710, 26711, 26721, 26720
8452, 26611, 26612, 26622, 26621, 26711, 26712, 26722, 26721
8453, 26612, 26613, 26623, 26622, 26712, 26713, 26723, 26722
8454, 26613, 26614, 26624, 26623, 26713, 26714, 26724, 26723
8455, 26614, 26615, 26625, 26624, 26714, 26715, 26725, 26724
8456, 26615, 26616, 26626, 26625, 26715, 26716, 26726, 26725
8457, 26616, 26617, 26627, 26626, 26716, 26717, 26727, 26726
8458, 26617, 26618, 26628, 26627, 26717, 26718, 26728, 26727
8459, 26618,  4771,  4772, 26628, 26718,  4781,  4782, 26728
8460,  4402, 26619,  5383,   431,  4412, 26719,   602,    24
8461, 26619, 26620,  5359,  5383, 26719, 26720,   603,   602
8462, 26620, 26621,  5335,  5359, 26720, 26721,   604,   603
8463, 26621, 26622,  5311,  5335, 26721, 26722,   605,   604
8464, 26622, 26623,  5287,  5311, 26722, 26723,   606,   605
8465, 26623, 26624,  5263,  5287, 26723, 26724,   607,   606
8466, 26624, 26625,   578,  5263, 26724, 26725,    28,   607
8467, 26625, 26626,  5430,   578, 26725, 26726,   608,    28
8468, 26626, 26627,  5454,  5430, 26726, 26727,   609,   608
8469, 26627, 26628,  5478,  5454, 26727, 26728,   610,   609
8470, 26628,  4772,   526,  5478, 26728,  4782,    26,   610
8471,   491,  5143, 26629,  4403,   492,  5153, 26729,  4413
8472,  5143,  5144, 26630, 26629,  5153,  5154, 26730, 26729
8473,  5144,  5145, 26631, 26630,  5154,  5155, 26731, 26730
8474,  5145,  5146, 26632, 26631,  5155,  5156, 26732, 26731
8475,  5146,  5147, 26633, 26632,  5156,  5157, 26733, 26732
8476,  5147,  5148, 26634, 26633,  5157,  5158, 26734, 26733
8477,  5148,  5149, 26635, 26634,  5158,  5159, 26735, 26734
8478,  5149,  5150, 26636, 26635,  5159,  5160, 26736, 26735
8479,  5150,  5151, 26637, 26636,  5160,  5161, 26737, 26736
8480,  5151,  5152, 26638, 26637,  5161,  5162, 26738, 26737
8481,  5152,   537,  4773, 26638,  5162,   536,  4783, 26738
8482,  4403, 26629, 26639,  4404,  4413, 26729, 26739,  4414
8483, 26629, 26630, 26640, 26639, 26729, 26730, 26740, 26739
8484, 26630, 26631, 26641, 26640, 26730, 26731, 26741, 26740
8485, 26631, 26632, 26642, 26641, 26731, 26732, 26742, 26741
8486, 26632, 26633, 26643, 26642, 26732, 26733, 26743, 26742
8487, 26633, 26634, 26644, 26643, 26733, 26734, 26744, 26743
8488, 26634, 26635, 26645, 26644, 26734, 26735, 26745, 26744
8489, 26635, 26636, 26646, 26645, 26735, 26736, 26746, 26745
8490, 26636, 26637, 26647, 26646, 26736, 26737, 26747, 26746
8491, 26637, 26638, 26648, 26647, 26737, 26738, 26748, 26747
8492, 26638,  4773,  4774, 26648, 26738,  4783,  4784, 26748
8493,  4404, 26639, 26649,  4405,  4414, 26739, 26749,  4415
8494, 26639, 26640, 26650, 26649, 26739, 26740, 26750, 26749
8495, 26640, 26641, 26651, 26650, 26740, 26741, 26751, 26750
8496, 26641, 26642, 26652, 26651, 26741, 26742, 26752, 26751
8497, 26642, 26643, 26653, 26652, 26742, 26743, 26753, 26752
8498, 26643, 26644, 26654, 26653, 26743, 26744, 26754, 26753
8499, 26644, 26645, 26655, 26654, 26744, 26745, 26755, 26754
8500, 26645, 26646, 26656, 26655, 26745, 26746, 26756, 26755
8501, 26646, 26647, 26657, 26656, 26746, 26747, 26757, 26756
8502, 26647, 26648, 26658, 26657, 26747, 26748, 26758, 26757
8503, 26648,  4774,  4775, 26658, 26748,  4784,  4785, 26758
8504,  4405, 26649, 26659,  4406,  4415, 26749, 26759,  4416
8505, 26649, 26650, 26660, 26659, 26749, 26750, 26760, 26759
8506, 26650, 26651, 26661, 26660, 26750, 26751, 26761, 26760
8507, 26651, 26652, 26662, 26661, 26751, 26752, 26762, 26761
8508, 26652, 26653, 26663, 26662, 26752, 26753, 26763, 26762
8509, 26653, 26654, 26664, 26663, 26753, 26754, 26764, 26763
8510, 26654, 26655, 26665, 26664, 26754, 26755, 26765, 26764
8511, 26655, 26656, 26666, 26665, 26755, 26756, 26766, 26765
8512, 26656, 26657, 26667, 26666, 26756, 26757, 26767, 26766
8513, 26657, 26658, 26668, 26667, 26757, 26758, 26768, 26767
8514, 26658,  4775,  4776, 26668, 26758,  4785,  4786, 26768
8515,  4406, 26659, 26669,  4407,  4416, 26759, 26769,  4417
8516, 26659, 26660, 26670, 26669, 26759, 26760, 26770, 26769
8517, 26660, 26661, 26671, 26670, 26760, 26761, 26771, 26770
8518, 26661, 26662, 26672, 26671, 26761, 26762, 26772, 26771
8519, 26662, 26663, 26673, 26672, 26762, 26763, 26773, 26772
8520, 26663, 26664, 26674, 26673, 26763, 26764, 26774, 26773
8521, 26664, 26665, 26675, 26674, 26764, 26765, 26775, 26774
8522, 26665, 26666, 26676, 26675, 26765, 26766, 26776, 26775
8523, 26666, 26667, 26677, 26676, 26766, 26767, 26777, 26776
8524, 26667, 26668, 26678, 26677, 26767, 26768, 26778, 26777
8525, 26668,  4776,  4777, 26678, 26768,  4786,  4787, 26778
8526,  4407, 26669, 26679,  4408,  4417, 26769, 26779,  4418
8527, 26669, 26670, 26680, 26679, 26769, 26770, 26780, 26779
8528, 26670, 26671, 26681, 26680, 26770, 26771, 26781, 26780
8529, 26671, 26672, 26682, 26681, 26771, 26772, 26782, 26781
8530, 26672, 26673, 26683, 26682, 26772, 26773, 26783, 26782
8531, 26673, 26674, 26684, 26683, 26773, 26774, 26784, 26783
8532, 26674, 26675, 26685, 26684, 26774, 26775, 26785, 26784
8533, 26675, 26676, 26686, 26685, 26775, 26776, 26786, 26785
8534, 26676, 26677, 26687, 26686, 26776, 26777, 26787, 26786
8535, 26677, 26678, 26688, 26687, 26777, 26778, 26788, 26787
8536, 26678,  4777,  4778, 26688, 26778,  4787,  4788, 26788
8537,  4408, 26679, 26689,  4409,  4418, 26779, 26789,  4419
8538, 26679, 26680, 26690, 26689, 26779, 26780, 26790, 26789
8539, 26680, 26681, 26691, 26690, 26780, 26781, 26791, 26790
8540, 26681, 26682, 26692, 26691, 26781, 26782, 26792, 26791
8541, 26682, 26683, 26693, 26692, 26782, 26783, 26793, 26792
8542, 26683, 26684, 26694, 26693, 26783, 26784, 26794, 26793
8543, 26684, 26685, 26695, 26694, 26784, 26785, 26795, 26794
8544, 26685, 26686, 26696, 26695, 26785, 26786, 26796, 26795
8545, 26686, 26687, 26697, 26696, 26786, 26787, 26797, 26796
8546, 26687, 26688, 26698, 26697, 26787, 26788, 26798, 26797
8547, 26688,  4778,  4779, 26698, 26788,  4788,  4789, 26798
8548,  4409, 26689, 26699,  4410,  4419, 26789, 26799,  4420
8549, 26689, 26690, 26700, 26699, 26789, 26790, 26800, 26799
8550, 26690, 26691, 26701, 26700, 26790, 26791, 26801, 26800
8551, 26691, 26692, 26702, 26701, 26791, 26792, 26802, 26801
8552, 26692, 26693, 26703, 26702, 26792, 26793, 26803, 26802
8553, 26693, 26694, 26704, 26703, 26793, 26794, 26804, 26803
8554, 26694, 26695, 26705, 26704, 26794, 26795, 26805, 26804
8555, 26695, 26696, 26706, 26705, 26795, 26796, 26806, 26805
8556, 26696, 26697, 26707, 26706, 26796, 26797, 26807, 26806
8557, 26697, 26698, 26708, 26707, 26797, 26798, 26808, 26807
8558, 26698,  4779,  4780, 26708, 26798,  4789,  4790, 26808
8559,  4410, 26699, 26709,  4411,  4420, 26799, 26809,  4421
8560, 26699, 26700, 26710, 26709, 26799, 26800, 26810, 26809
8561, 26700, 26701, 26711, 26710, 26800, 26801, 26811, 26810
8562, 26701, 26702, 26712, 26711, 26801, 26802, 26812, 26811
8563, 26702, 26703, 26713, 26712, 26802, 26803, 26813, 26812
8564, 26703, 26704, 26714, 26713, 26803, 26804, 26814, 26813
8565, 26704, 26705, 26715, 26714, 26804, 26805, 26815, 26814
8566, 26705, 26706, 26716, 26715, 26805, 26806, 26816, 26815
8567, 26706, 26707, 26717, 26716, 26806, 26807, 26817, 26816
8568, 26707, 26708, 26718, 26717, 26807, 26808, 26818, 26817
8569, 26708,  4780,  4781, 26718, 26808,  4790,  4791, 26818
8570,  4411, 26709, 26719,  4412,  4421, 26809, 26819,  4422
8571, 26709, 26710, 26720, 26719, 26809, 26810, 26820, 26819
8572, 26710, 26711, 26721, 26720, 26810, 26811, 26821, 26820
8573, 26711, 26712, 26722, 26721, 26811, 26812, 26822, 26821
8574, 26712, 26713, 26723, 26722, 26812, 26813, 26823, 26822
8575, 26713, 26714, 26724, 26723, 26813, 26814, 26824, 26823
8576, 26714, 26715, 26725, 26724, 26814, 26815, 26825, 26824
8577, 26715, 26716, 26726, 26725, 26815, 26816, 26826, 26825
8578, 26716, 26717, 26727, 26726, 26816, 26817, 26827, 26826
8579, 26717, 26718, 26728, 26727, 26817, 26818, 26828, 26827
8580, 26718,  4781,  4782, 26728, 26818,  4791,  4792, 26828
8581,  4412, 26719,   602,    24,  4422, 26819,  5488,   459
8582, 26719, 26720,   603,   602, 26819, 26820,  5487,  5488
8583, 26720, 26721,   604,   603, 26820, 26821,  5486,  5487
8584, 26721, 26722,   605,   604, 26821, 26822,  5485,  5486
8585, 26722, 26723,   606,   605, 26822, 26823,  5484,  5485
8586, 26723, 26724,   607,   606, 26823, 26824,  5483,  5484
8587, 26724, 26725,    28,   607, 26824, 26825,  5482,  5483
8588, 26725, 26726,   608,    28, 26825, 26826,  5481,  5482
8589, 26726, 26727,   609,   608, 26826, 26827,  5480,  5481
8590, 26727, 26728,   610,   609, 26827, 26828,  5479,  5480
8591, 26728,  4782,    26,   610, 26828,  4792,   527,  5479
8592,   492,  5153, 26729,  4413,   493,  5163, 26829,  4423
8593,  5153,  5154, 26730, 26729,  5163,  5164, 26830, 26829
8594,  5154,  5155, 26731, 26730,  5164,  5165, 26831, 26830
8595,  5155,  5156, 26732, 26731,  5165,  5166, 26832, 26831
8596,  5156,  5157, 26733, 26732,  5166,  5167, 26833, 26832
8597,  5157,  5158, 26734, 26733,  5167,  5168, 26834, 26833
8598,  5158,  5159, 26735, 26734,  5168,  5169, 26835, 26834
8599,  5159,  5160, 26736, 26735,  5169,  5170, 26836, 26835
8600,  5160,  5161, 26737, 26736,  5170,  5171, 26837, 26836
8601,  5161,  5162, 26738, 26737,  5171,  5172, 26838, 26837
8602,  5162,   536,  4783, 26738,  5172,   535,  4793, 26838
8603,  4413, 26729, 26739,  4414,  4423, 26829, 26839,  4424
8604, 26729, 26730, 26740, 26739, 26829, 26830, 26840, 26839
8605, 26730, 26731, 26741, 26740, 26830, 26831, 26841, 26840
8606, 26731, 26732, 26742, 26741, 26831, 26832, 26842, 26841
8607, 26732, 26733, 26743, 26742, 26832, 26833, 26843, 26842
8608, 26733, 26734, 26744, 26743, 26833, 26834, 26844, 26843
8609, 26734, 26735, 26745, 26744, 26834, 26835, 26845, 26844
8610, 26735, 26736, 26746, 26745, 26835, 26836, 26846, 26845
8611, 26736, 26737, 26747, 26746, 26836, 26837, 26847, 26846
8612, 26737, 26738, 26748, 26747, 26837, 26838, 26848, 26847
8613, 26738,  4783,  4784, 26748, 26838,  4793,  4794, 26848
8614,  4414, 26739, 26749,  4415,  4424, 26839, 26849,  4425
8615, 26739, 26740, 26750, 26749, 26839, 26840, 26850, 26849
8616, 26740, 26741, 26751, 26750, 26840, 26841, 26851, 26850
8617, 26741, 26742, 26752, 26751, 26841, 26842, 26852, 26851
8618, 26742, 26743, 26753, 26752, 26842, 26843, 26853, 26852
8619, 26743, 26744, 26754, 26753, 26843, 26844, 26854, 26853
8620, 26744, 26745, 26755, 26754, 26844, 26845, 26855, 26854
8621, 26745, 26746, 26756, 26755, 26845, 26846, 26856, 26855
8622, 26746, 26747, 26757, 26756, 26846, 26847, 26857, 26856
8623, 26747, 26748, 26758, 26757, 26847, 26848, 26858, 26857
8624, 26748,  4784,  4785, 26758, 26848,  4794,  4795, 26858
8625,  4415, 26749, 26759,  4416,  4425, 26849, 26859,  4426
8626, 26749, 26750, 26760, 26759, 26849, 26850, 26860, 26859
8627, 26750, 26751, 26761, 26760, 26850, 26851, 26861, 26860
8628, 26751, 26752, 26762, 26761, 26851, 26852, 26862, 26861
8629, 26752, 26753, 26763, 26762, 26852, 26853, 26863, 26862
8630, 26753, 26754, 26764, 26763, 26853, 26854, 26864, 26863
8631, 26754, 26755, 26765, 26764, 26854, 26855, 26865, 26864
8632, 26755, 26756, 26766, 26765, 26855, 26856, 26866, 26865
8633, 26756, 26757, 26767, 26766, 26856, 26857, 26867, 26866
8634, 26757, 26758, 26768, 26767, 26857, 26858, 26868, 26867
8635, 26758,  4785,  4786, 26768, 26858,  4795,  4796, 26868
8636,  4416, 26759, 26769,  4417,  4426, 26859, 26869,  4427
8637, 26759, 26760, 26770, 26769, 26859, 26860, 26870, 26869
8638, 26760, 26761, 26771, 26770, 26860, 26861, 26871, 26870
8639, 26761, 26762, 26772, 26771, 26861, 26862, 26872, 26871
8640, 26762, 26763, 26773, 26772, 26862, 26863, 26873, 26872
8641, 26763, 26764, 26774, 26773, 26863, 26864, 26874, 26873
8642, 26764, 26765, 26775, 26774, 26864, 26865, 26875, 26874
8643, 26765, 26766, 26776, 26775, 26865, 26866, 26876, 26875
8644, 26766, 26767, 26777, 26776, 26866, 26867, 26877, 26876
8645, 26767, 26768, 26778, 26777, 26867, 26868, 26878, 26877
8646, 26768,  4786,  4787, 26778, 26868,  4796,  4797, 26878
8647,  4417, 26769, 26779,  4418,  4427, 26869, 26879,  4428
8648, 26769, 26770, 26780, 26779, 26869, 26870, 26880, 26879
8649, 26770, 26771, 26781, 26780, 26870, 26871, 26881, 26880
8650, 26771, 26772, 26782, 26781, 26871, 26872, 26882, 26881
8651, 26772, 26773, 26783, 26782, 26872, 26873, 26883, 26882
8652, 26773, 26774, 26784, 26783, 26873, 26874, 26884, 26883
8653, 26774, 26775, 26785, 26784, 26874, 26875, 26885, 26884
8654, 26775, 26776, 26786, 26785, 26875, 26876, 26886, 26885
8655, 26776, 26777, 26787, 26786, 26876, 26877, 26887, 26886
8656, 26777, 26778, 26788, 26787, 26877, 26878, 26888, 26887
8657, 26778,  4787,  4788, 26788, 26878,  4797,  4798, 26888
8658,  4418, 26779, 26789,  4419,  4428, 26879, 26889,  4429
8659, 26779, 26780, 26790, 26789, 26879, 26880, 26890, 26889
8660, 26780, 26781, 26791, 26790, 26880, 26881, 26891, 26890
8661, 26781, 26782, 26792, 26791, 26881, 26882, 26892, 26891
8662, 26782, 26783, 26793, 26792, 26882, 26883, 26893, 26892
8663, 26783, 26784, 26794, 26793, 26883, 26884, 26894, 26893
8664, 26784, 26785, 26795, 26794, 26884, 26885, 26895, 26894
8665, 26785, 26786, 26796, 26795, 26885, 26886, 26896, 26895
8666, 26786, 26787, 26797, 26796, 26886, 26887, 26897, 26896
8667, 26787, 26788, 26798, 26797, 26887, 26888, 26898, 26897
8668, 26788,  4788,  4789, 26798, 26888,  4798,  4799, 26898
8669,  4419, 26789, 26799,  4420,  4429, 26889, 26899,  4430
8670, 26789, 26790, 26800, 26799, 26889, 26890, 26900, 26899
8671, 26790, 26791, 26801, 26800, 26890, 26891, 26901, 26900
8672, 26791, 26792, 26802, 26801, 26891, 26892, 26902, 26901
8673, 26792, 26793, 26803, 26802, 26892, 26893, 26903, 26902
8674, 26793, 26794, 26804, 26803, 26893, 26894, 26904, 26903
8675, 26794, 26795, 26805, 26804, 26894, 26895, 26905, 26904
8676, 26795, 26796, 26806, 26805, 26895, 26896, 26906, 26905
8677, 26796, 26797, 26807, 26806, 26896, 26897, 26907, 26906
8678, 26797, 26798, 26808, 26807, 26897, 26898, 26908, 26907
8679, 26798,  4789,  4790, 26808, 26898,  4799,  4800, 26908
8680,  4420, 26799, 26809,  4421,  4430, 26899, 26909,  4431
8681, 26799, 26800, 26810, 26809, 26899, 26900, 26910, 26909
8682, 26800, 26801, 26811, 26810, 26900, 26901, 26911, 26910
8683, 26801, 26802, 26812, 26811, 26901, 26902, 26912, 26911
8684, 26802, 26803, 26813, 26812, 26902, 26903, 26913, 26912
8685, 26803, 26804, 26814, 26813, 26903, 26904, 26914, 26913
8686, 26804, 26805, 26815, 26814, 26904, 26905, 26915, 26914
8687, 26805, 26806, 26816, 26815, 26905, 26906, 26916, 26915
8688, 26806, 26807, 26817, 26816, 26906, 26907, 26917, 26916
8689, 26807, 26808, 26818, 26817, 26907, 26908, 26918, 26917
8690, 26808,  4790,  4791, 26818, 26908,  4800,  4801, 26918
8691,  4421, 26809, 26819,  4422,  4431, 26909, 26919,  4432
8692, 26809, 26810, 26820, 26819, 26909, 26910, 26920, 26919
8693, 26810, 26811, 26821, 26820, 26910, 26911, 26921, 26920
8694, 26811, 26812, 26822, 26821, 26911, 26912, 26922, 26921
8695, 26812, 26813, 26823, 26822, 26912, 26913, 26923, 26922
8696, 26813, 26814, 26824, 26823, 26913, 26914, 26924, 26923
8697, 26814, 26815, 26825, 26824, 26914, 26915, 26925, 26924
8698, 26815, 26816, 26826, 26825, 26915, 26916, 26926, 26925
8699, 26816, 26817, 26827, 26826, 26916, 26917, 26927, 26926
8700, 26817, 26818, 26828, 26827, 26917, 26918, 26928, 26927
8701, 26818,  4791,  4792, 26828, 26918,  4801,  4802, 26928
8702,  4422, 26819,  5488,   459,  4432, 26919,  5498,   458
8703, 26819, 26820,  5487,  5488, 26919, 26920,  5497,  5498
8704, 26820, 26821,  5486,  5487, 26920, 26921,  5496,  5497
8705, 26821, 26822,  5485,  5486, 26921, 26922,  5495,  5496
8706, 26822, 26823,  5484,  5485, 26922, 26923,  5494,  5495
8707, 26823, 26824,  5483,  5484, 26923, 26924,  5493,  5494
8708, 26824, 26825,  5482,  5483, 26924, 26925,  5492,  5493
8709, 26825, 26826,  5481,  5482, 26925, 26926,  5491,  5492
8710, 26826, 26827,  5480,  5481, 26926, 26927,  5490,  5491
8711, 26827, 26828,  5479,  5480, 26927, 26928,  5489,  5490
8712, 26828,  4792,   527,  5479, 26928,  4802,   528,  5489
8713,   493,  5163, 26829,  4423,   494,  5173, 26929,  4433
8714,  5163,  5164, 26830, 26829,  5173,  5174, 26930, 26929
8715,  5164,  5165, 26831, 26830,  5174,  5175, 26931, 26930
8716,  5165,  5166, 26832, 26831,  5175,  5176, 26932, 26931
8717,  5166,  5167, 26833, 26832,  5176,  5177, 26933, 26932
8718,  5167,  5168, 26834, 26833,  5177,  5178, 26934, 26933
8719,  5168,  5169, 26835, 26834,  5178,  5179, 26935, 26934
8720,  5169,  5170, 26836, 26835,  5179,  5180, 26936, 26935
8721,  5170,  5171, 26837, 26836,  5180,  5181, 26937, 26936
8722,  5171,  5172, 26838, 26837,  5181,  5182, 26938, 26937
8723,  5172,   535,  4793, 26838,  5182,   534,  4803, 26938
8724,  4423, 26829, 26839,  4424,  4433, 26929, 26939,  4434
8725, 26829, 26830, 26840, 26839, 26929, 26930, 26940, 26939
8726, 26830, 26831, 26841, 26840, 26930, 26931, 26941, 26940
8727, 26831, 26832, 26842, 26841, 26931, 26932, 26942, 26941
8728, 26832, 26833, 26843, 26842, 26932, 26933, 26943, 26942
8729, 26833, 26834, 26844, 26843, 26933, 26934, 26944, 26943
8730, 26834, 26835, 26845, 26844, 26934, 26935, 26945, 26944
8731, 26835, 26836, 26846, 26845, 26935, 26936, 26946, 26945
8732, 26836, 26837, 26847, 26846, 26936, 26937, 26947, 26946
8733, 26837, 26838, 26848, 26847, 26937, 26938, 26948, 26947
8734, 26838,  4793,  4794, 26848, 26938,  4803,  4804, 26948
8735,  4424, 26839, 26849,  4425,  4434, 26939, 26949,  4435
8736, 26839, 26840, 26850, 26849, 26939, 26940, 26950, 26949
8737, 26840, 26841, 26851, 26850, 26940, 26941, 26951, 26950
8738, 26841, 26842, 26852, 26851, 26941, 26942, 26952, 26951
8739, 26842, 26843, 26853, 26852, 26942, 26943, 26953, 26952
8740, 26843, 26844, 26854, 26853, 26943, 26944, 26954, 26953
8741, 26844, 26845, 26855, 26854, 26944, 26945, 26955, 26954
8742, 26845, 26846, 26856, 26855, 26945, 26946, 26956, 26955
8743, 26846, 26847, 26857, 26856, 26946, 26947, 26957, 26956
8744, 26847, 26848, 26858, 26857, 26947, 26948, 26958, 26957
8745, 26848,  4794,  4795, 26858, 26948,  4804,  4805, 26958
8746,  4425, 26849, 26859,  4426,  4435, 26949, 26959,  4436
8747, 26849, 26850, 26860, 26859, 26949, 26950, 26960, 26959
8748, 26850, 26851, 26861, 26860, 26950, 26951, 26961, 26960
8749, 26851, 26852, 26862, 26861, 26951, 26952, 26962, 26961
8750, 26852, 26853, 26863, 26862, 26952, 26953, 26963, 26962
8751, 26853, 26854, 26864, 26863, 26953, 26954, 26964, 26963
8752, 26854, 26855, 26865, 26864, 26954, 26955, 26965, 26964
8753, 26855, 26856, 26866, 26865, 26955, 26956, 26966, 26965
8754, 26856, 26857, 26867, 26866, 26956, 26957, 26967, 26966
8755, 26857, 26858, 26868, 26867, 26957, 26958, 26968, 26967
8756, 26858,  4795,  4796, 26868, 26958,  4805,  4806, 26968
8757,  4426, 26859, 26869,  4427,  4436, 26959, 26969,  4437
8758, 26859, 26860, 26870, 26869, 26959, 26960, 26970, 26969
8759, 26860, 26861, 26871, 26870, 26960, 26961, 26971, 26970
8760, 26861, 26862, 26872, 26871, 26961, 26962, 26972, 26971
8761, 26862, 26863, 26873, 26872, 26962, 26963, 26973, 26972
8762, 26863, 26864, 26874, 26873, 26963, 26964, 26974, 26973
8763, 26864, 26865, 26875, 26874, 26964, 26965, 26975, 26974
8764, 26865, 26866, 26876, 26875, 26965, 26966, 26976, 26975
8765, 26866, 26867, 26877, 26876, 26966, 26967, 26977, 26976
8766, 26867, 26868, 26878, 26877, 26967, 26968, 26978, 26977
8767, 26868,  4796,  4797, 26878, 26968,  4806,  4807, 26978
8768,  4427, 26869, 26879,  4428,  4437, 26969, 26979,  4438
8769, 26869, 26870, 26880, 26879, 26969, 26970, 26980, 26979
8770, 26870, 26871, 26881, 26880, 26970, 26971, 26981, 26980
8771, 26871, 26872, 26882, 26881, 26971, 26972, 26982, 26981
8772, 26872, 26873, 26883, 26882, 26972, 26973, 26983, 26982
8773, 26873, 26874, 26884, 26883, 26973, 26974, 26984, 26983
8774, 26874, 26875, 26885, 26884, 26974, 26975, 26985, 26984
8775, 26875, 26876, 26886, 26885, 26975, 26976, 26986, 26985
8776, 26876, 26877, 26887, 26886, 26976, 26977, 26987, 26986
8777, 26877, 26878, 26888, 26887, 26977, 26978, 26988, 26987
8778, 26878,  4797,  4798, 26888, 26978,  4807,  4808, 26988
8779,  4428, 26879, 26889,  4429,  4438, 26979, 26989,  4439
8780, 26879, 26880, 26890, 26889, 26979, 26980, 26990, 26989
8781, 26880, 26881, 26891, 26890, 26980, 26981, 26991, 26990
8782, 26881, 26882, 26892, 26891, 26981, 26982, 26992, 26991
8783, 26882, 26883, 26893, 26892, 26982, 26983, 26993, 26992
8784, 26883, 26884, 26894, 26893, 26983, 26984, 26994, 26993
8785, 26884, 26885, 26895, 26894, 26984, 26985, 26995, 26994
8786, 26885, 26886, 26896, 26895, 26985, 26986, 26996, 26995
8787, 26886, 26887, 26897, 26896, 26986, 26987, 26997, 26996
8788, 26887, 26888, 26898, 26897, 26987, 26988, 26998, 26997
8789, 26888,  4798,  4799, 26898, 26988,  4808,  4809, 26998
8790,  4429, 26889, 26899,  4430,  4439, 26989, 26999,  4440
8791, 26889, 26890, 26900, 26899, 26989, 26990, 27000, 26999
8792, 26890, 26891, 26901, 26900, 26990, 26991, 27001, 27000
8793, 26891, 26892, 26902, 26901, 26991, 26992, 27002, 27001
8794, 26892, 26893, 26903, 26902, 26992, 26993, 27003, 27002
8795, 26893, 26894, 26904, 26903, 26993, 26994, 27004, 27003
8796, 26894, 26895, 26905, 26904, 26994, 26995, 27005, 27004
8797, 26895, 26896, 26906, 26905, 26995, 26996, 27006, 27005
8798, 26896, 26897, 26907, 26906, 26996, 26997, 27007, 27006
8799, 26897, 26898, 26908, 26907, 26997, 26998, 27008, 27007
8800, 26898,  4799,  4800, 26908, 26998,  4809,  4810, 27008
8801,  4430, 26899, 26909,  4431,  4440, 26999, 27009,  4441
8802, 26899, 26900, 26910, 26909, 26999, 27000, 27010, 27009
8803, 26900, 26901, 26911, 26910, 27000, 27001, 27011, 27010
8804, 26901, 26902, 26912, 26911, 27001, 27002, 27012, 27011
8805, 26902, 26903, 26913, 26912, 27002, 27003, 27013, 27012
8806, 26903, 26904, 26914, 26913, 27003, 27004, 27014, 27013
8807, 26904, 26905, 26915, 26914, 27004, 27005, 27015, 27014
8808, 26905, 26906, 26916, 26915, 27005, 27006, 27016, 27015
8809, 26906, 26907, 26917, 26916, 27006, 27007, 27017, 27016
8810, 26907, 26908, 26918, 26917, 27007, 27008, 27018, 27017
8811, 26908,  4800,  4801, 26918, 27008,  4810,  4811, 27018
8812,  4431, 26909, 26919,  4432,  4441, 27009, 27019,  4442
8813, 26909, 26910, 26920, 26919, 27009, 27010, 27020, 27019
8814, 26910, 26911, 26921, 26920, 27010, 27011, 27021, 27020
8815, 26911, 26912, 26922, 26921, 27011, 27012, 27022, 27021
8816, 26912, 26913, 26923, 26922, 27012, 27013, 27023, 27022
8817, 26913, 26914, 26924, 26923, 27013, 27014, 27024, 27023
8818, 26914, 26915, 26925, 26924, 27014, 27015, 27025, 27024
8819, 26915, 26916, 26926, 26925, 27015, 27016, 27026, 27025
8820, 26916, 26917, 26927, 26926, 27016, 27017, 27027, 27026
8821, 26917, 26918, 26928, 26927, 27017, 27018, 27028, 27027
8822, 26918,  4801,  4802, 26928, 27018,  4811,  4812, 27028
8823,  4432, 26919,  5498,   458,  4442, 27019,  5508,   457
8824, 26919, 26920,  5497,  5498, 27019, 27020,  5507,  5508
8825, 26920, 26921,  5496,  5497, 27020, 27021,  5506,  5507
8826, 26921, 26922,  5495,  5496, 27021, 27022,  5505,  5506
8827, 26922, 26923,  5494,  5495, 27022, 27023,  5504,  5505
8828, 26923, 26924,  5493,  5494, 27023, 27024,  5503,  5504
8829, 26924, 26925,  5492,  5493, 27024, 27025,  5502,  5503
8830, 26925, 26926,  5491,  5492, 27025, 27026,  5501,  5502
8831, 26926, 26927,  5490,  5491, 27026, 27027,  5500,  5501
8832, 26927, 26928,  5489,  5490, 27027, 27028,  5499,  5500
8833, 26928,  4802,   528,  5489, 27028,  4812,   529,  5499
8834,   494,  5173, 26929,  4433,   495,  5183, 27029,  4443
8835,  5173,  5174, 26930, 26929,  5183,  5184, 27030, 27029
8836,  5174,  5175, 26931, 26930,  5184,  5185, 27031, 27030
8837,  5175,  5176, 26932, 26931,  5185,  5186, 27032, 27031
8838,  5176,  5177, 26933, 26932,  5186,  5187, 27033, 27032
8839,  5177,  5178, 26934, 26933,  5187,  5188, 27034, 27033
8840,  5178,  5179, 26935, 26934,  5188,  5189, 27035, 27034
8841,  5179,  5180, 26936, 26935,  5189,  5190, 27036, 27035
8842,  5180,  5181, 26937, 26936,  5190,  5191, 27037, 27036
8843,  5181,  5182, 26938, 26937,  5191,  5192, 27038, 27037
8844,  5182,   534,  4803, 26938,  5192,   533,  4813, 27038
8845,  4433, 26929, 26939,  4434,  4443, 27029, 27039,  4444
8846, 26929, 26930, 26940, 26939, 27029, 27030, 27040, 27039
8847, 26930, 26931, 26941, 26940, 27030, 27031, 27041, 27040
8848, 26931, 26932, 26942, 26941, 27031, 27032, 27042, 27041
8849, 26932, 26933, 26943, 26942, 27032, 27033, 27043, 27042
8850, 26933, 26934, 26944, 26943, 27033, 27034, 27044, 27043
8851, 26934, 26935, 26945, 26944, 27034, 27035, 27045, 27044
8852, 26935, 26936, 26946, 26945, 27035, 27036, 27046, 27045
8853, 26936, 26937, 26947, 26946, 27036, 27037, 27047, 27046
8854, 26937, 26938, 26948, 26947, 27037, 27038, 27048, 27047
8855, 26938,  4803,  4804, 26948, 27038,  4813,  4814, 27048
8856,  4434, 26939, 26949,  4435,  4444, 27039, 27049,  4445
8857, 26939, 26940, 26950, 26949, 27039, 27040, 27050, 27049
8858, 26940, 26941, 26951, 26950, 27040, 27041, 27051, 27050
8859, 26941, 26942, 26952, 26951, 27041, 27042, 27052, 27051
8860, 26942, 26943, 26953, 26952, 27042, 27043, 27053, 27052
8861, 26943, 26944, 26954, 26953, 27043, 27044, 27054, 27053
8862, 26944, 26945, 26955, 26954, 27044, 27045, 27055, 27054
8863, 26945, 26946, 26956, 26955, 27045, 27046, 27056, 27055
8864, 26946, 26947, 26957, 26956, 27046, 27047, 27057, 27056
8865, 26947, 26948, 26958, 26957, 27047, 27048, 27058, 27057
8866, 26948,  4804,  4805, 26958, 27048,  4814,  4815, 27058
8867,  4435, 26949, 26959,  4436,  4445, 27049, 27059,  4446
8868, 26949, 26950, 26960, 26959, 27049, 27050, 27060, 27059
8869, 26950, 26951, 26961, 26960, 27050, 27051, 27061, 27060
8870, 26951, 26952, 26962, 26961, 27051, 27052, 27062, 27061
8871, 26952, 26953, 26963, 26962, 27052, 27053, 27063, 27062
8872, 26953, 26954, 26964, 26963, 27053, 27054, 27064, 27063
8873, 26954, 26955, 26965, 26964, 27054, 27055, 27065, 27064
8874, 26955, 26956, 26966, 26965, 27055, 27056, 27066, 27065
8875, 26956, 26957, 26967, 26966, 27056, 27057, 27067, 27066
8876, 26957, 26958, 26968, 26967, 27057, 27058, 27068, 27067
8877, 26958,  4805,  4806, 26968, 27058,  4815,  4816, 27068
8878,  4436, 26959, 26969,  4437,  4446, 27059, 27069,  4447
8879, 26959, 26960, 26970, 26969, 27059, 27060, 27070, 27069
8880, 26960, 26961, 26971, 26970, 27060, 27061, 27071, 27070
8881, 26961, 26962, 26972, 26971, 27061, 27062, 27072, 27071
8882, 26962, 26963, 26973, 26972, 27062, 27063, 27073, 27072
8883, 26963, 26964, 26974, 26973, 27063, 27064, 27074, 27073
8884, 26964, 26965, 26975, 26974, 27064, 27065, 27075, 27074
8885, 26965, 26966, 26976, 26975, 27065, 27066, 27076, 27075
8886, 26966, 26967, 26977, 26976, 27066, 27067, 27077, 27076
8887, 26967, 26968, 26978, 26977, 27067, 27068, 27078, 27077
8888, 26968,  4806,  4807, 26978, 27068,  4816,  4817, 27078
8889,  4437, 26969, 26979,  4438,  4447, 27069, 27079,  4448
8890, 26969, 26970, 26980, 26979, 27069, 27070, 27080, 27079
8891, 26970, 26971, 26981, 26980, 27070, 27071, 27081, 27080
8892, 26971, 26972, 26982, 26981, 27071, 27072, 27082, 27081
8893, 26972, 26973, 26983, 26982, 27072, 27073, 27083, 27082
8894, 26973, 26974, 26984, 26983, 27073, 27074, 27084, 27083
8895, 26974, 26975, 26985, 26984, 27074, 27075, 27085, 27084
8896, 26975, 26976, 26986, 26985, 27075, 27076, 27086, 27085
8897, 26976, 26977, 26987, 26986, 27076, 27077, 27087, 27086
8898, 26977, 26978, 26988, 26987, 27077, 27078, 27088, 27087
8899, 26978,  4807,  4808, 26988, 27078,  4817,  4818, 27088
8900,  4438, 26979, 26989,  4439,  4448, 27079, 27089,  4449
8901, 26979, 26980, 26990, 26989, 27079, 27080, 27090, 27089
8902, 26980, 26981, 26991, 26990, 27080, 27081, 27091, 27090
8903, 26981, 26982, 26992, 26991, 27081, 27082, 27092, 27091
8904, 26982, 26983, 26993, 26992, 27082, 27083, 27093, 27092
8905, 26983, 26984, 26994, 26993, 27083, 27084, 27094, 27093
8906, 26984, 26985, 26995, 26994, 27084, 27085, 27095, 27094
8907, 26985, 26986, 26996, 26995, 27085, 27086, 27096, 27095
8908, 26986, 26987, 26997, 26996, 27086, 27087, 27097, 27096
8909, 26987, 26988, 26998, 26997, 27087, 27088, 27098, 27097
8910, 26988,  4808,  4809, 26998, 27088,  4818,  4819, 27098
8911,  4439, 26989, 26999,  4440,  4449, 27089, 27099,  4450
8912, 26989, 26990, 27000, 26999, 27089, 27090, 27100, 27099
8913, 26990, 26991, 27001, 27000, 27090, 27091, 27101, 27100
8914, 26991, 26992, 27002, 27001, 27091, 27092, 27102, 27101
8915, 26992, 26993, 27003, 27002, 27092, 27093, 27103, 27102
8916, 26993, 26994, 27004, 27003, 27093, 27094, 27104, 27103
8917, 26994, 26995, 27005, 27004, 27094, 27095, 27105, 27104
8918, 26995, 26996, 27006, 27005, 27095, 27096, 27106, 27105
8919, 26996, 26997, 27007, 27006, 27096, 27097, 27107, 27106
8920, 26997, 26998, 27008, 27007, 27097, 27098, 27108, 27107
8921, 26998,  4809,  4810, 27008, 27098,  4819,  4820, 27108
8922,  4440, 26999, 27009,  4441,  4450, 27099, 27109,  4451
8923, 26999, 27000, 27010, 27009, 27099, 27100, 27110, 27109
8924, 27000, 27001, 27011, 27010, 27100, 27101, 27111, 27110
8925, 27001, 27002, 27012, 27011, 27101, 27102, 27112, 27111
8926, 27002, 27003, 27013, 27012, 27102, 27103, 27113, 27112
8927, 27003, 27004, 27014, 27013, 27103, 27104, 27114, 27113
8928, 27004, 27005, 27015, 27014, 27104, 27105, 27115, 27114
8929, 27005, 27006, 27016, 27015, 27105, 27106, 27116, 27115
8930, 27006, 27007, 27017, 27016, 27106, 27107, 27117, 27116
8931, 27007, 27008, 27018, 27017, 27107, 27108, 27118, 27117
8932, 27008,  4810,  4811, 27018, 27108,  4820,  4821, 27118
8933,  4441, 27009, 27019,  4442,  4451, 27109, 27119,  4452
8934, 27009, 27010, 27020, 27019, 27109, 27110, 27120, 27119
8935, 27010, 27011, 27021, 27020, 27110, 27111, 27121, 27120
8936, 27011, 27012, 27022, 27021, 27111, 27112, 27122, 27121
8937, 27012, 27013, 27023, 27022, 27112, 27113, 27123, 27122
8938, 27013, 27014, 27024, 27023, 27113, 27114, 27124, 27123
8939, 27014, 27015, 27025, 27024, 27114, 27115, 27125, 27124
8940, 27015, 27016, 27026, 27025, 27115, 27116, 27126, 27125
8941, 27016, 27017, 27027, 27026, 27116, 27117, 27127, 27126
8942, 27017, 27018, 27028, 27027, 27117, 27118, 27128, 27127
8943, 27018,  4811,  4812, 27028, 27118,  4821,  4822, 27128
8944,  4442, 27019,  5508,   457,  4452, 27119,  5518,   456
8945, 27019, 27020,  5507,  5508, 27119, 27120,  5517,  5518
8946, 27020, 27021,  5506,  5507, 27120, 27121,  5516,  5517
8947, 27021, 27022,  5505,  5506, 27121, 27122,  5515,  5516
8948, 27022, 27023,  5504,  5505, 27122, 27123,  5514,  5515
8949, 27023, 27024,  5503,  5504, 27123, 27124,  5513,  5514
8950, 27024, 27025,  5502,  5503, 27124, 27125,  5512,  5513
8951, 27025, 27026,  5501,  5502, 27125, 27126,  5511,  5512
8952, 27026, 27027,  5500,  5501, 27126, 27127,  5510,  5511
8953, 27027, 27028,  5499,  5500, 27127, 27128,  5509,  5510
8954, 27028,  4812,   529,  5499, 27128,  4822,   530,  5509
8955,   495,  5183, 27029,  4443,   496,  5193, 27129,  4453
8956,  5183,  5184, 27030, 27029,  5193,  5194, 27130, 27129
8957,  5184,  5185, 27031, 27030,  5194,  5195, 27131, 27130
8958,  5185,  5186, 27032, 27031,  5195,  5196, 27132, 27131
8959,  5186,  5187, 27033, 27032,  5196,  5197, 27133, 27132
8960,  5187,  5188, 27034, 27033,  5197,  5198, 27134, 27133
8961,  5188,  5189, 27035, 27034,  5198,  5199, 27135, 27134
8962,  5189,  5190, 27036, 27035,  5199,  5200, 27136, 27135
8963,  5190,  5191, 27037, 27036,  5200,  5201, 27137, 27136
8964,  5191,  5192, 27038, 27037,  5201,  5202, 27138, 27137
8965,  5192,   533,  4813, 27038,  5202,   532,  4823, 27138
8966,  4443, 27029, 27039,  4444,  4453, 27129, 27139,  4454
8967, 27029, 27030, 27040, 27039, 27129, 27130, 27140, 27139
8968, 27030, 27031, 27041, 27040, 27130, 27131, 27141, 27140
8969, 27031, 27032, 27042, 27041, 27131, 27132, 27142, 27141
8970, 27032, 27033, 27043, 27042, 27132, 27133, 27143, 27142
8971, 27033, 27034, 27044, 27043, 27133, 27134, 27144, 27143
8972, 27034, 27035, 27045, 27044, 27134, 27135, 27145, 27144
8973, 27035, 27036, 27046, 27045, 27135, 27136, 27146, 27145
8974, 27036, 27037, 27047, 27046, 27136, 27137, 27147, 27146
8975, 27037, 27038, 27048, 27047, 27137, 27138, 27148, 27147
8976, 27038,  4813,  4814, 27048, 27138,  4823,  4824, 27148
8977,  4444, 27039, 27049,  4445,  4454, 27139, 27149,  4455
8978, 27039, 27040, 27050, 27049, 27139, 27140, 27150, 27149
8979, 27040, 27041, 27051, 27050, 27140, 27141, 27151, 27150
8980, 27041, 27042, 27052, 27051, 27141, 27142, 27152, 27151
8981, 27042, 27043, 27053, 27052, 27142, 27143, 27153, 27152
8982, 27043, 27044, 27054, 27053, 27143, 27144, 27154, 27153
8983, 27044, 27045, 27055, 27054, 27144, 27145, 27155, 27154
8984, 27045, 27046, 27056, 27055, 27145, 27146, 27156, 27155
8985, 27046, 27047, 27057, 27056, 27146, 27147, 27157, 27156
8986, 27047, 27048, 27058, 27057, 27147, 27148, 27158, 27157
8987, 27048,  4814,  4815, 27058, 27148,  4824,  4825, 27158
8988,  4445, 27049, 27059,  4446,  4455, 27149, 27159,  4456
8989, 27049, 27050, 27060, 27059, 27149, 27150, 27160, 27159
8990, 27050, 27051, 27061, 27060, 27150, 27151, 27161, 27160
8991, 27051, 27052, 27062, 27061, 27151, 27152, 27162, 27161
8992, 27052, 27053, 27063, 27062, 27152, 27153, 27163, 27162
8993, 27053, 27054, 27064, 27063, 27153, 27154, 27164, 27163
8994, 27054, 27055, 27065, 27064, 27154, 27155, 27165, 27164
8995, 27055, 27056, 27066, 27065, 27155, 27156, 27166, 27165
8996, 27056, 27057, 27067, 27066, 27156, 27157, 27167, 27166
8997, 27057, 27058, 27068, 27067, 27157, 27158, 27168, 27167
8998, 27058,  4815,  4816, 27068, 27158,  4825,  4826, 27168
8999,  4446, 27059, 27069,  4447,  4456, 27159, 27169,  4457
9000, 27059, 27060, 27070, 27069, 27159, 27160, 27170, 27169
9001, 27060, 27061, 27071, 27070, 27160, 27161, 27171, 27170
9002, 27061, 27062, 27072, 27071, 27161, 27162, 27172, 27171
9003, 27062, 27063, 27073, 27072, 27162, 27163, 27173, 27172
9004, 27063, 27064, 27074, 27073, 27163, 27164, 27174, 27173
9005, 27064, 27065, 27075, 27074, 27164, 27165, 27175, 27174
9006, 27065, 27066, 27076, 27075, 27165, 27166, 27176, 27175
9007, 27066, 27067, 27077, 27076, 27166, 27167, 27177, 27176
9008, 27067, 27068, 27078, 27077, 27167, 27168, 27178, 27177
9009, 27068,  4816,  4817, 27078, 27168,  4826,  4827, 27178
9010,  4447, 27069, 27079,  4448,  4457, 27169, 27179,  4458
9011, 27069, 27070, 27080, 27079, 27169, 27170, 27180, 27179
9012, 27070, 27071, 27081, 27080, 27170, 27171, 27181, 27180
9013, 27071, 27072, 27082, 27081, 27171, 27172, 27182, 27181
9014, 27072, 27073, 27083, 27082, 27172, 27173, 27183, 27182
9015, 27073, 27074, 27084, 27083, 27173, 27174, 27184, 27183
9016, 27074, 27075, 27085, 27084, 27174, 27175, 27185, 27184
9017, 27075, 27076, 27086, 27085, 27175, 27176, 27186, 27185
9018, 27076, 27077, 27087, 27086, 27176, 27177, 27187, 27186
9019, 27077, 27078, 27088, 27087, 27177, 27178, 27188, 27187
9020, 27078,  4817,  4818, 27088, 27178,  4827,  4828, 27188
9021,  4448, 27079, 27089,  4449,  4458, 27179, 27189,  4459
9022, 27079, 27080, 27090, 27089, 27179, 27180, 27190, 27189
9023, 27080, 27081, 27091, 27090, 27180, 27181, 27191, 27190
9024, 27081, 27082, 27092, 27091, 27181, 27182, 27192, 27191
9025, 27082, 27083, 27093, 27092, 27182, 27183, 27193, 27192
9026, 27083, 27084, 27094, 27093, 27183, 27184, 27194, 27193
9027, 27084, 27085, 27095, 27094, 27184, 27185, 27195, 27194
9028, 27085, 27086, 27096, 27095, 27185, 27186, 27196, 27195
9029, 27086, 27087, 27097, 27096, 27186, 27187, 27197, 27196
9030, 27087, 27088, 27098, 27097, 27187, 27188, 27198, 27197
9031, 27088,  4818,  4819, 27098, 27188,  4828,  4829, 27198
9032,  4449, 27089, 27099,  4450,  4459, 27189, 27199,  4460
9033, 27089, 27090, 27100, 27099, 27189, 27190, 27200, 27199
9034, 27090, 27091, 27101, 27100, 27190, 27191, 27201, 27200
9035, 27091, 27092, 27102, 27101, 27191, 27192, 27202, 27201
9036, 27092, 27093, 27103, 27102, 27192, 27193, 27203, 27202
9037, 27093, 27094, 27104, 27103, 27193, 27194, 27204, 27203
9038, 27094, 27095, 27105, 27104, 27194, 27195, 27205, 27204
9039, 27095, 27096, 27106, 27105, 27195, 27196, 27206, 27205
9040, 27096, 27097, 27107, 27106, 27196, 27197, 27207, 27206
9041, 27097, 27098, 27108, 27107, 27197, 27198, 27208, 27207
9042, 27098,  4819,  4820, 27108, 27198,  4829,  4830, 27208
9043,  4450, 27099, 27109,  4451,  4460, 27199, 27209,  4461
9044, 27099, 27100, 27110, 27109, 27199, 27200, 27210, 27209
9045, 27100, 27101, 27111, 27110, 27200, 27201, 27211, 27210
9046, 27101, 27102, 27112, 27111, 27201, 27202, 27212, 27211
9047, 27102, 27103, 27113, 27112, 27202, 27203, 27213, 27212
9048, 27103, 27104, 27114, 27113, 27203, 27204, 27214, 27213
9049, 27104, 27105, 27115, 27114, 27204, 27205, 27215, 27214
9050, 27105, 27106, 27116, 27115, 27205, 27206, 27216, 27215
9051, 27106, 27107, 27117, 27116, 27206, 27207, 27217, 27216
9052, 27107, 27108, 27118, 27117, 27207, 27208, 27218, 27217
9053, 27108,  4820,  4821, 27118, 27208,  4830,  4831, 27218
9054,  4451, 27109, 27119,  4452,  4461, 27209, 27219,  4462
9055, 27109, 27110, 27120, 27119, 27209, 27210, 27220, 27219
9056, 27110, 27111, 27121, 27120, 27210, 27211, 27221, 27220
9057, 27111, 27112, 27122, 27121, 27211, 27212, 27222, 27221
9058, 27112, 27113, 27123, 27122, 27212, 27213, 27223, 27222
9059, 27113, 27114, 27124, 27123, 27213, 27214, 27224, 27223
9060, 27114, 27115, 27125, 27124, 27214, 27215, 27225, 27224
9061, 27115, 27116, 27126, 27125, 27215, 27216, 27226, 27225
9062, 27116, 27117, 27127, 27126, 27216, 27217, 27227, 27226
9063, 27117, 27118, 27128, 27127, 27217, 27218, 27228, 27227
9064, 27118,  4821,  4822, 27128, 27218,  4831,  4832, 27228
9065,  4452, 27119,  5518,   456,  4462, 27219,  5528,   455
9066, 27119, 27120,  5517,  5518, 27219, 27220,  5527,  5528
9067, 27120, 27121,  5516,  5517, 27220, 27221,  5526,  5527
9068, 27121, 27122,  5515,  5516, 27221, 27222,  5525,  5526
9069, 27122, 27123,  5514,  5515, 27222, 27223,  5524,  5525
9070, 27123, 27124,  5513,  5514, 27223, 27224,  5523,  5524
9071, 27124, 27125,  5512,  5513, 27224, 27225,  5522,  5523
9072, 27125, 27126,  5511,  5512, 27225, 27226,  5521,  5522
9073, 27126, 27127,  5510,  5511, 27226, 27227,  5520,  5521
9074, 27127, 27128,  5509,  5510, 27227, 27228,  5519,  5520
9075, 27128,  4822,   530,  5509, 27228,  4832,   531,  5519
9076,   496,  5193, 27129,  4453,    19,   385,  3993,   424
9077,  5193,  5194, 27130, 27129,   385,   386,  3994,  3993
9078,  5194,  5195, 27131, 27130,   386,   387,  3995,  3994
9079,  5195,  5196, 27132, 27131,   387,   388,  3996,  3995
9080,  5196,  5197, 27133, 27132,   388,   389,  3997,  3996
9081,  5197,  5198, 27134, 27133,   389,   390,  3998,  3997
9082,  5198,  5199, 27135, 27134,   390,   391,  3999,  3998
9083,  5199,  5200, 27136, 27135,   391,   392,  4000,  3999
9084,  5200,  5201, 27137, 27136,   392,   393,  4001,  4000
9085,  5201,  5202, 27138, 27137,   393,   394,  4002,  4001
9086,  5202,   532,  4823, 27138,   394,    20,   395,  4002
9087,  4453, 27129, 27139,  4454,   424,  3993,  4003,   423
9088, 27129, 27130, 27140, 27139,  3993,  3994,  4004,  4003
9089, 27130, 27131, 27141, 27140,  3994,  3995,  4005,  4004
9090, 27131, 27132, 27142, 27141,  3995,  3996,  4006,  4005
9091, 27132, 27133, 27143, 27142,  3996,  3997,  4007,  4006
9092, 27133, 27134, 27144, 27143,  3997,  3998,  4008,  4007
9093, 27134, 27135, 27145, 27144,  3998,  3999,  4009,  4008
9094, 27135, 27136, 27146, 27145,  3999,  4000,  4010,  4009
9095, 27136, 27137, 27147, 27146,  4000,  4001,  4011,  4010
9096, 27137, 27138, 27148, 27147,  4001,  4002,  4012,  4011
9097, 27138,  4823,  4824, 27148,  4002,   395,   396,  4012
9098,  4454, 27139, 27149,  4455,   423,  4003,  4013,   422
9099, 27139, 27140, 27150, 27149,  4003,  4004,  4014,  4013
9100, 27140, 27141, 27151, 27150,  4004,  4005,  4015,  4014
9101, 27141, 27142, 27152, 27151,  4005,  4006,  4016,  4015
9102, 27142, 27143, 27153, 27152,  4006,  4007,  4017,  4016
9103, 27143, 27144, 27154, 27153,  4007,  4008,  4018,  4017
9104, 27144, 27145, 27155, 27154,  4008,  4009,  4019,  4018
9105, 27145, 27146, 27156, 27155,  4009,  4010,  4020,  4019
9106, 27146, 27147, 27157, 27156,  4010,  4011,  4021,  4020
9107, 27147, 27148, 27158, 27157,  4011,  4012,  4022,  4021
9108, 27148,  4824,  4825, 27158,  4012,   396,   397,  4022
9109,  4455, 27149, 27159,  4456,   422,  4013,  4023,   421
9110, 27149, 27150, 27160, 27159,  4013,  4014,  4024,  4023
9111, 27150, 27151, 27161, 27160,  4014,  4015,  4025,  4024
9112, 27151, 27152, 27162, 27161,  4015,  4016,  4026,  4025
9113, 27152, 27153, 27163, 27162,  4016,  4017,  4027,  4026
9114, 27153, 27154, 27164, 27163,  4017,  4018,  4028,  4027
9115, 27154, 27155, 27165, 27164,  4018,  4019,  4029,  4028
9116, 27155, 27156, 27166, 27165,  4019,  4020,  4030,  4029
9117, 27156, 27157, 27167, 27166,  4020,  4021,  4031,  4030
9118, 27157, 27158, 27168, 27167,  4021,  4022,  4032,  4031
9119, 27158,  4825,  4826, 27168,  4022,   397,   398,  4032
9120,  4456, 27159, 27169,  4457,   421,  4023,  4033,   420
9121, 27159, 27160, 27170, 27169,  4023,  4024,  4034,  4033
9122, 27160, 27161, 27171, 27170,  4024,  4025,  4035,  4034
9123, 27161, 27162, 27172, 27171,  4025,  4026,  4036,  4035
9124, 27162, 27163, 27173, 27172,  4026,  4027,  4037,  4036
9125, 27163, 27164, 27174, 27173,  4027,  4028,  4038,  4037
9126, 27164, 27165, 27175, 27174,  4028,  4029,  4039,  4038
9127, 27165, 27166, 27176, 27175,  4029,  4030,  4040,  4039
9128, 27166, 27167, 27177, 27176,  4030,  4031,  4041,  4040
9129, 27167, 27168, 27178, 27177,  4031,  4032,  4042,  4041
9130, 27168,  4826,  4827, 27178,  4032,   398,   399,  4042
9131,  4457, 27169, 27179,  4458,   420,  4033,  4043,   419
9132, 27169, 27170, 27180, 27179,  4033,  4034,  4044,  4043
9133, 27170, 27171, 27181, 27180,  4034,  4035,  4045,  4044
9134, 27171, 27172, 27182, 27181,  4035,  4036,  4046,  4045
9135, 27172, 27173, 27183, 27182,  4036,  4037,  4047,  4046
9136, 27173, 27174, 27184, 27183,  4037,  4038,  4048,  4047
9137, 27174, 27175, 27185, 27184,  4038,  4039,  4049,  4048
9138, 27175, 27176, 27186, 27185,  4039,  4040,  4050,  4049
9139, 27176, 27177, 27187, 27186,  4040,  4041,  4051,  4050
9140, 27177, 27178, 27188, 27187,  4041,  4042,  4052,  4051
9141, 27178,  4827,  4828, 27188,  4042,   399,   400,  4052
9142,  4458, 27179, 27189,  4459,   419,  4043,  4053,   418
9143, 27179, 27180, 27190, 27189,  4043,  4044,  4054,  4053
9144, 27180, 27181, 27191, 27190,  4044,  4045,  4055,  4054
9145, 27181, 27182, 27192, 27191,  4045,  4046,  4056,  4055
9146, 27182, 27183, 27193, 27192,  4046,  4047,  4057,  4056
9147, 27183, 27184, 27194, 27193,  4047,  4048,  4058,  4057
9148, 27184, 27185, 27195, 27194,  4048,  4049,  4059,  4058
9149, 27185, 27186, 27196, 27195,  4049,  4050,  4060,  4059
9150, 27186, 27187, 27197, 27196,  4050,  4051,  4061,  4060
9151, 27187, 27188, 27198, 27197,  4051,  4052,  4062,  4061
9152, 27188,  4828,  4829, 27198,  4052,   400,   401,  4062
9153,  4459, 27189, 27199,  4460,   418,  4053,  4063,   417
9154, 27189, 27190, 27200, 27199,  4053,  4054,  4064,  4063
9155, 27190, 27191, 27201, 27200,  4054,  4055,  4065,  4064
9156, 27191, 27192, 27202, 27201,  4055,  4056,  4066,  4065
9157, 27192, 27193, 27203, 27202,  4056,  4057,  4067,  4066
9158, 27193, 27194, 27204, 27203,  4057,  4058,  4068,  4067
9159, 27194, 27195, 27205, 27204,  4058,  4059,  4069,  4068
9160, 27195, 27196, 27206, 27205,  4059,  4060,  4070,  4069
9161, 27196, 27197, 27207, 27206,  4060,  4061,  4071,  4070
9162, 27197, 27198, 27208, 27207,  4061,  4062,  4072,  4071
9163, 27198,  4829,  4830, 27208,  4062,   401,   402,  4072
9164,  4460, 27199, 27209,  4461,   417,  4063,  4073,   416
9165, 27199, 27200, 27210, 27209,  4063,  4064,  4074,  4073
9166, 27200, 27201, 27211, 27210,  4064,  4065,  4075,  4074
9167, 27201, 27202, 27212, 27211,  4065,  4066,  4076,  4075
9168, 27202, 27203, 27213, 27212,  4066,  4067,  4077,  4076
9169, 27203, 27204, 27214, 27213,  4067,  4068,  4078,  4077
9170, 27204, 27205, 27215, 27214,  4068,  4069,  4079,  4078
9171, 27205, 27206, 27216, 27215,  4069,  4070,  4080,  4079
9172, 27206, 27207, 27217, 27216,  4070,  4071,  4081,  4080
9173, 27207, 27208, 27218, 27217,  4071,  4072,  4082,  4081
9174, 27208,  4830,  4831, 27218,  4072,   402,   403,  4082
9175,  4461, 27209, 27219,  4462,   416,  4073,  4083,   415
9176, 27209, 27210, 27220, 27219,  4073,  4074,  4084,  4083
9177, 27210, 27211, 27221, 27220,  4074,  4075,  4085,  4084
9178, 27211, 27212, 27222, 27221,  4075,  4076,  4086,  4085
9179, 27212, 27213, 27223, 27222,  4076,  4077,  4087,  4086
9180, 27213, 27214, 27224, 27223,  4077,  4078,  4088,  4087
9181, 27214, 27215, 27225, 27224,  4078,  4079,  4089,  4088
9182, 27215, 27216, 27226, 27225,  4079,  4080,  4090,  4089
9183, 27216, 27217, 27227, 27226,  4080,  4081,  4091,  4090
9184, 27217, 27218, 27228, 27227,  4081,  4082,  4092,  4091
9185, 27218,  4831,  4832, 27228,  4082,   403,   404,  4092
9186,  4462, 27219,  5528,   455,   415,  4083,   414,    22
9187, 27219, 27220,  5527,  5528,  4083,  4084,   413,   414
9188, 27220, 27221,  5526,  5527,  4084,  4085,   412,   413
9189, 27221, 27222,  5525,  5526,  4085,  4086,   411,   412
9190, 27222, 27223,  5524,  5525,  4086,  4087,   410,   411
9191, 27223, 27224,  5523,  5524,  4087,  4088,   409,   410
9192, 27224, 27225,  5522,  5523,  4088,  4089,   408,   409
9193, 27225, 27226,  5521,  5522,  4089,  4090,   407,   408
9194, 27226, 27227,  5520,  5521,  4090,  4091,   406,   407
9195, 27227, 27228,  5519,  5520,  4091,  4092,   405,   406
9196, 27228,  4832,   531,  5519,  4092,   404,    21,   405
 9197,    10,   205,  3793,   305,   708,  7469, 27229,  5529
 9198,   205,   204,  3794,  3793,  7469,  7470, 27230, 27229
 9199,   204,   203,  3795,  3794,  7470,  7471, 27231, 27230
 9200,   203,   202,  3796,  3795,  7471,  7472, 27232, 27231
 9201,   202,   201,  3797,  3796,  7472,  7473, 27233, 27232
 9202,   201,   200,  3798,  3797,  7473,  7474, 27234, 27233
 9203,   200,   199,  3799,  3798,  7474,  7475, 27235, 27234
 9204,   199,   198,  3800,  3799,  7475,  7476, 27236, 27235
 9205,   198,   197,  3801,  3800,  7476,  7477, 27237, 27236
 9206,   197,   196,  3802,  3801,  7477,  7478, 27238, 27237
 9207,   196,     9,   334,  3802,  7478,   948,  6499, 27238
 9208,   305,  3793,  3803,   306,  5529, 27229, 27239,  5530
 9209,  3793,  3794,  3804,  3803, 27229, 27230, 27240, 27239
 9210,  3794,  3795,  3805,  3804, 27230, 27231, 27241, 27240
 9211,  3795,  3796,  3806,  3805, 27231, 27232, 27242, 27241
 9212,  3796,  3797,  3807,  3806, 27232, 27233, 27243, 27242
 9213,  3797,  3798,  3808,  3807, 27233, 27234, 27244, 27243
 9214,  3798,  3799,  3809,  3808, 27234, 27235, 27245, 27244
 9215,  3799,  3800,  3810,  3809, 27235, 27236, 27246, 27245
 9216,  3800,  3801,  3811,  3810, 27236, 27237, 27247, 27246
 9217,  3801,  3802,  3812,  3811, 27237, 27238, 27248, 27247
 9218,  3802,   334,   333,  3812, 27238,  6499,  6500, 27248
 9219,   306,  3803,  3813,   307,  5530, 27239, 27249,  5531
 9220,  3803,  3804,  3814,  3813, 27239, 27240, 27250, 27249
 9221,  3804,  3805,  3815,  3814, 27240, 27241, 27251, 27250
 9222,  3805,  3806,  3816,  3815, 27241, 27242, 27252, 27251
 9223,  3806,  3807,  3817,  3816, 27242, 27243, 27253, 27252
 9224,  3807,  3808,  3818,  3817, 27243, 27244, 27254, 27253
 9225,  3808,  3809,  3819,  3818, 27244, 27245, 27255, 27254
 9226,  3809,  3810,  3820,  3819, 27245, 27246, 27256, 27255
 9227,  3810,  3811,  3821,  3820, 27246, 27247, 27257, 27256
 9228,  3811,  3812,  3822,  3821, 27247, 27248, 27258, 27257
 9229,  3812,   333,   332,  3822, 27248,  6500,  6501, 27258
 9230,   307,  3813,  3823,   308,  5531, 27249, 27259,  5532
 9231,  3813,  3814,  3824,  3823, 27249, 27250, 27260, 27259
 9232,  3814,  3815,  3825,  3824, 27250, 27251, 27261, 27260
 9233,  3815,  3816,  3826,  3825, 27251, 27252, 27262, 27261
 9234,  3816,  3817,  3827,  3826, 27252, 27253, 27263, 27262
 9235,  3817,  3818,  3828,  3827, 27253, 27254, 27264, 27263
 9236,  3818,  3819,  3829,  3828, 27254, 27255, 27265, 27264
 9237,  3819,  3820,  3830,  3829, 27255, 27256, 27266, 27265
 9238,  3820,  3821,  3831,  3830, 27256, 27257, 27267, 27266
 9239,  3821,  3822,  3832,  3831, 27257, 27258, 27268, 27267
 9240,  3822,   332,   331,  3832, 27258,  6501,  6502, 27268
 9241,   308,  3823,  3833,   309,  5532, 27259, 27269,  5533
 9242,  3823,  3824,  3834,  3833, 27259, 27260, 27270, 27269
 9243,  3824,  3825,  3835,  3834, 27260, 27261, 27271, 27270
 9244,  3825,  3826,  3836,  3835, 27261, 27262, 27272, 27271
 9245,  3826,  3827,  3837,  3836, 27262, 27263, 27273, 27272
 9246,  3827,  3828,  3838,  3837, 27263, 27264, 27274, 27273
 9247,  3828,  3829,  3839,  3838, 27264, 27265, 27275, 27274
 9248,  3829,  3830,  3840,  3839, 27265, 27266, 27276, 27275
 9249,  3830,  3831,  3841,  3840, 27266, 27267, 27277, 27276
 9250,  3831,  3832,  3842,  3841, 27267, 27268, 27278, 27277
 9251,  3832,   331,   330,  3842, 27268,  6502,  6503, 27278
 9252,   309,  3833,  3843,   310,  5533, 27269, 27279,  5534
 9253,  3833,  3834,  3844,  3843, 27269, 27270, 27280, 27279
 9254,  3834,  3835,  3845,  3844, 27270, 27271, 27281, 27280
 9255,  3835,  3836,  3846,  3845, 27271, 27272, 27282, 27281
 9256,  3836,  3837,  3847,  3846, 27272, 27273, 27283, 27282
 9257,  3837,  3838,  3848,  3847, 27273, 27274, 27284, 27283
 9258,  3838,  3839,  3849,  3848, 27274, 27275, 27285, 27284
 9259,  3839,  3840,  3850,  3849, 27275, 27276, 27286, 27285
 9260,  3840,  3841,  3851,  3850, 27276, 27277, 27287, 27286
 9261,  3841,  3842,  3852,  3851, 27277, 27278, 27288, 27287
 9262,  3842,   330,   329,  3852, 27278,  6503,  6504, 27288
 9263,   310,  3843,  3853,   311,  5534, 27279, 27289,  5535
 9264,  3843,  3844,  3854,  3853, 27279, 27280, 27290, 27289
 9265,  3844,  3845,  3855,  3854, 27280, 27281, 27291, 27290
 9266,  3845,  3846,  3856,  3855, 27281, 27282, 27292, 27291
 9267,  3846,  3847,  3857,  3856, 27282, 27283, 27293, 27292
 9268,  3847,  3848,  3858,  3857, 27283, 27284, 27294, 27293
 9269,  3848,  3849,  3859,  3858, 27284, 27285, 27295, 27294
 9270,  3849,  3850,  3860,  3859, 27285, 27286, 27296, 27295
 9271,  3850,  3851,  3861,  3860, 27286, 27287, 27297, 27296
 9272,  3851,  3852,  3862,  3861, 27287, 27288, 27298, 27297
 9273,  3852,   329,   328,  3862, 27288,  6504,  6505, 27298
 9274,   311,  3853,  3863,   312,  5535, 27289, 27299,  5536
 9275,  3853,  3854,  3864,  3863, 27289, 27290, 27300, 27299
 9276,  3854,  3855,  3865,  3864, 27290, 27291, 27301, 27300
 9277,  3855,  3856,  3866,  3865, 27291, 27292, 27302, 27301
 9278,  3856,  3857,  3867,  3866, 27292, 27293, 27303, 27302
 9279,  3857,  3858,  3868,  3867, 27293, 27294, 27304, 27303
 9280,  3858,  3859,  3869,  3868, 27294, 27295, 27305, 27304
 9281,  3859,  3860,  3870,  3869, 27295, 27296, 27306, 27305
 9282,  3860,  3861,  3871,  3870, 27296, 27297, 27307, 27306
 9283,  3861,  3862,  3872,  3871, 27297, 27298, 27308, 27307
 9284,  3862,   328,   327,  3872, 27298,  6505,  6506, 27308
 9285,   312,  3863,  3873,   313,  5536, 27299, 27309,  5537
 9286,  3863,  3864,  3874,  3873, 27299, 27300, 27310, 27309
 9287,  3864,  3865,  3875,  3874, 27300, 27301, 27311, 27310
 9288,  3865,  3866,  3876,  3875, 27301, 27302, 27312, 27311
 9289,  3866,  3867,  3877,  3876, 27302, 27303, 27313, 27312
 9290,  3867,  3868,  3878,  3877, 27303, 27304, 27314, 27313
 9291,  3868,  3869,  3879,  3878, 27304, 27305, 27315, 27314
 9292,  3869,  3870,  3880,  3879, 27305, 27306, 27316, 27315
 9293,  3870,  3871,  3881,  3880, 27306, 27307, 27317, 27316
 9294,  3871,  3872,  3882,  3881, 27307, 27308, 27318, 27317
 9295,  3872,   327,   326,  3882, 27308,  6506,  6507, 27318
 9296,   313,  3873,  3883,   314,  5537, 27309, 27319,  5538
 9297,  3873,  3874,  3884,  3883, 27309, 27310, 27320, 27319
 9298,  3874,  3875,  3885,  3884, 27310, 27311, 27321, 27320
 9299,  3875,  3876,  3886,  3885, 27311, 27312, 27322, 27321
 9300,  3876,  3877,  3887,  3886, 27312, 27313, 27323, 27322
 9301,  3877,  3878,  3888,  3887, 27313, 27314, 27324, 27323
 9302,  3878,  3879,  3889,  3888, 27314, 27315, 27325, 27324
 9303,  3879,  3880,  3890,  3889, 27315, 27316, 27326, 27325
 9304,  3880,  3881,  3891,  3890, 27316, 27317, 27327, 27326
 9305,  3881,  3882,  3892,  3891, 27317, 27318, 27328, 27327
 9306,  3882,   326,   325,  3892, 27318,  6507,  6508, 27328
 9307,   314,  3883,   258,    13,  5538, 27319,  8429,   707
 9308,  3883,  3884,   259,   258, 27319, 27320,  8430,  8429
 9309,  3884,  3885,   260,   259, 27320, 27321,  8431,  8430
 9310,  3885,  3886,   261,   260, 27321, 27322,  8432,  8431
 9311,  3886,  3887,   262,   261, 27322, 27323,  8433,  8432
 9312,  3887,  3888,   263,   262, 27323, 27324,  8434,  8433
 9313,  3888,  3889,   264,   263, 27324, 27325,  8435,  8434
 9314,  3889,  3890,   265,   264, 27325, 27326,  8436,  8435
 9315,  3890,  3891,   266,   265, 27326, 27327,  8437,  8436
 9316,  3891,  3892,   267,   266, 27327, 27328,  8438,  8437
 9317,  3892,   325,    12,   267, 27328,  6508,   804,  8438
 9318,   708,  7469, 27229,  5529,   709,  7479, 27329,  5539
 9319,  7469,  7470, 27230, 27229,  7479,  7480, 27330, 27329
 9320,  7470,  7471, 27231, 27230,  7480,  7481, 27331, 27330
 9321,  7471,  7472, 27232, 27231,  7481,  7482, 27332, 27331
 9322,  7472,  7473, 27233, 27232,  7482,  7483, 27333, 27332
 9323,  7473,  7474, 27234, 27233,  7483,  7484, 27334, 27333
 9324,  7474,  7475, 27235, 27234,  7484,  7485, 27335, 27334
 9325,  7475,  7476, 27236, 27235,  7485,  7486, 27336, 27335
 9326,  7476,  7477, 27237, 27236,  7486,  7487, 27337, 27336
 9327,  7477,  7478, 27238, 27237,  7487,  7488, 27338, 27337
 9328,  7478,   948,  6499, 27238,  7488,   947,  6509, 27338
 9329,  5529, 27229, 27239,  5530,  5539, 27329, 27339,  5540
 9330, 27229, 27230, 27240, 27239, 27329, 27330, 27340, 27339
 9331, 27230, 27231, 27241, 27240, 27330, 27331, 27341, 27340
 9332, 27231, 27232, 27242, 27241, 27331, 27332, 27342, 27341
 9333, 27232, 27233, 27243, 27242, 27332, 27333, 27343, 27342
 9334, 27233, 27234, 27244, 27243, 27333, 27334, 27344, 27343
 9335, 27234, 27235, 27245, 27244, 27334, 27335, 27345, 27344
 9336, 27235, 27236, 27246, 27245, 27335, 27336, 27346, 27345
 9337, 27236, 27237, 27247, 27246, 27336, 27337, 27347, 27346
 9338, 27237, 27238, 27248, 27247, 27337, 27338, 27348, 27347
 9339, 27238,  6499,  6500, 27248, 27338,  6509,  6510, 27348
 9340,  5530, 27239, 27249,  5531,  5540, 27339, 27349,  5541
 9341, 27239, 27240, 27250, 27249, 27339, 27340, 27350, 27349
 9342, 27240, 27241, 27251, 27250, 27340, 27341, 27351, 27350
 9343, 27241, 27242, 27252, 27251, 27341, 27342, 27352, 27351
 9344, 27242, 27243, 27253, 27252, 27342, 27343, 27353, 27352
 9345, 27243, 27244, 27254, 27253, 27343, 27344, 27354, 27353
 9346, 27244, 27245, 27255, 27254, 27344, 27345, 27355, 27354
 9347, 27245, 27246, 27256, 27255, 27345, 27346, 27356, 27355
 9348, 27246, 27247, 27257, 27256, 27346, 27347, 27357, 27356
 9349, 27247, 27248, 27258, 27257, 27347, 27348, 27358, 27357
 9350, 27248,  6500,  6501, 27258, 27348,  6510,  6511, 27358
 9351,  5531, 27249, 27259,  5532,  5541, 27349, 27359,  5542
 9352, 27249, 27250, 27260, 27259, 27349, 27350, 27360, 27359
 9353, 27250, 27251, 27261, 27260, 27350, 27351, 27361, 27360
 9354, 27251, 27252, 27262, 27261, 27351, 27352, 27362, 27361
 9355, 27252, 27253, 27263, 27262, 27352, 27353, 27363, 27362
 9356, 27253, 27254, 27264, 27263, 27353, 27354, 27364, 27363
 9357, 27254, 27255, 27265, 27264, 27354, 27355, 27365, 27364
 9358, 27255, 27256, 27266, 27265, 27355, 27356, 27366, 27365
 9359, 27256, 27257, 27267, 27266, 27356, 27357, 27367, 27366
 9360, 27257, 27258, 27268, 27267, 27357, 27358, 27368, 27367
 9361, 27258,  6501,  6502, 27268, 27358,  6511,  6512, 27368
 9362,  5532, 27259, 27269,  5533,  5542, 27359, 27369,  5543
 9363, 27259, 27260, 27270, 27269, 27359, 27360, 27370, 27369
 9364, 27260, 27261, 27271, 27270, 27360, 27361, 27371, 27370
 9365, 27261, 27262, 27272, 27271, 27361, 27362, 27372, 27371
 9366, 27262, 27263, 27273, 27272, 27362, 27363, 27373, 27372
 9367, 27263, 27264, 27274, 27273, 27363, 27364, 27374, 27373
 9368, 27264, 27265, 27275, 27274, 27364, 27365, 27375, 27374
 9369, 27265, 27266, 27276, 27275, 27365, 27366, 27376, 27375
 9370, 27266, 27267, 27277, 27276, 27366, 27367, 27377, 27376
 9371, 27267, 27268, 27278, 27277, 27367, 27368, 27378, 27377
 9372, 27268,  6502,  6503, 27278, 27368,  6512,  6513, 27378
 9373,  5533, 27269, 27279,  5534,  5543, 27369, 27379,  5544
 9374, 27269, 27270, 27280, 27279, 27369, 27370, 27380, 27379
 9375, 27270, 27271, 27281, 27280, 27370, 27371, 27381, 27380
 9376, 27271, 27272, 27282, 27281, 27371, 27372, 27382, 27381
 9377, 27272, 27273, 27283, 27282, 27372, 27373, 27383, 27382
 9378, 27273, 27274, 27284, 27283, 27373, 27374, 27384, 27383
 9379, 27274, 27275, 27285, 27284, 27374, 27375, 27385, 27384
 9380, 27275, 27276, 27286, 27285, 27375, 27376, 27386, 27385
 9381, 27276, 27277, 27287, 27286, 27376, 27377, 27387, 27386
 9382, 27277, 27278, 27288, 27287, 27377, 27378, 27388, 27387
 9383, 27278,  6503,  6504, 27288, 27378,  6513,  6514, 27388
 9384,  5534, 27279, 27289,  5535,  5544, 27379, 27389,  5545
 9385, 27279, 27280, 27290, 27289, 27379, 27380, 27390, 27389
 9386, 27280, 27281, 27291, 27290, 27380, 27381, 27391, 27390
 9387, 27281, 27282, 27292, 27291, 27381, 27382, 27392, 27391
 9388, 27282, 27283, 27293, 27292, 27382, 27383, 27393, 27392
 9389, 27283, 27284, 27294, 27293, 27383, 27384, 27394, 27393
 9390, 27284, 27285, 27295, 27294, 27384, 27385, 27395, 27394
 9391, 27285, 27286, 27296, 27295, 27385, 27386, 27396, 27395
 9392, 27286, 27287, 27297, 27296, 27386, 27387, 27397, 27396
 9393, 27287, 27288, 27298, 27297, 27387, 27388, 27398, 27397
 9394, 27288,  6504,  6505, 27298, 27388,  6514,  6515, 27398
 9395,  5535, 27289, 27299,  5536,  5545, 27389, 27399,  5546
 9396, 27289, 27290, 27300, 27299, 27389, 27390, 27400, 27399
 9397, 27290, 27291, 27301, 27300, 27390, 27391, 27401, 27400
 9398, 27291, 27292, 27302, 27301, 27391, 27392, 27402, 27401
 9399, 27292, 27293, 27303, 27302, 27392, 27393, 27403, 27402
 9400, 27293, 27294, 27304, 27303, 27393, 27394, 27404, 27403
 9401, 27294, 27295, 27305, 27304, 27394, 27395, 27405, 27404
 9402, 27295, 27296, 27306, 27305, 27395, 27396, 27406, 27405
 9403, 27296, 27297, 27307, 27306, 27396, 27397, 27407, 27406
 9404, 27297, 27298, 27308, 27307, 27397, 27398, 27408, 27407
 9405, 27298,  6505,  6506, 27308, 27398,  6515,  6516, 27408
 9406,  5536, 27299, 27309,  5537,  5546, 27399, 27409,  5547
 9407, 27299, 27300, 27310, 27309, 27399, 27400, 27410, 27409
 9408, 27300, 27301, 27311, 27310, 27400, 27401, 27411, 27410
 9409, 27301, 27302, 27312, 27311, 27401, 27402, 27412, 27411
 9410, 27302, 27303, 27313, 27312, 27402, 27403, 27413, 27412
 9411, 27303, 27304, 27314, 27313, 27403, 27404, 27414, 27413
 9412, 27304, 27305, 27315, 27314, 27404, 27405, 27415, 27414
 9413, 27305, 27306, 27316, 27315, 27405, 27406, 27416, 27415
 9414, 27306, 27307, 27317, 27316, 27406, 27407, 27417, 27416
 9415, 27307, 27308, 27318, 27317, 27407, 27408, 27418, 27417
 9416, 27308,  6506,  6507, 27318, 27408,  6516,  6517, 27418
 9417,  5537, 27309, 27319,  5538,  5547, 27409, 27419,  5548
 9418, 27309, 27310, 27320, 27319, 27409, 27410, 27420, 27419
 9419, 27310, 27311, 27321, 27320, 27410, 27411, 27421, 27420
 9420, 27311, 27312, 27322, 27321, 27411, 27412, 27422, 27421
 9421, 27312, 27313, 27323, 27322, 27412, 27413, 27423, 27422
 9422, 27313, 27314, 27324, 27323, 27413, 27414, 27424, 27423
 9423, 27314, 27315, 27325, 27324, 27414, 27415, 27425, 27424
 9424, 27315, 27316, 27326, 27325, 27415, 27416, 27426, 27425
 9425, 27316, 27317, 27327, 27326, 27416, 27417, 27427, 27426
 9426, 27317, 27318, 27328, 27327, 27417, 27418, 27428, 27427
 9427, 27318,  6507,  6508, 27328, 27418,  6517,  6518, 27428
 9428,  5538, 27319,  8429,   707,  5548, 27419,  8439,   706
 9429, 27319, 27320,  8430,  8429, 27419, 27420,  8440,  8439
 9430, 27320, 27321,  8431,  8430, 27420, 27421,  8441,  8440
 9431, 27321, 27322,  8432,  8431, 27421, 27422,  8442,  8441
 9432, 27322, 27323,  8433,  8432, 27422, 27423,  8443,  8442
 9433, 27323, 27324,  8434,  8433, 27423, 27424,  8444,  8443
 9434, 27324, 27325,  8435,  8434, 27424, 27425,  8445,  8444
 9435, 27325, 27326,  8436,  8435, 27425, 27426,  8446,  8445
 9436, 27326, 27327,  8437,  8436, 27426, 27427,  8447,  8446
 9437, 27327, 27328,  8438,  8437, 27427, 27428,  8448,  8447
 9438, 27328,  6508,   804,  8438, 27428,  6518,   805,  8448
 9439,   709,  7479, 27329,  5539,   710,  7489, 27429,  5549
 9440,  7479,  7480, 27330, 27329,  7489,  7490, 27430, 27429
 9441,  7480,  7481, 27331, 27330,  7490,  7491, 27431, 27430
 9442,  7481,  7482, 27332, 27331,  7491,  7492, 27432, 27431
 9443,  7482,  7483, 27333, 27332,  7492,  7493, 27433, 27432
 9444,  7483,  7484, 27334, 27333,  7493,  7494, 27434, 27433
 9445,  7484,  7485, 27335, 27334,  7494,  7495, 27435, 27434
 9446,  7485,  7486, 27336, 27335,  7495,  7496, 27436, 27435
 9447,  7486,  7487, 27337, 27336,  7496,  7497, 27437, 27436
 9448,  7487,  7488, 27338, 27337,  7497,  7498, 27438, 27437
 9449,  7488,   947,  6509, 27338,  7498,   946,  6519, 27438
 9450,  5539, 27329, 27339,  5540,  5549, 27429, 27439,  5550
 9451, 27329, 27330, 27340, 27339, 27429, 27430, 27440, 27439
 9452, 27330, 27331, 27341, 27340, 27430, 27431, 27441, 27440
 9453, 27331, 27332, 27342, 27341, 27431, 27432, 27442, 27441
 9454, 27332, 27333, 27343, 27342, 27432, 27433, 27443, 27442
 9455, 27333, 27334, 27344, 27343, 27433, 27434, 27444, 27443
 9456, 27334, 27335, 27345, 27344, 27434, 27435, 27445, 27444
 9457, 27335, 27336, 27346, 27345, 27435, 27436, 27446, 27445
 9458, 27336, 27337, 27347, 27346, 27436, 27437, 27447, 27446
 9459, 27337, 27338, 27348, 27347, 27437, 27438, 27448, 27447
 9460, 27338,  6509,  6510, 27348, 27438,  6519,  6520, 27448
 9461,  5540, 27339, 27349,  5541,  5550, 27439, 27449,  5551
 9462, 27339, 27340, 27350, 27349, 27439, 27440, 27450, 27449
 9463, 27340, 27341, 27351, 27350, 27440, 27441, 27451, 27450
 9464, 27341, 27342, 27352, 27351, 27441, 27442, 27452, 27451
 9465, 27342, 27343, 27353, 27352, 27442, 27443, 27453, 27452
 9466, 27343, 27344, 27354, 27353, 27443, 27444, 27454, 27453
 9467, 27344, 27345, 27355, 27354, 27444, 27445, 27455, 27454
 9468, 27345, 27346, 27356, 27355, 27445, 27446, 27456, 27455
 9469, 27346, 27347, 27357, 27356, 27446, 27447, 27457, 27456
 9470, 27347, 27348, 27358, 27357, 27447, 27448, 27458, 27457
 9471, 27348,  6510,  6511, 27358, 27448,  6520,  6521, 27458
 9472,  5541, 27349, 27359,  5542,  5551, 27449, 27459,  5552
 9473, 27349, 27350, 27360, 27359, 27449, 27450, 27460, 27459
 9474, 27350, 27351, 27361, 27360, 27450, 27451, 27461, 27460
 9475, 27351, 27352, 27362, 27361, 27451, 27452, 27462, 27461
 9476, 27352, 27353, 27363, 27362, 27452, 27453, 27463, 27462
 9477, 27353, 27354, 27364, 27363, 27453, 27454, 27464, 27463
 9478, 27354, 27355, 27365, 27364, 27454, 27455, 27465, 27464
 9479, 27355, 27356, 27366, 27365, 27455, 27456, 27466, 27465
 9480, 27356, 27357, 27367, 27366, 27456, 27457, 27467, 27466
 9481, 27357, 27358, 27368, 27367, 27457, 27458, 27468, 27467
 9482, 27358,  6511,  6512, 27368, 27458,  6521,  6522, 27468
 9483,  5542, 27359, 27369,  5543,  5552, 27459, 27469,  5553
 9484, 27359, 27360, 27370, 27369, 27459, 27460, 27470, 27469
 9485, 27360, 27361, 27371, 27370, 27460, 27461, 27471, 27470
 9486, 27361, 27362, 27372, 27371, 27461, 27462, 27472, 27471
 9487, 27362, 27363, 27373, 27372, 27462, 27463, 27473, 27472
 9488, 27363, 27364, 27374, 27373, 27463, 27464, 27474, 27473
 9489, 27364, 27365, 27375, 27374, 27464, 27465, 27475, 27474
 9490, 27365, 27366, 27376, 27375, 27465, 27466, 27476, 27475
 9491, 27366, 27367, 27377, 27376, 27466, 27467, 27477, 27476
 9492, 27367, 27368, 27378, 27377, 27467, 27468, 27478, 27477
 9493, 27368,  6512,  6513, 27378, 27468,  6522,  6523, 27478
 9494,  5543, 27369, 27379,  5544,  5553, 27469, 27479,  5554
 9495, 27369, 27370, 27380, 27379, 27469, 27470, 27480, 27479
 9496, 27370, 27371, 27381, 27380, 27470, 27471, 27481, 27480
 9497, 27371, 27372, 27382, 27381, 27471, 27472, 27482, 27481
 9498, 27372, 27373, 27383, 27382, 27472, 27473, 27483, 27482
 9499, 27373, 27374, 27384, 27383, 27473, 27474, 27484, 27483
 9500, 27374, 27375, 27385, 27384, 27474, 27475, 27485, 27484
 9501, 27375, 27376, 27386, 27385, 27475, 27476, 27486, 27485
 9502, 27376, 27377, 27387, 27386, 27476, 27477, 27487, 27486
 9503, 27377, 27378, 27388, 27387, 27477, 27478, 27488, 27487
 9504, 27378,  6513,  6514, 27388, 27478,  6523,  6524, 27488
 9505,  5544, 27379, 27389,  5545,  5554, 27479, 27489,  5555
 9506, 27379, 27380, 27390, 27389, 27479, 27480, 27490, 27489
 9507, 27380, 27381, 27391, 27390, 27480, 27481, 27491, 27490
 9508, 27381, 27382, 27392, 27391, 27481, 27482, 27492, 27491
 9509, 27382, 27383, 27393, 27392, 27482, 27483, 27493, 27492
 9510, 27383, 27384, 27394, 27393, 27483, 27484, 27494, 27493
 9511, 27384, 27385, 27395, 27394, 27484, 27485, 27495, 27494
 9512, 27385, 27386, 27396, 27395, 27485, 27486, 27496, 27495
 9513, 27386, 27387, 27397, 27396, 27486, 27487, 27497, 27496
 9514, 27387, 27388, 27398, 27397, 27487, 27488, 27498, 27497
 9515, 27388,  6514,  6515, 27398, 27488,  6524,  6525, 27498
 9516,  5545, 27389, 27399,  5546,  5555, 27489, 27499,  5556
 9517, 27389, 27390, 27400, 27399, 27489, 27490, 27500, 27499
 9518, 27390, 27391, 27401, 27400, 27490, 27491, 27501, 27500
 9519, 27391, 27392, 27402, 27401, 27491, 27492, 27502, 27501
 9520, 27392, 27393, 27403, 27402, 27492, 27493, 27503, 27502
 9521, 27393, 27394, 27404, 27403, 27493, 27494, 27504, 27503
 9522, 27394, 27395, 27405, 27404, 27494, 27495, 27505, 27504
 9523, 27395, 27396, 27406, 27405, 27495, 27496, 27506, 27505
 9524, 27396, 27397, 27407, 27406, 27496, 27497, 27507, 27506
 9525, 27397, 27398, 27408, 27407, 27497, 27498, 27508, 27507
 9526, 27398,  6515,  6516, 27408, 27498,  6525,  6526, 27508
 9527,  5546, 27399, 27409,  5547,  5556, 27499, 27509,  5557
 9528, 27399, 27400, 27410, 27409, 27499, 27500, 27510, 27509
 9529, 27400, 27401, 27411, 27410, 27500, 27501, 27511, 27510
 9530, 27401, 27402, 27412, 27411, 27501, 27502, 27512, 27511
 9531, 27402, 27403, 27413, 27412, 27502, 27503, 27513, 27512
 9532, 27403, 27404, 27414, 27413, 27503, 27504, 27514, 27513
 9533, 27404, 27405, 27415, 27414, 27504, 27505, 27515, 27514
 9534, 27405, 27406, 27416, 27415, 27505, 27506, 27516, 27515
 9535, 27406, 27407, 27417, 27416, 27506, 27507, 27517, 27516
 9536, 27407, 27408, 27418, 27417, 27507, 27508, 27518, 27517
 9537, 27408,  6516,  6517, 27418, 27508,  6526,  6527, 27518
 9538,  5547, 27409, 27419,  5548,  5557, 27509, 27519,  5558
 9539, 27409, 27410, 27420, 27419, 27509, 27510, 27520, 27519
 9540, 27410, 27411, 27421, 27420, 27510, 27511, 27521, 27520
 9541, 27411, 27412, 27422, 27421, 27511, 27512, 27522, 27521
 9542, 27412, 27413, 27423, 27422, 27512, 27513, 27523, 27522
 9543, 27413, 27414, 27424, 27423, 27513, 27514, 27524, 27523
 9544, 27414, 27415, 27425, 27424, 27514, 27515, 27525, 27524
 9545, 27415, 27416, 27426, 27425, 27515, 27516, 27526, 27525
 9546, 27416, 27417, 27427, 27426, 27516, 27517, 27527, 27526
 9547, 27417, 27418, 27428, 27427, 27517, 27518, 27528, 27527
 9548, 27418,  6517,  6518, 27428, 27518,  6527,  6528, 27528
 9549,  5548, 27419,  8439,   706,  5558, 27519,  8449,   705
 9550, 27419, 27420,  8440,  8439, 27519, 27520,  8450,  8449
 9551, 27420, 27421,  8441,  8440, 27520, 27521,  8451,  8450
 9552, 27421, 27422,  8442,  8441, 27521, 27522,  8452,  8451
 9553, 27422, 27423,  8443,  8442, 27522, 27523,  8453,  8452
 9554, 27423, 27424,  8444,  8443, 27523, 27524,  8454,  8453
 9555, 27424, 27425,  8445,  8444, 27524, 27525,  8455,  8454
 9556, 27425, 27426,  8446,  8445, 27525, 27526,  8456,  8455
 9557, 27426, 27427,  8447,  8446, 27526, 27527,  8457,  8456
 9558, 27427, 27428,  8448,  8447, 27527, 27528,  8458,  8457
 9559, 27428,  6518,   805,  8448, 27528,  6528,   806,  8458
 9560,   710,  7489, 27429,  5549,   711,  7499, 27529,  5559
 9561,  7489,  7490, 27430, 27429,  7499,  7500, 27530, 27529
 9562,  7490,  7491, 27431, 27430,  7500,  7501, 27531, 27530
 9563,  7491,  7492, 27432, 27431,  7501,  7502, 27532, 27531
 9564,  7492,  7493, 27433, 27432,  7502,  7503, 27533, 27532
 9565,  7493,  7494, 27434, 27433,  7503,  7504, 27534, 27533
 9566,  7494,  7495, 27435, 27434,  7504,  7505, 27535, 27534
 9567,  7495,  7496, 27436, 27435,  7505,  7506, 27536, 27535
 9568,  7496,  7497, 27437, 27436,  7506,  7507, 27537, 27536
 9569,  7497,  7498, 27438, 27437,  7507,  7508, 27538, 27537
 9570,  7498,   946,  6519, 27438,  7508,   945,  6529, 27538
 9571,  5549, 27429, 27439,  5550,  5559, 27529, 27539,  5560
 9572, 27429, 27430, 27440, 27439, 27529, 27530, 27540, 27539
 9573, 27430, 27431, 27441, 27440, 27530, 27531, 27541, 27540
 9574, 27431, 27432, 27442, 27441, 27531, 27532, 27542, 27541
 9575, 27432, 27433, 27443, 27442, 27532, 27533, 27543, 27542
 9576, 27433, 27434, 27444, 27443, 27533, 27534, 27544, 27543
 9577, 27434, 27435, 27445, 27444, 27534, 27535, 27545, 27544
 9578, 27435, 27436, 27446, 27445, 27535, 27536, 27546, 27545
 9579, 27436, 27437, 27447, 27446, 27536, 27537, 27547, 27546
 9580, 27437, 27438, 27448, 27447, 27537, 27538, 27548, 27547
 9581, 27438,  6519,  6520, 27448, 27538,  6529,  6530, 27548
 9582,  5550, 27439, 27449,  5551,  5560, 27539, 27549,  5561
 9583, 27439, 27440, 27450, 27449, 27539, 27540, 27550, 27549
 9584, 27440, 27441, 27451, 27450, 27540, 27541, 27551, 27550
 9585, 27441, 27442, 27452, 27451, 27541, 27542, 27552, 27551
 9586, 27442, 27443, 27453, 27452, 27542, 27543, 27553, 27552
 9587, 27443, 27444, 27454, 27453, 27543, 27544, 27554, 27553
 9588, 27444, 27445, 27455, 27454, 27544, 27545, 27555, 27554
 9589, 27445, 27446, 27456, 27455, 27545, 27546, 27556, 27555
 9590, 27446, 27447, 27457, 27456, 27546, 27547, 27557, 27556
 9591, 27447, 27448, 27458, 27457, 27547, 27548, 27558, 27557
 9592, 27448,  6520,  6521, 27458, 27548,  6530,  6531, 27558
 9593,  5551, 27449, 27459,  5552,  5561, 27549, 27559,  5562
 9594, 27449, 27450, 27460, 27459, 27549, 27550, 27560, 27559
 9595, 27450, 27451, 27461, 27460, 27550, 27551, 27561, 27560
 9596, 27451, 27452, 27462, 27461, 27551, 27552, 27562, 27561
 9597, 27452, 27453, 27463, 27462, 27552, 27553, 27563, 27562
 9598, 27453, 27454, 27464, 27463, 27553, 27554, 27564, 27563
 9599, 27454, 27455, 27465, 27464, 27554, 27555, 27565, 27564
 9600, 27455, 27456, 27466, 27465, 27555, 27556, 27566, 27565
 9601, 27456, 27457, 27467, 27466, 27556, 27557, 27567, 27566
 9602, 27457, 27458, 27468, 27467, 27557, 27558, 27568, 27567
 9603, 27458,  6521,  6522, 27468, 27558,  6531,  6532, 27568
 9604,  5552, 27459, 27469,  5553,  5562, 27559, 27569,  5563
 9605, 27459, 27460, 27470, 27469, 27559, 27560, 27570, 27569
 9606, 27460, 27461, 27471, 27470, 27560, 27561, 27571, 27570
 9607, 27461, 27462, 27472, 27471, 27561, 27562, 27572, 27571
 9608, 27462, 27463, 27473, 27472, 27562, 27563, 27573, 27572
 9609, 27463, 27464, 27474, 27473, 27563, 27564, 27574, 27573
 9610, 27464, 27465, 27475, 27474, 27564, 27565, 27575, 27574
 9611, 27465, 27466, 27476, 27475, 27565, 27566, 27576, 27575
 9612, 27466, 27467, 27477, 27476, 27566, 27567, 27577, 27576
 9613, 27467, 27468, 27478, 27477, 27567, 27568, 27578, 27577
 9614, 27468,  6522,  6523, 27478, 27568,  6532,  6533, 27578
 9615,  5553, 27469, 27479,  5554,  5563, 27569, 27579,  5564
 9616, 27469, 27470, 27480, 27479, 27569, 27570, 27580, 27579
 9617, 27470, 27471, 27481, 27480, 27570, 27571, 27581, 27580
 9618, 27471, 27472, 27482, 27481, 27571, 27572, 27582, 27581
 9619, 27472, 27473, 27483, 27482, 27572, 27573, 27583, 27582
 9620, 27473, 27474, 27484, 27483, 27573, 27574, 27584, 27583
 9621, 27474, 27475, 27485, 27484, 27574, 27575, 27585, 27584
 9622, 27475, 27476, 27486, 27485, 27575, 27576, 27586, 27585
 9623, 27476, 27477, 27487, 27486, 27576, 27577, 27587, 27586
 9624, 27477, 27478, 27488, 27487, 27577, 27578, 27588, 27587
 9625, 27478,  6523,  6524, 27488, 27578,  6533,  6534, 27588
 9626,  5554, 27479, 27489,  5555,  5564, 27579, 27589,  5565
 9627, 27479, 27480, 27490, 27489, 27579, 27580, 27590, 27589
 9628, 27480, 27481, 27491, 27490, 27580, 27581, 27591, 27590
 9629, 27481, 27482, 27492, 27491, 27581, 27582, 27592, 27591
 9630, 27482, 27483, 27493, 27492, 27582, 27583, 27593, 27592
 9631, 27483, 27484, 27494, 27493, 27583, 27584, 27594, 27593
 9632, 27484, 27485, 27495, 27494, 27584, 27585, 27595, 27594
 9633, 27485, 27486, 27496, 27495, 27585, 27586, 27596, 27595
 9634, 27486, 27487, 27497, 27496, 27586, 27587, 27597, 27596
 9635, 27487, 27488, 27498, 27497, 27587, 27588, 27598, 27597
 9636, 27488,  6524,  6525, 27498, 27588,  6534,  6535, 27598
 9637,  5555, 27489, 27499,  5556,  5565, 27589, 27599,  5566
 9638, 27489, 27490, 27500, 27499, 27589, 27590, 27600, 27599
 9639, 27490, 27491, 27501, 27500, 27590, 27591, 27601, 27600
 9640, 27491, 27492, 27502, 27501, 27591, 27592, 27602, 27601
 9641, 27492, 27493, 27503, 27502, 27592, 27593, 27603, 27602
 9642, 27493, 27494, 27504, 27503, 27593, 27594, 27604, 27603
 9643, 27494, 27495, 27505, 27504, 27594, 27595, 27605, 27604
 9644, 27495, 27496, 27506, 27505, 27595, 27596, 27606, 27605
 9645, 27496, 27497, 27507, 27506, 27596, 27597, 27607, 27606
 9646, 27497, 27498, 27508, 27507, 27597, 27598, 27608, 27607
 9647, 27498,  6525,  6526, 27508, 27598,  6535,  6536, 27608
 9648,  5556, 27499, 27509,  5557,  5566, 27599, 27609,  5567
 9649, 27499, 27500, 27510, 27509, 27599, 27600, 27610, 27609
 9650, 27500, 27501, 27511, 27510, 27600, 27601, 27611, 27610
 9651, 27501, 27502, 27512, 27511, 27601, 27602, 27612, 27611
 9652, 27502, 27503, 27513, 27512, 27602, 27603, 27613, 27612
 9653, 27503, 27504, 27514, 27513, 27603, 27604, 27614, 27613
 9654, 27504, 27505, 27515, 27514, 27604, 27605, 27615, 27614
 9655, 27505, 27506, 27516, 27515, 27605, 27606, 27616, 27615
 9656, 27506, 27507, 27517, 27516, 27606, 27607, 27617, 27616
 9657, 27507, 27508, 27518, 27517, 27607, 27608, 27618, 27617
 9658, 27508,  6526,  6527, 27518, 27608,  6536,  6537, 27618
 9659,  5557, 27509, 27519,  5558,  5567, 27609, 27619,  5568
 9660, 27509, 27510, 27520, 27519, 27609, 27610, 27620, 27619
 9661, 27510, 27511, 27521, 27520, 27610, 27611, 27621, 27620
 9662, 27511, 27512, 27522, 27521, 27611, 27612, 27622, 27621
 9663, 27512, 27513, 27523, 27522, 27612, 27613, 27623, 27622
 9664, 27513, 27514, 27524, 27523, 27613, 27614, 27624, 27623
 9665, 27514, 27515, 27525, 27524, 27614, 27615, 27625, 27624
 9666, 27515, 27516, 27526, 27525, 27615, 27616, 27626, 27625
 9667, 27516, 27517, 27527, 27526, 27616, 27617, 27627, 27626
 9668, 27517, 27518, 27528, 27527, 27617, 27618, 27628, 27627
 9669, 27518,  6527,  6528, 27528, 27618,  6537,  6538, 27628
 9670,  5558, 27519,  8449,   705,  5568, 27619,  8459,   704
 9671, 27519, 27520,  8450,  8449, 27619, 27620,  8460,  8459
 9672, 27520, 27521,  8451,  8450, 27620, 27621,  8461,  8460
 9673, 27521, 27522,  8452,  8451, 27621, 27622,  8462,  8461
 9674, 27522, 27523,  8453,  8452, 27622, 27623,  8463,  8462
 9675, 27523, 27524,  8454,  8453, 27623, 27624,  8464,  8463
 9676, 27524, 27525,  8455,  8454, 27624, 27625,  8465,  8464
 9677, 27525, 27526,  8456,  8455, 27625, 27626,  8466,  8465
 9678, 27526, 27527,  8457,  8456, 27626, 27627,  8467,  8466
 9679, 27527, 27528,  8458,  8457, 27627, 27628,  8468,  8467
 9680, 27528,  6528,   806,  8458, 27628,  6538,   807,  8468
 9681,   711,  7499, 27529,  5559,   712,  7509, 27629,  5569
 9682,  7499,  7500, 27530, 27529,  7509,  7510, 27630, 27629
 9683,  7500,  7501, 27531, 27530,  7510,  7511, 27631, 27630
 9684,  7501,  7502, 27532, 27531,  7511,  7512, 27632, 27631
 9685,  7502,  7503, 27533, 27532,  7512,  7513, 27633, 27632
 9686,  7503,  7504, 27534, 27533,  7513,  7514, 27634, 27633
 9687,  7504,  7505, 27535, 27534,  7514,  7515, 27635, 27634
 9688,  7505,  7506, 27536, 27535,  7515,  7516, 27636, 27635
 9689,  7506,  7507, 27537, 27536,  7516,  7517, 27637, 27636
 9690,  7507,  7508, 27538, 27537,  7517,  7518, 27638, 27637
 9691,  7508,   945,  6529, 27538,  7518,   944,  6539, 27638
 9692,  5559, 27529, 27539,  5560,  5569, 27629, 27639,  5570
 9693, 27529, 27530, 27540, 27539, 27629, 27630, 27640, 27639
 9694, 27530, 27531, 27541, 27540, 27630, 27631, 27641, 27640
 9695, 27531, 27532, 27542, 27541, 27631, 27632, 27642, 27641
 9696, 27532, 27533, 27543, 27542, 27632, 27633, 27643, 27642
 9697, 27533, 27534, 27544, 27543, 27633, 27634, 27644, 27643
 9698, 27534, 27535, 27545, 27544, 27634, 27635, 27645, 27644
 9699, 27535, 27536, 27546, 27545, 27635, 27636, 27646, 27645
 9700, 27536, 27537, 27547, 27546, 27636, 27637, 27647, 27646
 9701, 27537, 27538, 27548, 27547, 27637, 27638, 27648, 27647
 9702, 27538,  6529,  6530, 27548, 27638,  6539,  6540, 27648
 9703,  5560, 27539, 27549,  5561,  5570, 27639, 27649,  5571
 9704, 27539, 27540, 27550, 27549, 27639, 27640, 27650, 27649
 9705, 27540, 27541, 27551, 27550, 27640, 27641, 27651, 27650
 9706, 27541, 27542, 27552, 27551, 27641, 27642, 27652, 27651
 9707, 27542, 27543, 27553, 27552, 27642, 27643, 27653, 27652
 9708, 27543, 27544, 27554, 27553, 27643, 27644, 27654, 27653
 9709, 27544, 27545, 27555, 27554, 27644, 27645, 27655, 27654
 9710, 27545, 27546, 27556, 27555, 27645, 27646, 27656, 27655
 9711, 27546, 27547, 27557, 27556, 27646, 27647, 27657, 27656
 9712, 27547, 27548, 27558, 27557, 27647, 27648, 27658, 27657
 9713, 27548,  6530,  6531, 27558, 27648,  6540,  6541, 27658
 9714,  5561, 27549, 27559,  5562,  5571, 27649, 27659,  5572
 9715, 27549, 27550, 27560, 27559, 27649, 27650, 27660, 27659
 9716, 27550, 27551, 27561, 27560, 27650, 27651, 27661, 27660
 9717, 27551, 27552, 27562, 27561, 27651, 27652, 27662, 27661
 9718, 27552, 27553, 27563, 27562, 27652, 27653, 27663, 27662
 9719, 27553, 27554, 27564, 27563, 27653, 27654, 27664, 27663
 9720, 27554, 27555, 27565, 27564, 27654, 27655, 27665, 27664
 9721, 27555, 27556, 27566, 27565, 27655, 27656, 27666, 27665
 9722, 27556, 27557, 27567, 27566, 27656, 27657, 27667, 27666
 9723, 27557, 27558, 27568, 27567, 27657, 27658, 27668, 27667
 9724, 27558,  6531,  6532, 27568, 27658,  6541,  6542, 27668
 9725,  5562, 27559, 27569,  5563,  5572, 27659, 27669,  5573
 9726, 27559, 27560, 27570, 27569, 27659, 27660, 27670, 27669
 9727, 27560, 27561, 27571, 27570, 27660, 27661, 27671, 27670
 9728, 27561, 27562, 27572, 27571, 27661, 27662, 27672, 27671
 9729, 27562, 27563, 27573, 27572, 27662, 27663, 27673, 27672
 9730, 27563, 27564, 27574, 27573, 27663, 27664, 27674, 27673
 9731, 27564, 27565, 27575, 27574, 27664, 27665, 27675, 27674
 9732, 27565, 27566, 27576, 27575, 27665, 27666, 27676, 27675
 9733, 27566, 27567, 27577, 27576, 27666, 27667, 27677, 27676
 9734, 27567, 27568, 27578, 27577, 27667, 27668, 27678, 27677
 9735, 27568,  6532,  6533, 27578, 27668,  6542,  6543, 27678
 9736,  5563, 27569, 27579,  5564,  5573, 27669, 27679,  5574
 9737, 27569, 27570, 27580, 27579, 27669, 27670, 27680, 27679
 9738, 27570, 27571, 27581, 27580, 27670, 27671, 27681, 27680
 9739, 27571, 27572, 27582, 27581, 27671, 27672, 27682, 27681
 9740, 27572, 27573, 27583, 27582, 27672, 27673, 27683, 27682
 9741, 27573, 27574, 27584, 27583, 27673, 27674, 27684, 27683
 9742, 27574, 27575, 27585, 27584, 27674, 27675, 27685, 27684
 9743, 27575, 27576, 27586, 27585, 27675, 27676, 27686, 27685
 9744, 27576, 27577, 27587, 27586, 27676, 27677, 27687, 27686
 9745, 27577, 27578, 27588, 27587, 27677, 27678, 27688, 27687
 9746, 27578,  6533,  6534, 27588, 27678,  6543,  6544, 27688
 9747,  5564, 27579, 27589,  5565,  5574, 27679, 27689,  5575
 9748, 27579, 27580, 27590, 27589, 27679, 27680, 27690, 27689
 9749, 27580, 27581, 27591, 27590, 27680, 27681, 27691, 27690
 9750, 27581, 27582, 27592, 27591, 27681, 27682, 27692, 27691
 9751, 27582, 27583, 27593, 27592, 27682, 27683, 27693, 27692
 9752, 27583, 27584, 27594, 27593, 27683, 27684, 27694, 27693
 9753, 27584, 27585, 27595, 27594, 27684, 27685, 27695, 27694
 9754, 27585, 27586, 27596, 27595, 27685, 27686, 27696, 27695
 9755, 27586, 27587, 27597, 27596, 27686, 27687, 27697, 27696
 9756, 27587, 27588, 27598, 27597, 27687, 27688, 27698, 27697
 9757, 27588,  6534,  6535, 27598, 27688,  6544,  6545, 27698
 9758,  5565, 27589, 27599,  5566,  5575, 27689, 27699,  5576
 9759, 27589, 27590, 27600, 27599, 27689, 27690, 27700, 27699
 9760, 27590, 27591, 27601, 27600, 27690, 27691, 27701, 27700
 9761, 27591, 27592, 27602, 27601, 27691, 27692, 27702, 27701
 9762, 27592, 27593, 27603, 27602, 27692, 27693, 27703, 27702
 9763, 27593, 27594, 27604, 27603, 27693, 27694, 27704, 27703
 9764, 27594, 27595, 27605, 27604, 27694, 27695, 27705, 27704
 9765, 27595, 27596, 27606, 27605, 27695, 27696, 27706, 27705
 9766, 27596, 27597, 27607, 27606, 27696, 27697, 27707, 27706
 9767, 27597, 27598, 27608, 27607, 27697, 27698, 27708, 27707
 9768, 27598,  6535,  6536, 27608, 27698,  6545,  6546, 27708
 9769,  5566, 27599, 27609,  5567,  5576, 27699, 27709,  5577
 9770, 27599, 27600, 27610, 27609, 27699, 27700, 27710, 27709
 9771, 27600, 27601, 27611, 27610, 27700, 27701, 27711, 27710
 9772, 27601, 27602, 27612, 27611, 27701, 27702, 27712, 27711
 9773, 27602, 27603, 27613, 27612, 27702, 27703, 27713, 27712
 9774, 27603, 27604, 27614, 27613, 27703, 27704, 27714, 27713
 9775, 27604, 27605, 27615, 27614, 27704, 27705, 27715, 27714
 9776, 27605, 27606, 27616, 27615, 27705, 27706, 27716, 27715
 9777, 27606, 27607, 27617, 27616, 27706, 27707, 27717, 27716
 9778, 27607, 27608, 27618, 27617, 27707, 27708, 27718, 27717
 9779, 27608,  6536,  6537, 27618, 27708,  6546,  6547, 27718
 9780,  5567, 27609, 27619,  5568,  5577, 27709, 27719,  5578
 9781, 27609, 27610, 27620, 27619, 27709, 27710, 27720, 27719
 9782, 27610, 27611, 27621, 27620, 27710, 27711, 27721, 27720
 9783, 27611, 27612, 27622, 27621, 27711, 27712, 27722, 27721
 9784, 27612, 27613, 27623, 27622, 27712, 27713, 27723, 27722
 9785, 27613, 27614, 27624, 27623, 27713, 27714, 27724, 27723
 9786, 27614, 27615, 27625, 27624, 27714, 27715, 27725, 27724
 9787, 27615, 27616, 27626, 27625, 27715, 27716, 27726, 27725
 9788, 27616, 27617, 27627, 27626, 27716, 27717, 27727, 27726
 9789, 27617, 27618, 27628, 27627, 27717, 27718, 27728, 27727
 9790, 27618,  6537,  6538, 27628, 27718,  6547,  6548, 27728
 9791,  5568, 27619,  8459,   704,  5578, 27719,  8469,   703
 9792, 27619, 27620,  8460,  8459, 27719, 27720,  8470,  8469
 9793, 27620, 27621,  8461,  8460, 27720, 27721,  8471,  8470
 9794, 27621, 27622,  8462,  8461, 27721, 27722,  8472,  8471
 9795, 27622, 27623,  8463,  8462, 27722, 27723,  8473,  8472
 9796, 27623, 27624,  8464,  8463, 27723, 27724,  8474,  8473
 9797, 27624, 27625,  8465,  8464, 27724, 27725,  8475,  8474
 9798, 27625, 27626,  8466,  8465, 27725, 27726,  8476,  8475
 9799, 27626, 27627,  8467,  8466, 27726, 27727,  8477,  8476
 9800, 27627, 27628,  8468,  8467, 27727, 27728,  8478,  8477
 9801, 27628,  6538,   807,  8468, 27728,  6548,   808,  8478
 9802,   712,  7509, 27629,  5569,   713,  7519, 27729,  5579
 9803,  7509,  7510, 27630, 27629,  7519,  7520, 27730, 27729
 9804,  7510,  7511, 27631, 27630,  7520,  7521, 27731, 27730
 9805,  7511,  7512, 27632, 27631,  7521,  7522, 27732, 27731
 9806,  7512,  7513, 27633, 27632,  7522,  7523, 27733, 27732
 9807,  7513,  7514, 27634, 27633,  7523,  7524, 27734, 27733
 9808,  7514,  7515, 27635, 27634,  7524,  7525, 27735, 27734
 9809,  7515,  7516, 27636, 27635,  7525,  7526, 27736, 27735
 9810,  7516,  7517, 27637, 27636,  7526,  7527, 27737, 27736
 9811,  7517,  7518, 27638, 27637,  7527,  7528, 27738, 27737
 9812,  7518,   944,  6539, 27638,  7528,   943,  6549, 27738
 9813,  5569, 27629, 27639,  5570,  5579, 27729, 27739,  5580
 9814, 27629, 27630, 27640, 27639, 27729, 27730, 27740, 27739
 9815, 27630, 27631, 27641, 27640, 27730, 27731, 27741, 27740
 9816, 27631, 27632, 27642, 27641, 27731, 27732, 27742, 27741
 9817, 27632, 27633, 27643, 27642, 27732, 27733, 27743, 27742
 9818, 27633, 27634, 27644, 27643, 27733, 27734, 27744, 27743
 9819, 27634, 27635, 27645, 27644, 27734, 27735, 27745, 27744
 9820, 27635, 27636, 27646, 27645, 27735, 27736, 27746, 27745
 9821, 27636, 27637, 27647, 27646, 27736, 27737, 27747, 27746
 9822, 27637, 27638, 27648, 27647, 27737, 27738, 27748, 27747
 9823, 27638,  6539,  6540, 27648, 27738,  6549,  6550, 27748
 9824,  5570, 27639, 27649,  5571,  5580, 27739, 27749,  5581
 9825, 27639, 27640, 27650, 27649, 27739, 27740, 27750, 27749
 9826, 27640, 27641, 27651, 27650, 27740, 27741, 27751, 27750
 9827, 27641, 27642, 27652, 27651, 27741, 27742, 27752, 27751
 9828, 27642, 27643, 27653, 27652, 27742, 27743, 27753, 27752
 9829, 27643, 27644, 27654, 27653, 27743, 27744, 27754, 27753
 9830, 27644, 27645, 27655, 27654, 27744, 27745, 27755, 27754
 9831, 27645, 27646, 27656, 27655, 27745, 27746, 27756, 27755
 9832, 27646, 27647, 27657, 27656, 27746, 27747, 27757, 27756
 9833, 27647, 27648, 27658, 27657, 27747, 27748, 27758, 27757
 9834, 27648,  6540,  6541, 27658, 27748,  6550,  6551, 27758
 9835,  5571, 27649, 27659,  5572,  5581, 27749, 27759,  5582
 9836, 27649, 27650, 27660, 27659, 27749, 27750, 27760, 27759
 9837, 27650, 27651, 27661, 27660, 27750, 27751, 27761, 27760
 9838, 27651, 27652, 27662, 27661, 27751, 27752, 27762, 27761
 9839, 27652, 27653, 27663, 27662, 27752, 27753, 27763, 27762
 9840, 27653, 27654, 27664, 27663, 27753, 27754, 27764, 27763
 9841, 27654, 27655, 27665, 27664, 27754, 27755, 27765, 27764
 9842, 27655, 27656, 27666, 27665, 27755, 27756, 27766, 27765
 9843, 27656, 27657, 27667, 27666, 27756, 27757, 27767, 27766
 9844, 27657, 27658, 27668, 27667, 27757, 27758, 27768, 27767
 9845, 27658,  6541,  6542, 27668, 27758,  6551,  6552, 27768
 9846,  5572, 27659, 27669,  5573,  5582, 27759, 27769,  5583
 9847, 27659, 27660, 27670, 27669, 27759, 27760, 27770, 27769
 9848, 27660, 27661, 27671, 27670, 27760, 27761, 27771, 27770
 9849, 27661, 27662, 27672, 27671, 27761, 27762, 27772, 27771
 9850, 27662, 27663, 27673, 27672, 27762, 27763, 27773, 27772
 9851, 27663, 27664, 27674, 27673, 27763, 27764, 27774, 27773
 9852, 27664, 27665, 27675, 27674, 27764, 27765, 27775, 27774
 9853, 27665, 27666, 27676, 27675, 27765, 27766, 27776, 27775
 9854, 27666, 27667, 27677, 27676, 27766, 27767, 27777, 27776
 9855, 27667, 27668, 27678, 27677, 27767, 27768, 27778, 27777
 9856, 27668,  6542,  6543, 27678, 27768,  6552,  6553, 27778
 9857,  5573, 27669, 27679,  5574,  5583, 27769, 27779,  5584
 9858, 27669, 27670, 27680, 27679, 27769, 27770, 27780, 27779
 9859, 27670, 27671, 27681, 27680, 27770, 27771, 27781, 27780
 9860, 27671, 27672, 27682, 27681, 27771, 27772, 27782, 27781
 9861, 27672, 27673, 27683, 27682, 27772, 27773, 27783, 27782
 9862, 27673, 27674, 27684, 27683, 27773, 27774, 27784, 27783
 9863, 27674, 27675, 27685, 27684, 27774, 27775, 27785, 27784
 9864, 27675, 27676, 27686, 27685, 27775, 27776, 27786, 27785
 9865, 27676, 27677, 27687, 27686, 27776, 27777, 27787, 27786
 9866, 27677, 27678, 27688, 27687, 27777, 27778, 27788, 27787
 9867, 27678,  6543,  6544, 27688, 27778,  6553,  6554, 27788
 9868,  5574, 27679, 27689,  5575,  5584, 27779, 27789,  5585
 9869, 27679, 27680, 27690, 27689, 27779, 27780, 27790, 27789
 9870, 27680, 27681, 27691, 27690, 27780, 27781, 27791, 27790
 9871, 27681, 27682, 27692, 27691, 27781, 27782, 27792, 27791
 9872, 27682, 27683, 27693, 27692, 27782, 27783, 27793, 27792
 9873, 27683, 27684, 27694, 27693, 27783, 27784, 27794, 27793
 9874, 27684, 27685, 27695, 27694, 27784, 27785, 27795, 27794
 9875, 27685, 27686, 27696, 27695, 27785, 27786, 27796, 27795
 9876, 27686, 27687, 27697, 27696, 27786, 27787, 27797, 27796
 9877, 27687, 27688, 27698, 27697, 27787, 27788, 27798, 27797
 9878, 27688,  6544,  6545, 27698, 27788,  6554,  6555, 27798
 9879,  5575, 27689, 27699,  5576,  5585, 27789, 27799,  5586
 9880, 27689, 27690, 27700, 27699, 27789, 27790, 27800, 27799
 9881, 27690, 27691, 27701, 27700, 27790, 27791, 27801, 27800
 9882, 27691, 27692, 27702, 27701, 27791, 27792, 27802, 27801
 9883, 27692, 27693, 27703, 27702, 27792, 27793, 27803, 27802
 9884, 27693, 27694, 27704, 27703, 27793, 27794, 27804, 27803
 9885, 27694, 27695, 27705, 27704, 27794, 27795, 27805, 27804
 9886, 27695, 27696, 27706, 27705, 27795, 27796, 27806, 27805
 9887, 27696, 27697, 27707, 27706, 27796, 27797, 27807, 27806
 9888, 27697, 27698, 27708, 27707, 27797, 27798, 27808, 27807
 9889, 27698,  6545,  6546, 27708, 27798,  6555,  6556, 27808
 9890,  5576, 27699, 27709,  5577,  5586, 27799, 27809,  5587
 9891, 27699, 27700, 27710, 27709, 27799, 27800, 27810, 27809
 9892, 27700, 27701, 27711, 27710, 27800, 27801, 27811, 27810
 9893, 27701, 27702, 27712, 27711, 27801, 27802, 27812, 27811
 9894, 27702, 27703, 27713, 27712, 27802, 27803, 27813, 27812
 9895, 27703, 27704, 27714, 27713, 27803, 27804, 27814, 27813
 9896, 27704, 27705, 27715, 27714, 27804, 27805, 27815, 27814
 9897, 27705, 27706, 27716, 27715, 27805, 27806, 27816, 27815
 9898, 27706, 27707, 27717, 27716, 27806, 27807, 27817, 27816
 9899, 27707, 27708, 27718, 27717, 27807, 27808, 27818, 27817
 9900, 27708,  6546,  6547, 27718, 27808,  6556,  6557, 27818
 9901,  5577, 27709, 27719,  5578,  5587, 27809, 27819,  5588
 9902, 27709, 27710, 27720, 27719, 27809, 27810, 27820, 27819
 9903, 27710, 27711, 27721, 27720, 27810, 27811, 27821, 27820
 9904, 27711, 27712, 27722, 27721, 27811, 27812, 27822, 27821
 9905, 27712, 27713, 27723, 27722, 27812, 27813, 27823, 27822
 9906, 27713, 27714, 27724, 27723, 27813, 27814, 27824, 27823
 9907, 27714, 27715, 27725, 27724, 27814, 27815, 27825, 27824
 9908, 27715, 27716, 27726, 27725, 27815, 27816, 27826, 27825
 9909, 27716, 27717, 27727, 27726, 27816, 27817, 27827, 27826
 9910, 27717, 27718, 27728, 27727, 27817, 27818, 27828, 27827
 9911, 27718,  6547,  6548, 27728, 27818,  6557,  6558, 27828
 9912,  5578, 27719,  8469,   703,  5588, 27819,  8479,   702
 9913, 27719, 27720,  8470,  8469, 27819, 27820,  8480,  8479
 9914, 27720, 27721,  8471,  8470, 27820, 27821,  8481,  8480
 9915, 27721, 27722,  8472,  8471, 27821, 27822,  8482,  8481
 9916, 27722, 27723,  8473,  8472, 27822, 27823,  8483,  8482
 9917, 27723, 27724,  8474,  8473, 27823, 27824,  8484,  8483
 9918, 27724, 27725,  8475,  8474, 27824, 27825,  8485,  8484
 9919, 27725, 27726,  8476,  8475, 27825, 27826,  8486,  8485
 9920, 27726, 27727,  8477,  8476, 27826, 27827,  8487,  8486
 9921, 27727, 27728,  8478,  8477, 27827, 27828,  8488,  8487
 9922, 27728,  6548,   808,  8478, 27828,  6558,   809,  8488
 9923,   713,  7519, 27729,  5579,   714,  7529, 27829,  5589
 9924,  7519,  7520, 27730, 27729,  7529,  7530, 27830, 27829
 9925,  7520,  7521, 27731, 27730,  7530,  7531, 27831, 27830
 9926,  7521,  7522, 27732, 27731,  7531,  7532, 27832, 27831
 9927,  7522,  7523, 27733, 27732,  7532,  7533, 27833, 27832
 9928,  7523,  7524, 27734, 27733,  7533,  7534, 27834, 27833
 9929,  7524,  7525, 27735, 27734,  7534,  7535, 27835, 27834
 9930,  7525,  7526, 27736, 27735,  7535,  7536, 27836, 27835
 9931,  7526,  7527, 27737, 27736,  7536,  7537, 27837, 27836
 9932,  7527,  7528, 27738, 27737,  7537,  7538, 27838, 27837
 9933,  7528,   943,  6549, 27738,  7538,   942,  6559, 27838
 9934,  5579, 27729, 27739,  5580,  5589, 27829, 27839,  5590
 9935, 27729, 27730, 27740, 27739, 27829, 27830, 27840, 27839
 9936, 27730, 27731, 27741, 27740, 27830, 27831, 27841, 27840
 9937, 27731, 27732, 27742, 27741, 27831, 27832, 27842, 27841
 9938, 27732, 27733, 27743, 27742, 27832, 27833, 27843, 27842
 9939, 27733, 27734, 27744, 27743, 27833, 27834, 27844, 27843
 9940, 27734, 27735, 27745, 27744, 27834, 27835, 27845, 27844
 9941, 27735, 27736, 27746, 27745, 27835, 27836, 27846, 27845
 9942, 27736, 27737, 27747, 27746, 27836, 27837, 27847, 27846
 9943, 27737, 27738, 27748, 27747, 27837, 27838, 27848, 27847
 9944, 27738,  6549,  6550, 27748, 27838,  6559,  6560, 27848
 9945,  5580, 27739, 27749,  5581,  5590, 27839, 27849,  5591
 9946, 27739, 27740, 27750, 27749, 27839, 27840, 27850, 27849
 9947, 27740, 27741, 27751, 27750, 27840, 27841, 27851, 27850
 9948, 27741, 27742, 27752, 27751, 27841, 27842, 27852, 27851
 9949, 27742, 27743, 27753, 27752, 27842, 27843, 27853, 27852
 9950, 27743, 27744, 27754, 27753, 27843, 27844, 27854, 27853
 9951, 27744, 27745, 27755, 27754, 27844, 27845, 27855, 27854
 9952, 27745, 27746, 27756, 27755, 27845, 27846, 27856, 27855
 9953, 27746, 27747, 27757, 27756, 27846, 27847, 27857, 27856
 9954, 27747, 27748, 27758, 27757, 27847, 27848, 27858, 27857
 9955, 27748,  6550,  6551, 27758, 27848,  6560,  6561, 27858
 9956,  5581, 27749, 27759,  5582,  5591, 27849, 27859,  5592
