  41995,   18.1704597,   66.5019302,   2.72727275
  41996,   17.6322117,   67.0758438,   2.72727275
  41997,   17.0758419,   67.6322098,   2.72727275
  41998,   16.5019302,   68.1704636,   2.72727275
  41999,   15.9110603,   68.6900406,   2.72727275
  42000,   15.3038416,   69.1904068,   2.72727275
  42001,   14.6808939,   69.6710587,   2.72727275
  42002,   14.0428638,   70.1315002,   2.72727275
  42003,   13.3904009,   70.5712509,   2.72727275
  42004,   12.7241831,   70.9898682,   2.72727275
  42005,   12.0448847,   71.3869171,   2.72727275
  42006,   11.3532124,   71.7619858,   2.72727275
  42007,   10.6498728,   72.1146927,   2.72727275
  42008,   9.93558979,   72.4446716,   2.72727275
  42009,   9.21109867,   72.7515945,   2.72727275
  42010,   8.47714138,   73.0351334,   2.72727275
  42011,   7.73447418,   73.2950058,   2.72727275
  42012,   6.98385954,   73.5309372,   2.72727275
  42013,   6.22606802,    73.742691,   2.72727275
  42014,   5.46187687,   73.9300461,   2.72727275
  42015,   4.69207525,   74.0928192,   2.72727275
  42016,   3.91745162,   74.2308273,   2.72727275
  42017,   3.13880301,   74.3439331,   2.72727275
  42018,   2.35692859,   74.4320297,   2.72727275
  42019,   1.57263267,   74.4950256,   2.72727275
  42020,  0.786720514,   74.5328445,   2.72727275
  42021,           0.,   74.5454559,   2.72727275
  42022, -0.786720514,   74.5328445,   2.72727275
  42023,  -1.57263267,   74.4950256,   2.72727275
  42024,  -2.35692859,   74.4320297,   2.72727275
  42025,  -3.13880301,   74.3439331,   2.72727275
  42026,  -3.91745162,   74.2308273,   2.72727275
  42027,  -4.69207525,   74.0928192,   2.72727275
  42028,  -5.46187687,   73.9300461,   2.72727275
  42029,  -6.22606802,    73.742691,   2.72727275
  42030,  -6.98385954,   73.5309372,   2.72727275
  42031,  -7.73447418,   73.2950058,   2.72727275
  42032,  -8.47714138,   73.0351334,   2.72727275
  42033,  -9.21109867,   72.7515945,   2.72727275
  42034,  -9.93558979,   72.4446716,   2.72727275
  42035,  -10.6498728,   72.1146927,   2.72727275
  42036,  -11.3532124,   71.7619858,   2.72727275
  42037,  -12.0448847,   71.3869171,   2.72727275
  42038,  -12.7241831,   70.9898682,   2.72727275
  42039,  -13.3904009,   70.5712509,   2.72727275
  42040,  -14.0428638,   70.1315002,   2.72727275
  42041,  -14.6808939,   69.6710587,   2.72727275
  42042,  -15.3038416,   69.1904068,   2.72727275
  42043,  -15.9110603,   68.6900406,   2.72727275
  42044,  -16.5019302,   68.1704636,   2.72727275
  42045,  -17.0758419,   67.6322098,   2.72727275
  42046,  -17.6322117,   67.0758438,   2.72727275
  42047,  -18.1704597,   66.5019302,   2.72727275
  42048,  -18.6900368,   65.9110641,   2.72727275
  42049,  -19.1904087,   65.3038406,   2.72727275
  42050,  -19.6710625,   64.6808929,   2.72727275
  42051,  -20.1315002,   64.0428619,   2.72727275
  42052,  -20.5712528,   63.3904037,   2.72727275
  42053,  -20.9898682,   62.7241821,   2.72727275
  42054,  -21.3869133,   62.0448837,   2.72727275
  42055,   -21.761982,   61.3532143,   2.72727275
  42056,  -22.1146927,   60.6498718,   2.72727275
  42057,  -22.4446754,   59.9355927,   2.72727275
  42058,  -22.7515926,   59.2110977,   2.72727275
  42059,  -23.0351315,   58.4771423,   2.72727275
  42060,  -23.2950039,   57.7344742,   2.72727275
  42061,  -23.5309391,     56.98386,   2.72727275
  42062,  -23.7426929,   56.2260666,   2.72727275
  42063,   -23.930048,   55.4618759,   2.72727275
  42064,  -24.0928154,   54.6920738,   2.72727275
  42065,  -24.2308254,   53.9174538,   2.72727275
  42066,  -24.3439369,   53.1388016,   2.72727275
  42067,  -24.4320354,   52.3569298,   2.72727275
  42068,  -24.4950237,   51.5726318,   2.72727275
  42069,  -24.5328426,   50.7867203,   2.72727275
  42070,   24.5328426,   50.7867203,   3.63636374
  42071,   24.4950237,   51.5726318,   3.63636374
  42072,   24.4320354,   52.3569298,   3.63636374
  42073,   24.3439369,   53.1388016,   3.63636374
  42074,   24.2308254,   53.9174538,   3.63636374
  42075,   24.0928154,   54.6920738,   3.63636374
  42076,    23.930048,   55.4618759,   3.63636374
  42077,   23.7426929,   56.2260666,   3.63636374
  42078,   23.5309391,     56.98386,   3.63636374
  42079,   23.2950039,   57.7344742,   3.63636374
  42080,   23.0351315,   58.4771423,   3.63636374
  42081,   22.7515926,   59.2110977,   3.63636374
  42082,   22.4446754,   59.9355927,   3.63636374
  42083,   22.1146927,   60.6498718,   3.63636374
  42084,    21.761982,   61.3532143,   3.63636374
  42085,   21.3869133,   62.0448837,   3.63636374
  42086,   20.9898682,   62.7241821,   3.63636374
  42087,   20.5712528,   63.3904037,   3.63636374
  42088,   20.1315002,   64.0428619,   3.63636374
  42089,   19.6710625,   64.6808929,   3.63636374
  42090,   19.1904087,   65.3038406,   3.63636374
  42091,   18.6900368,   65.9110641,   3.63636374
  42092,   18.1704597,   66.5019302,   3.63636374
  42093,   17.6322117,   67.0758438,   3.63636374
  42094,   17.0758419,   67.6322098,   3.63636374
  42095,   16.5019302,   68.1704636,   3.63636374
  42096,   15.9110603,   68.6900406,   3.63636374
  42097,   15.3038416,   69.1904068,   3.63636374
  42098,   14.6808939,   69.6710587,   3.63636374
  42099,   14.0428638,   70.1315002,   3.63636374
  42100,   13.3904009,   70.5712509,   3.63636374
  42101,   12.7241831,   70.9898682,   3.63636374
  42102,   12.0448847,   71.3869171,   3.63636374
  42103,   11.3532124,   71.7619858,   3.63636374
  42104,   10.6498728,   72.1146927,   3.63636374
  42105,   9.93558979,   72.4446716,   3.63636374
  42106,   9.21109867,   72.7515945,   3.63636374
  42107,   8.47714138,   73.0351334,   3.63636374
  42108,   7.73447418,   73.2950058,   3.63636374
  42109,   6.98385954,   73.5309372,   3.63636374
  42110,   6.22606802,    73.742691,   3.63636374
  42111,   5.46187687,   73.9300461,   3.63636374
  42112,   4.69207525,   74.0928192,   3.63636374
  42113,   3.91745162,   74.2308273,   3.63636374
  42114,   3.13880301,   74.3439331,   3.63636374
  42115,   2.35692859,   74.4320297,   3.63636374
  42116,   1.57263267,   74.4950256,   3.63636374
  42117,  0.786720514,   74.5328445,   3.63636374
  42118,           0.,   74.5454559,   3.63636374
  42119, -0.786720514,   74.5328445,   3.63636374
  42120,  -1.57263267,   74.4950256,   3.63636374
  42121,  -2.35692859,   74.4320297,   3.63636374
  42122,  -3.13880301,   74.3439331,   3.63636374
  42123,  -3.91745162,   74.2308273,   3.63636374
  42124,  -4.69207525,   74.0928192,   3.63636374
  42125,  -5.46187687,   73.9300461,   3.63636374
  42126,  -6.22606802,    73.742691,   3.63636374
  42127,  -6.98385954,   73.5309372,   3.63636374
  42128,  -7.73447418,   73.2950058,   3.63636374
  42129,  -8.47714138,   73.0351334,   3.63636374
  42130,  -9.21109867,   72.7515945,   3.63636374
  42131,  -9.93558979,   72.4446716,   3.63636374
  42132,  -10.6498728,   72.1146927,   3.63636374
  42133,  -11.3532124,   71.7619858,   3.63636374
  42134,  -12.0448847,   71.3869171,   3.63636374
  42135,  -12.7241831,   70.9898682,   3.63636374
  42136,  -13.3904009,   70.5712509,   3.63636374
  42137,  -14.0428638,   70.1315002,   3.63636374
  42138,  -14.6808939,   69.6710587,   3.63636374
  42139,  -15.3038416,   69.1904068,   3.63636374
  42140,  -15.9110603,   68.6900406,   3.63636374
  42141,  -16.5019302,   68.1704636,   3.63636374
  42142,  -17.0758419,   67.6322098,   3.63636374
  42143,  -17.6322117,   67.0758438,   3.63636374
  42144,  -18.1704597,   66.5019302,   3.63636374
  42145,  -18.6900368,   65.9110641,   3.63636374
  42146,  -19.1904087,   65.3038406,   3.63636374
  42147,  -19.6710625,   64.6808929,   3.63636374
  42148,  -20.1315002,   64.0428619,   3.63636374
  42149,  -20.5712528,   63.3904037,   3.63636374
  42150,  -20.9898682,   62.7241821,   3.63636374
  42151,  -21.3869133,   62.0448837,   3.63636374
  42152,   -21.761982,   61.3532143,   3.63636374
  42153,  -22.1146927,   60.6498718,   3.63636374
  42154,  -22.4446754,   59.9355927,   3.63636374
  42155,  -22.7515926,   59.2110977,   3.63636374
  42156,  -23.0351315,   58.4771423,   3.63636374
  42157,  -23.2950039,   57.7344742,   3.63636374
  42158,  -23.5309391,     56.98386,   3.63636374
  42159,  -23.7426929,   56.2260666,   3.63636374
  42160,   -23.930048,   55.4618759,   3.63636374
  42161,  -24.0928154,   54.6920738,   3.63636374
  42162,  -24.2308254,   53.9174538,   3.63636374
  42163,  -24.3439369,   53.1388016,   3.63636374
  42164,  -24.4320354,   52.3569298,   3.63636374
  42165,  -24.4950237,   51.5726318,   3.63636374
  42166,  -24.5328426,   50.7867203,   3.63636374
  42167,   24.5328426,   50.7867203,    4.5454545
  42168,   24.4950237,   51.5726318,    4.5454545
  42169,   24.4320354,   52.3569298,    4.5454545
  42170,   24.3439369,   53.1388016,    4.5454545
  42171,   24.2308254,   53.9174538,    4.5454545
  42172,   24.0928154,   54.6920738,    4.5454545
  42173,    23.930048,   55.4618759,    4.5454545
  42174,   23.7426929,   56.2260666,    4.5454545
  42175,   23.5309391,     56.98386,    4.5454545
  42176,   23.2950039,   57.7344742,    4.5454545
  42177,   23.0351315,   58.4771423,    4.5454545
  42178,   22.7515926,   59.2110977,    4.5454545
  42179,   22.4446754,   59.9355927,    4.5454545
  42180,   22.1146927,   60.6498718,    4.5454545
  42181,    21.761982,   61.3532143,    4.5454545
  42182,   21.3869133,   62.0448837,    4.5454545
  42183,   20.9898682,   62.7241821,    4.5454545
  42184,   20.5712528,   63.3904037,    4.5454545
  42185,   20.1315002,   64.0428619,    4.5454545
  42186,   19.6710625,   64.6808929,    4.5454545
  42187,   19.1904087,   65.3038406,    4.5454545
  42188,   18.6900368,   65.9110641,    4.5454545
  42189,   18.1704597,   66.5019302,    4.5454545
  42190,   17.6322117,   67.0758438,    4.5454545
  42191,   17.0758419,   67.6322098,    4.5454545
  42192,   16.5019302,   68.1704636,    4.5454545
  42193,   15.9110603,   68.6900406,    4.5454545
  42194,   15.3038416,   69.1904068,    4.5454545
  42195,   14.6808939,   69.6710587,    4.5454545
  42196,   14.0428638,   70.1315002,    4.5454545
  42197,   13.3904009,   70.5712509,    4.5454545
  42198,   12.7241831,   70.9898682,    4.5454545
  42199,   12.0448847,   71.3869171,    4.5454545
  42200,   11.3532124,   71.7619858,    4.5454545
  42201,   10.6498728,   72.1146927,    4.5454545
  42202,   9.93558979,   72.4446716,    4.5454545
  42203,   9.21109867,   72.7515945,    4.5454545
  42204,   8.47714138,   73.0351334,    4.5454545
  42205,   7.73447418,   73.2950058,    4.5454545
  42206,   6.98385954,   73.5309372,    4.5454545
  42207,   6.22606802,    73.742691,    4.5454545
  42208,   5.46187687,   73.9300461,    4.5454545
  42209,   4.69207525,   74.0928192,    4.5454545
  42210,   3.91745162,   74.2308273,    4.5454545
  42211,   3.13880301,   74.3439331,    4.5454545
  42212,   2.35692859,   74.4320297,    4.5454545
  42213,   1.57263267,   74.4950256,    4.5454545
  42214,  0.786720514,   74.5328445,    4.5454545
  42215,           0.,   74.5454559,    4.5454545
  42216, -0.786720514,   74.5328445,    4.5454545
  42217,  -1.57263267,   74.4950256,    4.5454545
  42218,  -2.35692859,   74.4320297,    4.5454545
  42219,  -3.13880301,   74.3439331,    4.5454545
  42220,  -3.91745162,   74.2308273,    4.5454545
  42221,  -4.69207525,   74.0928192,    4.5454545
  42222,  -5.46187687,   73.9300461,    4.5454545
  42223,  -6.22606802,    73.742691,    4.5454545
  42224,  -6.98385954,   73.5309372,    4.5454545
  42225,  -7.73447418,   73.2950058,    4.5454545
  42226,  -8.47714138,   73.0351334,    4.5454545
  42227,  -9.21109867,   72.7515945,    4.5454545
  42228,  -9.93558979,   72.4446716,    4.5454545
  42229,  -10.6498728,   72.1146927,    4.5454545
  42230,  -11.3532124,   71.7619858,    4.5454545
  42231,  -12.0448847,   71.3869171,    4.5454545
  42232,  -12.7241831,   70.9898682,    4.5454545
  42233,  -13.3904009,   70.5712509,    4.5454545
  42234,  -14.0428638,   70.1315002,    4.5454545
  42235,  -14.6808939,   69.6710587,    4.5454545
  42236,  -15.3038416,   69.1904068,    4.5454545
  42237,  -15.9110603,   68.6900406,    4.5454545
  42238,  -16.5019302,   68.1704636,    4.5454545
  42239,  -17.0758419,   67.6322098,    4.5454545
  42240,  -17.6322117,   67.0758438,    4.5454545
  42241,  -18.1704597,   66.5019302,    4.5454545
  42242,  -18.6900368,   65.9110641,    4.5454545
  42243,  -19.1904087,   65.3038406,    4.5454545
  42244,  -19.6710625,   64.6808929,    4.5454545
  42245,  -20.1315002,   64.0428619,    4.5454545
  42246,  -20.5712528,   63.3904037,    4.5454545
  42247,  -20.9898682,   62.7241821,    4.5454545
  42248,  -21.3869133,   62.0448837,    4.5454545
  42249,   -21.761982,   61.3532143,    4.5454545
  42250,  -22.1146927,   60.6498718,    4.5454545
  42251,  -22.4446754,   59.9355927,    4.5454545
  42252,  -22.7515926,   59.2110977,    4.5454545
  42253,  -23.0351315,   58.4771423,    4.5454545
  42254,  -23.2950039,   57.7344742,    4.5454545
  42255,  -23.5309391,     56.98386,    4.5454545
  42256,  -23.7426929,   56.2260666,    4.5454545
  42257,   -23.930048,   55.4618759,    4.5454545
  42258,  -24.0928154,   54.6920738,    4.5454545
  42259,  -24.2308254,   53.9174538,    4.5454545
  42260,  -24.3439369,   53.1388016,    4.5454545
  42261,  -24.4320354,   52.3569298,    4.5454545
  42262,  -24.4950237,   51.5726318,    4.5454545
  42263,  -24.5328426,   50.7867203,    4.5454545
  42264,   24.5328426,   50.7867203,    5.4545455
  42265,   24.4950237,   51.5726318,    5.4545455
  42266,   24.4320354,   52.3569298,    5.4545455
  42267,   24.3439369,   53.1388016,    5.4545455
  42268,   24.2308254,   53.9174538,    5.4545455
  42269,   24.0928154,   54.6920738,    5.4545455
  42270,    23.930048,   55.4618759,    5.4545455
  42271,   23.7426929,   56.2260666,    5.4545455
  42272,   23.5309391,     56.98386,    5.4545455
  42273,   23.2950039,   57.7344742,    5.4545455
  42274,   23.0351315,   58.4771423,    5.4545455
  42275,   22.7515926,   59.2110977,    5.4545455
  42276,   22.4446754,   59.9355927,    5.4545455
  42277,   22.1146927,   60.6498718,    5.4545455
  42278,    21.761982,   61.3532143,    5.4545455
  42279,   21.3869133,   62.0448837,    5.4545455
  42280,   20.9898682,   62.7241821,    5.4545455
  42281,   20.5712528,   63.3904037,    5.4545455
  42282,   20.1315002,   64.0428619,    5.4545455
  42283,   19.6710625,   64.6808929,    5.4545455
  42284,   19.1904087,   65.3038406,    5.4545455
  42285,   18.6900368,   65.9110641,    5.4545455
  42286,   18.1704597,   66.5019302,    5.4545455
  42287,   17.6322117,   67.0758438,    5.4545455
  42288,   17.0758419,   67.6322098,    5.4545455
  42289,   16.5019302,   68.1704636,    5.4545455
  42290,   15.9110603,   68.6900406,    5.4545455
  42291,   15.3038416,   69.1904068,    5.4545455
  42292,   14.6808939,   69.6710587,    5.4545455
  42293,   14.0428638,   70.1315002,    5.4545455
  42294,   13.3904009,   70.5712509,    5.4545455
  42295,   12.7241831,   70.9898682,    5.4545455
  42296,   12.0448847,   71.3869171,    5.4545455
  42297,   11.3532124,   71.7619858,    5.4545455
  42298,   10.6498728,   72.1146927,    5.4545455
  42299,   9.93558979,   72.4446716,    5.4545455
  42300,   9.21109867,   72.7515945,    5.4545455
  42301,   8.47714138,   73.0351334,    5.4545455
  42302,   7.73447418,   73.2950058,    5.4545455
  42303,   6.98385954,   73.5309372,    5.4545455
  42304,   6.22606802,    73.742691,    5.4545455
  42305,   5.46187687,   73.9300461,    5.4545455
  42306,   4.69207525,   74.0928192,    5.4545455
  42307,   3.91745162,   74.2308273,    5.4545455
  42308,   3.13880301,   74.3439331,    5.4545455
  42309,   2.35692859,   74.4320297,    5.4545455
  42310,   1.57263267,   74.4950256,    5.4545455
  42311,  0.786720514,   74.5328445,    5.4545455
  42312,           0.,   74.5454559,    5.4545455
  42313, -0.786720514,   74.5328445,    5.4545455
  42314,  -1.57263267,   74.4950256,    5.4545455
  42315,  -2.35692859,   74.4320297,    5.4545455
  42316,  -3.13880301,   74.3439331,    5.4545455
  42317,  -3.91745162,   74.2308273,    5.4545455
  42318,  -4.69207525,   74.0928192,    5.4545455
  42319,  -5.46187687,   73.9300461,    5.4545455
  42320,  -6.22606802,    73.742691,    5.4545455
  42321,  -6.98385954,   73.5309372,    5.4545455
  42322,  -7.73447418,   73.2950058,    5.4545455
  42323,  -8.47714138,   73.0351334,    5.4545455
  42324,  -9.21109867,   72.7515945,    5.4545455
  42325,  -9.93558979,   72.4446716,    5.4545455
  42326,  -10.6498728,   72.1146927,    5.4545455
  42327,  -11.3532124,   71.7619858,    5.4545455
  42328,  -12.0448847,   71.3869171,    5.4545455
  42329,  -12.7241831,   70.9898682,    5.4545455
  42330,  -13.3904009,   70.5712509,    5.4545455
  42331,  -14.0428638,   70.1315002,    5.4545455
  42332,  -14.6808939,   69.6710587,    5.4545455
  42333,  -15.3038416,   69.1904068,    5.4545455
  42334,  -15.9110603,   68.6900406,    5.4545455
  42335,  -16.5019302,   68.1704636,    5.4545455
  42336,  -17.0758419,   67.6322098,    5.4545455
  42337,  -17.6322117,   67.0758438,    5.4545455
  42338,  -18.1704597,   66.5019302,    5.4545455
  42339,  -18.6900368,   65.9110641,    5.4545455
  42340,  -19.1904087,   65.3038406,    5.4545455
  42341,  -19.6710625,   64.6808929,    5.4545455
  42342,  -20.1315002,   64.0428619,    5.4545455
  42343,  -20.5712528,   63.3904037,    5.4545455
  42344,  -20.9898682,   62.7241821,    5.4545455
  42345,  -21.3869133,   62.0448837,    5.4545455
  42346,   -21.761982,   61.3532143,    5.4545455
  42347,  -22.1146927,   60.6498718,    5.4545455
  42348,  -22.4446754,   59.9355927,    5.4545455
  42349,  -22.7515926,   59.2110977,    5.4545455
  42350,  -23.0351315,   58.4771423,    5.4545455
  42351,  -23.2950039,   57.7344742,    5.4545455
  42352,  -23.5309391,     56.98386,    5.4545455
  42353,  -23.7426929,   56.2260666,    5.4545455
  42354,   -23.930048,   55.4618759,    5.4545455
  42355,  -24.0928154,   54.6920738,    5.4545455
  42356,  -24.2308254,   53.9174538,    5.4545455
  42357,  -24.3439369,   53.1388016,    5.4545455
  42358,  -24.4320354,   52.3569298,    5.4545455
  42359,  -24.4950237,   51.5726318,    5.4545455
  42360,  -24.5328426,   50.7867203,    5.4545455
  42361,   24.5328426,   50.7867203,   6.36363649
  42362,   24.4950237,   51.5726318,   6.36363649
  42363,   24.4320354,   52.3569298,   6.36363649
  42364,   24.3439369,   53.1388016,   6.36363649
  42365,   24.2308254,   53.9174538,   6.36363649
  42366,   24.0928154,   54.6920738,   6.36363649
  42367,    23.930048,   55.4618759,   6.36363649
  42368,   23.7426929,   56.2260666,   6.36363649
  42369,   23.5309391,     56.98386,   6.36363649
  42370,   23.2950039,   57.7344742,   6.36363649
  42371,   23.0351315,   58.4771423,   6.36363649
  42372,   22.7515926,   59.2110977,   6.36363649
  42373,   22.4446754,   59.9355927,   6.36363649
  42374,   22.1146927,   60.6498718,   6.36363649
  42375,    21.761982,   61.3532143,   6.36363649
  42376,   21.3869133,   62.0448837,   6.36363649
  42377,   20.9898682,   62.7241821,   6.36363649
  42378,   20.5712528,   63.3904037,   6.36363649
  42379,   20.1315002,   64.0428619,   6.36363649
  42380,   19.6710625,   64.6808929,   6.36363649
  42381,   19.1904087,   65.3038406,   6.36363649
  42382,   18.6900368,   65.9110641,   6.36363649
  42383,   18.1704597,   66.5019302,   6.36363649
  42384,   17.6322117,   67.0758438,   6.36363649
  42385,   17.0758419,   67.6322098,   6.36363649
  42386,   16.5019302,   68.1704636,   6.36363649
  42387,   15.9110603,   68.6900406,   6.36363649
  42388,   15.3038416,   69.1904068,   6.36363649
  42389,   14.6808939,   69.6710587,   6.36363649
  42390,   14.0428638,   70.1315002,   6.36363649
  42391,   13.3904009,   70.5712509,   6.36363649
  42392,   12.7241831,   70.9898682,   6.36363649
  42393,   12.0448847,   71.3869171,   6.36363649
  42394,   11.3532124,   71.7619858,   6.36363649
  42395,   10.6498728,   72.1146927,   6.36363649
  42396,   9.93558979,   72.4446716,   6.36363649
  42397,   9.21109867,   72.7515945,   6.36363649
  42398,   8.47714138,   73.0351334,   6.36363649
  42399,   7.73447418,   73.2950058,   6.36363649
  42400,   6.98385954,   73.5309372,   6.36363649
  42401,   6.22606802,    73.742691,   6.36363649
  42402,   5.46187687,   73.9300461,   6.36363649
  42403,   4.69207525,   74.0928192,   6.36363649
  42404,   3.91745162,   74.2308273,   6.36363649
  42405,   3.13880301,   74.3439331,   6.36363649
  42406,   2.35692859,   74.4320297,   6.36363649
  42407,   1.57263267,   74.4950256,   6.36363649
  42408,  0.786720514,   74.5328445,   6.36363649
  42409,           0.,   74.5454559,   6.36363649
  42410, -0.786720514,   74.5328445,   6.36363649
  42411,  -1.57263267,   74.4950256,   6.36363649
  42412,  -2.35692859,   74.4320297,   6.36363649
  42413,  -3.13880301,   74.3439331,   6.36363649
  42414,  -3.91745162,   74.2308273,   6.36363649
  42415,  -4.69207525,   74.0928192,   6.36363649
  42416,  -5.46187687,   73.9300461,   6.36363649
  42417,  -6.22606802,    73.742691,   6.36363649
  42418,  -6.98385954,   73.5309372,   6.36363649
  42419,  -7.73447418,   73.2950058,   6.36363649
  42420,  -8.47714138,   73.0351334,   6.36363649
  42421,  -9.21109867,   72.7515945,   6.36363649
  42422,  -9.93558979,   72.4446716,   6.36363649
  42423,  -10.6498728,   72.1146927,   6.36363649
  42424,  -11.3532124,   71.7619858,   6.36363649
  42425,  -12.0448847,   71.3869171,   6.36363649
  42426,  -12.7241831,   70.9898682,   6.36363649
  42427,  -13.3904009,   70.5712509,   6.36363649
  42428,  -14.0428638,   70.1315002,   6.36363649
  42429,  -14.6808939,   69.6710587,   6.36363649
  42430,  -15.3038416,   69.1904068,   6.36363649
  42431,  -15.9110603,   68.6900406,   6.36363649
  42432,  -16.5019302,   68.1704636,   6.36363649
  42433,  -17.0758419,   67.6322098,   6.36363649
  42434,  -17.6322117,   67.0758438,   6.36363649
  42435,  -18.1704597,   66.5019302,   6.36363649
  42436,  -18.6900368,   65.9110641,   6.36363649
  42437,  -19.1904087,   65.3038406,   6.36363649
  42438,  -19.6710625,   64.6808929,   6.36363649
  42439,  -20.1315002,   64.0428619,   6.36363649
  42440,  -20.5712528,   63.3904037,   6.36363649
  42441,  -20.9898682,   62.7241821,   6.36363649
  42442,  -21.3869133,   62.0448837,   6.36363649
  42443,   -21.761982,   61.3532143,   6.36363649
  42444,  -22.1146927,   60.6498718,   6.36363649
  42445,  -22.4446754,   59.9355927,   6.36363649
  42446,  -22.7515926,   59.2110977,   6.36363649
  42447,  -23.0351315,   58.4771423,   6.36363649
  42448,  -23.2950039,   57.7344742,   6.36363649
  42449,  -23.5309391,     56.98386,   6.36363649
  42450,  -23.7426929,   56.2260666,   6.36363649
  42451,   -23.930048,   55.4618759,   6.36363649
  42452,  -24.0928154,   54.6920738,   6.36363649
  42453,  -24.2308254,   53.9174538,   6.36363649
  42454,  -24.3439369,   53.1388016,   6.36363649
  42455,  -24.4320354,   52.3569298,   6.36363649
  42456,  -24.4950237,   51.5726318,   6.36363649
  42457,  -24.5328426,   50.7867203,   6.36363649
  42458,   24.5328426,   50.7867203,   7.27272749
  42459,   24.4950237,   51.5726318,   7.27272749
  42460,   24.4320354,   52.3569298,   7.27272749
  42461,   24.3439369,   53.1388016,   7.27272749
  42462,   24.2308254,   53.9174538,   7.27272749
  42463,   24.0928154,   54.6920738,   7.27272749
  42464,    23.930048,   55.4618759,   7.27272749
  42465,   23.7426929,   56.2260666,   7.27272749
  42466,   23.5309391,     56.98386,   7.27272749
  42467,   23.2950039,   57.7344742,   7.27272749
  42468,   23.0351315,   58.4771423,   7.27272749
  42469,   22.7515926,   59.2110977,   7.27272749
  42470,   22.4446754,   59.9355927,   7.27272749
  42471,   22.1146927,   60.6498718,   7.27272749
  42472,    21.761982,   61.3532143,   7.27272749
  42473,   21.3869133,   62.0448837,   7.27272749
  42474,   20.9898682,   62.7241821,   7.27272749
  42475,   20.5712528,   63.3904037,   7.27272749
  42476,   20.1315002,   64.0428619,   7.27272749
  42477,   19.6710625,   64.6808929,   7.27272749
  42478,   19.1904087,   65.3038406,   7.27272749
  42479,   18.6900368,   65.9110641,   7.27272749
  42480,   18.1704597,   66.5019302,   7.27272749
  42481,   17.6322117,   67.0758438,   7.27272749
  42482,   17.0758419,   67.6322098,   7.27272749
  42483,   16.5019302,   68.1704636,   7.27272749
  42484,   15.9110603,   68.6900406,   7.27272749
  42485,   15.3038416,   69.1904068,   7.27272749
  42486,   14.6808939,   69.6710587,   7.27272749
  42487,   14.0428638,   70.1315002,   7.27272749
  42488,   13.3904009,   70.5712509,   7.27272749
  42489,   12.7241831,   70.9898682,   7.27272749
  42490,   12.0448847,   71.3869171,   7.27272749
  42491,   11.3532124,   71.7619858,   7.27272749
  42492,   10.6498728,   72.1146927,   7.27272749
  42493,   9.93558979,   72.4446716,   7.27272749
  42494,   9.21109867,   72.7515945,   7.27272749
  42495,   8.47714138,   73.0351334,   7.27272749
  42496,   7.73447418,   73.2950058,   7.27272749
  42497,   6.98385954,   73.5309372,   7.27272749
  42498,   6.22606802,    73.742691,   7.27272749
  42499,   5.46187687,   73.9300461,   7.27272749
  42500,   4.69207525,   74.0928192,   7.27272749
  42501,   3.91745162,   74.2308273,   7.27272749
  42502,   3.13880301,   74.3439331,   7.27272749
  42503,   2.35692859,   74.4320297,   7.27272749
  42504,   1.57263267,   74.4950256,   7.27272749
  42505,  0.786720514,   74.5328445,   7.27272749
  42506,           0.,   74.5454559,   7.27272749
  42507, -0.786720514,   74.5328445,   7.27272749
  42508,  -1.57263267,   74.4950256,   7.27272749
  42509,  -2.35692859,   74.4320297,   7.27272749
  42510,  -3.13880301,   74.3439331,   7.27272749
  42511,  -3.91745162,   74.2308273,   7.27272749
  42512,  -4.69207525,   74.0928192,   7.27272749
  42513,  -5.46187687,   73.9300461,   7.27272749
  42514,  -6.22606802,    73.742691,   7.27272749
  42515,  -6.98385954,   73.5309372,   7.27272749
  42516,  -7.73447418,   73.2950058,   7.27272749
  42517,  -8.47714138,   73.0351334,   7.27272749
  42518,  -9.21109867,   72.7515945,   7.27272749
  42519,  -9.93558979,   72.4446716,   7.27272749
  42520,  -10.6498728,   72.1146927,   7.27272749
  42521,  -11.3532124,   71.7619858,   7.27272749
  42522,  -12.0448847,   71.3869171,   7.27272749
  42523,  -12.7241831,   70.9898682,   7.27272749
  42524,  -13.3904009,   70.5712509,   7.27272749
  42525,  -14.0428638,   70.1315002,   7.27272749
  42526,  -14.6808939,   69.6710587,   7.27272749
  42527,  -15.3038416,   69.1904068,   7.27272749
  42528,  -15.9110603,   68.6900406,   7.27272749
  42529,  -16.5019302,   68.1704636,   7.27272749
  42530,  -17.0758419,   67.6322098,   7.27272749
  42531,  -17.6322117,   67.0758438,   7.27272749
  42532,  -18.1704597,   66.5019302,   7.27272749
  42533,  -18.6900368,   65.9110641,   7.27272749
  42534,  -19.1904087,   65.3038406,   7.27272749
  42535,  -19.6710625,   64.6808929,   7.27272749
  42536,  -20.1315002,   64.0428619,   7.27272749
  42537,  -20.5712528,   63.3904037,   7.27272749
  42538,  -20.9898682,   62.7241821,   7.27272749
  42539,  -21.3869133,   62.0448837,   7.27272749
  42540,   -21.761982,   61.3532143,   7.27272749
  42541,  -22.1146927,   60.6498718,   7.27272749
  42542,  -22.4446754,   59.9355927,   7.27272749
  42543,  -22.7515926,   59.2110977,   7.27272749
  42544,  -23.0351315,   58.4771423,   7.27272749
  42545,  -23.2950039,   57.7344742,   7.27272749
  42546,  -23.5309391,     56.98386,   7.27272749
  42547,  -23.7426929,   56.2260666,   7.27272749
  42548,   -23.930048,   55.4618759,   7.27272749
  42549,  -24.0928154,   54.6920738,   7.27272749
  42550,  -24.2308254,   53.9174538,   7.27272749
  42551,  -24.3439369,   53.1388016,   7.27272749
  42552,  -24.4320354,   52.3569298,   7.27272749
  42553,  -24.4950237,   51.5726318,   7.27272749
  42554,  -24.5328426,   50.7867203,   7.27272749
  42555,   24.5328426,   50.7867203,   8.18181801
  42556,   24.4950237,   51.5726318,   8.18181801
  42557,   24.4320354,   52.3569298,   8.18181801
  42558,   24.3439369,   53.1388016,   8.18181801
  42559,   24.2308254,   53.9174538,   8.18181801
  42560,   24.0928154,   54.6920738,   8.18181801
  42561,    23.930048,   55.4618759,   8.18181801
  42562,   23.7426929,   56.2260666,   8.18181801
  42563,   23.5309391,     56.98386,   8.18181801
  42564,   23.2950039,   57.7344742,   8.18181801
  42565,   23.0351315,   58.4771423,   8.18181801
  42566,   22.7515926,   59.2110977,   8.18181801
  42567,   22.4446754,   59.9355927,   8.18181801
  42568,   22.1146927,   60.6498718,   8.18181801
  42569,    21.761982,   61.3532143,   8.18181801
  42570,   21.3869133,   62.0448837,   8.18181801
  42571,   20.9898682,   62.7241821,   8.18181801
  42572,   20.5712528,   63.3904037,   8.18181801
  42573,   20.1315002,   64.0428619,   8.18181801
  42574,   19.6710625,   64.6808929,   8.18181801
  42575,   19.1904087,   65.3038406,   8.18181801
  42576,   18.6900368,   65.9110641,   8.18181801
  42577,   18.1704597,   66.5019302,   8.18181801
  42578,   17.6322117,   67.0758438,   8.18181801
  42579,   17.0758419,   67.6322098,   8.18181801
  42580,   16.5019302,   68.1704636,   8.18181801
  42581,   15.9110603,   68.6900406,   8.18181801
  42582,   15.3038416,   69.1904068,   8.18181801
  42583,   14.6808939,   69.6710587,   8.18181801
  42584,   14.0428638,   70.1315002,   8.18181801
  42585,   13.3904009,   70.5712509,   8.18181801
  42586,   12.7241831,   70.9898682,   8.18181801
  42587,   12.0448847,   71.3869171,   8.18181801
  42588,   11.3532124,   71.7619858,   8.18181801
  42589,   10.6498728,   72.1146927,   8.18181801
  42590,   9.93558979,   72.4446716,   8.18181801
  42591,   9.21109867,   72.7515945,   8.18181801
  42592,   8.47714138,   73.0351334,   8.18181801
  42593,   7.73447418,   73.2950058,   8.18181801
  42594,   6.98385954,   73.5309372,   8.18181801
  42595,   6.22606802,    73.742691,   8.18181801
  42596,   5.46187687,   73.9300461,   8.18181801
  42597,   4.69207525,   74.0928192,   8.18181801
  42598,   3.91745162,   74.2308273,   8.18181801
  42599,   3.13880301,   74.3439331,   8.18181801
  42600,   2.35692859,   74.4320297,   8.18181801
  42601,   1.57263267,   74.4950256,   8.18181801
  42602,  0.786720514,   74.5328445,   8.18181801
  42603,           0.,   74.5454559,   8.18181801
  42604, -0.786720514,   74.5328445,   8.18181801
  42605,  -1.57263267,   74.4950256,   8.18181801
  42606,  -2.35692859,   74.4320297,   8.18181801
  42607,  -3.13880301,   74.3439331,   8.18181801
  42608,  -3.91745162,   74.2308273,   8.18181801
  42609,  -4.69207525,   74.0928192,   8.18181801
  42610,  -5.46187687,   73.9300461,   8.18181801
  42611,  -6.22606802,    73.742691,   8.18181801
  42612,  -6.98385954,   73.5309372,   8.18181801
  42613,  -7.73447418,   73.2950058,   8.18181801
  42614,  -8.47714138,   73.0351334,   8.18181801
  42615,  -9.21109867,   72.7515945,   8.18181801
  42616,  -9.93558979,   72.4446716,   8.18181801
  42617,  -10.6498728,   72.1146927,   8.18181801
  42618,  -11.3532124,   71.7619858,   8.18181801
  42619,  -12.0448847,   71.3869171,   8.18181801
  42620,  -12.7241831,   70.9898682,   8.18181801
  42621,  -13.3904009,   70.5712509,   8.18181801
  42622,  -14.0428638,   70.1315002,   8.18181801
  42623,  -14.6808939,   69.6710587,   8.18181801
  42624,  -15.3038416,   69.1904068,   8.18181801
  42625,  -15.9110603,   68.6900406,   8.18181801
  42626,  -16.5019302,   68.1704636,   8.18181801
  42627,  -17.0758419,   67.6322098,   8.18181801
  42628,  -17.6322117,   67.0758438,   8.18181801
  42629,  -18.1704597,   66.5019302,   8.18181801
  42630,  -18.6900368,   65.9110641,   8.18181801
  42631,  -19.1904087,   65.3038406,   8.18181801
  42632,  -19.6710625,   64.6808929,   8.18181801
  42633,  -20.1315002,   64.0428619,   8.18181801
  42634,  -20.5712528,   63.3904037,   8.18181801
  42635,  -20.9898682,   62.7241821,   8.18181801
  42636,  -21.3869133,   62.0448837,   8.18181801
  42637,   -21.761982,   61.3532143,   8.18181801
  42638,  -22.1146927,   60.6498718,   8.18181801
  42639,  -22.4446754,   59.9355927,   8.18181801
  42640,  -22.7515926,   59.2110977,   8.18181801
  42641,  -23.0351315,   58.4771423,   8.18181801
  42642,  -23.2950039,   57.7344742,   8.18181801
  42643,  -23.5309391,     56.98386,   8.18181801
  42644,  -23.7426929,   56.2260666,   8.18181801
  42645,   -23.930048,   55.4618759,   8.18181801
  42646,  -24.0928154,   54.6920738,   8.18181801
  42647,  -24.2308254,   53.9174538,   8.18181801
  42648,  -24.3439369,   53.1388016,   8.18181801
  42649,  -24.4320354,   52.3569298,   8.18181801
  42650,  -24.4950237,   51.5726318,   8.18181801
  42651,  -24.5328426,   50.7867203,   8.18181801
  42652,   24.5328426,   50.7867203,     9.090909
  42653,   24.4950237,   51.5726318,     9.090909
  42654,   24.4320354,   52.3569298,     9.090909
  42655,   24.3439369,   53.1388016,     9.090909
  42656,   24.2308254,   53.9174538,     9.090909
  42657,   24.0928154,   54.6920738,     9.090909
  42658,    23.930048,   55.4618759,     9.090909
  42659,   23.7426929,   56.2260666,     9.090909
  42660,   23.5309391,     56.98386,     9.090909
  42661,   23.2950039,   57.7344742,     9.090909
  42662,   23.0351315,   58.4771423,     9.090909
  42663,   22.7515926,   59.2110977,     9.090909
  42664,   22.4446754,   59.9355927,     9.090909
  42665,   22.1146927,   60.6498718,     9.090909
  42666,    21.761982,   61.3532143,     9.090909
  42667,   21.3869133,   62.0448837,     9.090909
  42668,   20.9898682,   62.7241821,     9.090909
  42669,   20.5712528,   63.3904037,     9.090909
  42670,   20.1315002,   64.0428619,     9.090909
  42671,   19.6710625,   64.6808929,     9.090909
  42672,   19.1904087,   65.3038406,     9.090909
  42673,   18.6900368,   65.9110641,     9.090909
  42674,   18.1704597,   66.5019302,     9.090909
  42675,   17.6322117,   67.0758438,     9.090909
  42676,   17.0758419,   67.6322098,     9.090909
  42677,   16.5019302,   68.1704636,     9.090909
  42678,   15.9110603,   68.6900406,     9.090909
  42679,   15.3038416,   69.1904068,     9.090909
  42680,   14.6808939,   69.6710587,     9.090909
  42681,   14.0428638,   70.1315002,     9.090909
  42682,   13.3904009,   70.5712509,     9.090909
  42683,   12.7241831,   70.9898682,     9.090909
  42684,   12.0448847,   71.3869171,     9.090909
  42685,   11.3532124,   71.7619858,     9.090909
  42686,   10.6498728,   72.1146927,     9.090909
  42687,   9.93558979,   72.4446716,     9.090909
  42688,   9.21109867,   72.7515945,     9.090909
  42689,   8.47714138,   73.0351334,     9.090909
  42690,   7.73447418,   73.2950058,     9.090909
  42691,   6.98385954,   73.5309372,     9.090909
  42692,   6.22606802,    73.742691,     9.090909
  42693,   5.46187687,   73.9300461,     9.090909
  42694,   4.69207525,   74.0928192,     9.090909
  42695,   3.91745162,   74.2308273,     9.090909
  42696,   3.13880301,   74.3439331,     9.090909
  42697,   2.35692859,   74.4320297,     9.090909
  42698,   1.57263267,   74.4950256,     9.090909
  42699,  0.786720514,   74.5328445,     9.090909
  42700,           0.,   74.5454559,     9.090909
  42701, -0.786720514,   74.5328445,     9.090909
  42702,  -1.57263267,   74.4950256,     9.090909
  42703,  -2.35692859,   74.4320297,     9.090909
  42704,  -3.13880301,   74.3439331,     9.090909
  42705,  -3.91745162,   74.2308273,     9.090909
  42706,  -4.69207525,   74.0928192,     9.090909
  42707,  -5.46187687,   73.9300461,     9.090909
  42708,  -6.22606802,    73.742691,     9.090909
  42709,  -6.98385954,   73.5309372,     9.090909
  42710,  -7.73447418,   73.2950058,     9.090909
  42711,  -8.47714138,   73.0351334,     9.090909
  42712,  -9.21109867,   72.7515945,     9.090909
  42713,  -9.93558979,   72.4446716,     9.090909
  42714,  -10.6498728,   72.1146927,     9.090909
  42715,  -11.3532124,   71.7619858,     9.090909
  42716,  -12.0448847,   71.3869171,     9.090909
  42717,  -12.7241831,   70.9898682,     9.090909
  42718,  -13.3904009,   70.5712509,     9.090909
  42719,  -14.0428638,   70.1315002,     9.090909
  42720,  -14.6808939,   69.6710587,     9.090909
  42721,  -15.3038416,   69.1904068,     9.090909
  42722,  -15.9110603,   68.6900406,     9.090909
  42723,  -16.5019302,   68.1704636,     9.090909
  42724,  -17.0758419,   67.6322098,     9.090909
  42725,  -17.6322117,   67.0758438,     9.090909
  42726,  -18.1704597,   66.5019302,     9.090909
  42727,  -18.6900368,   65.9110641,     9.090909
  42728,  -19.1904087,   65.3038406,     9.090909
  42729,  -19.6710625,   64.6808929,     9.090909
  42730,  -20.1315002,   64.0428619,     9.090909
  42731,  -20.5712528,   63.3904037,     9.090909
  42732,  -20.9898682,   62.7241821,     9.090909
  42733,  -21.3869133,   62.0448837,     9.090909
  42734,   -21.761982,   61.3532143,     9.090909
  42735,  -22.1146927,   60.6498718,     9.090909
  42736,  -22.4446754,   59.9355927,     9.090909
  42737,  -22.7515926,   59.2110977,     9.090909
  42738,  -23.0351315,   58.4771423,     9.090909
  42739,  -23.2950039,   57.7344742,     9.090909
  42740,  -23.5309391,     56.98386,     9.090909
  42741,  -23.7426929,   56.2260666,     9.090909
  42742,   -23.930048,   55.4618759,     9.090909
  42743,  -24.0928154,   54.6920738,     9.090909
  42744,  -24.2308254,   53.9174538,     9.090909
  42745,  -24.3439369,   53.1388016,     9.090909
  42746,  -24.4320354,   52.3569298,     9.090909
  42747,  -24.4950237,   51.5726318,     9.090909
  42748,  -24.5328426,   50.7867203,     9.090909
  42749,   23.6242199,   50.7575836,  0.909090936
  42750,    23.587801,   51.5143852,  0.909090936
  42751,   23.5271454,   52.2696342,  0.909090936
  42752,   23.4423103,   53.0225525,  0.909090936
  42753,   23.3333874,   53.7723618,  0.909090936
  42754,    23.200489,   54.5182953,  0.909090936
  42755,   23.0437508,   55.2595863,  0.909090936
  42756,   22.8633327,    55.995472,  0.909090936
  42757,   22.6594219,   56.7251968,  0.909090936
  42758,   22.4322262,   57.4480133,  0.909090936
  42759,   22.1819782,   58.1631737,  0.909090936
  42760,   21.9089413,   58.8699455,  0.909090936
  42761,   21.6133919,   59.5676079,  0.909090936
  42762,   21.2956295,   60.2554321,  0.909090936
  42763,   20.9559822,    60.932724,  0.909090936
  42764,   20.5948067,   61.5987778,  0.909090936
  42765,   20.2124653,   62.2529144,  0.909090936
  42766,   19.8093548,   62.8944626,  0.909090936
  42767,   19.3858891,   63.5227585,  0.909090936
  42768,    18.942503,   64.1371613,  0.909090936
  42769,   18.4796524,     64.73703,  0.909090936
  42770,   17.9978142,   65.3217621,  0.909090936
  42771,   17.4974804,   65.8907471,  0.909090936
  42772,    16.979166,   66.4434052,  0.909090936
  42773,   16.4434032,   66.9791641,  0.909090936
  42774,    15.890748,   67.4974823,  0.909090936
  42775,   15.3217621,   67.9978104,  0.909090936
  42776,   14.7370329,   68.4796524,  0.909090936
  42777,   14.1371574,   68.9425049,  0.909090936
  42778,   13.5227575,   69.3858871,  0.909090936
  42779,   12.8944607,   69.8093567,  0.909090936
  42780,   12.2529173,   70.2124634,  0.909090936
  42781,   11.5987778,   70.5948029,  0.909090936
  42782,    10.932723,    70.955986,  0.909090936
  42783,   10.2554331,   71.2956314,  0.909090936
  42784,   9.56760502,   71.6133881,  0.909090936
  42785,   8.86994648,   71.9089432,  0.909090936
  42786,   8.16317272,   72.1819839,  0.909090936
  42787,   7.44801188,   72.4322281,  0.909090936
  42788,   6.72519779,   72.6594238,  0.909090936
  42789,   5.99547291,   72.8633347,  0.909090936
  42790,   5.25958538,   73.0437469,  0.909090936
  42791,   4.51829529,   73.2004929,  0.909090936
  42792,    3.7723608,   73.3333893,  0.909090936
  42793,   3.02255106,   73.4423065,  0.909090936
  42794,   2.26963496,   73.5271454,  0.909090936
  42795,   1.51438701,   73.5877991,  0.909090936
  42796,  0.757582724,   73.6242218,  0.909090936
  42797,           0.,   73.6363602,  0.909090936
  42798, -0.757582724,   73.6242218,  0.909090936
  42799,  -1.51438701,   73.5877991,  0.909090936
  42800,  -2.26963496,   73.5271454,  0.909090936
  42801,  -3.02255106,   73.4423065,  0.909090936
  42802,   -3.7723608,   73.3333893,  0.909090936
  42803,  -4.51829529,   73.2004929,  0.909090936
  42804,  -5.25958538,   73.0437469,  0.909090936
  42805,  -5.99547291,   72.8633347,  0.909090936
  42806,  -6.72519779,   72.6594238,  0.909090936
  42807,  -7.44801188,   72.4322281,  0.909090936
  42808,  -8.16317272,   72.1819839,  0.909090936
  42809,  -8.86994648,   71.9089432,  0.909090936
  42810,  -9.56760502,   71.6133881,  0.909090936
  42811,  -10.2554331,   71.2956314,  0.909090936
  42812,   -10.932723,    70.955986,  0.909090936
  42813,  -11.5987778,   70.5948029,  0.909090936
  42814,  -12.2529173,   70.2124634,  0.909090936
  42815,  -12.8944607,   69.8093567,  0.909090936
  42816,  -13.5227575,   69.3858871,  0.909090936
  42817,  -14.1371574,   68.9425049,  0.909090936
  42818,  -14.7370329,   68.4796524,  0.909090936
  42819,  -15.3217621,   67.9978104,  0.909090936
  42820,   -15.890748,   67.4974823,  0.909090936
  42821,  -16.4434032,   66.9791641,  0.909090936
  42822,   -16.979166,   66.4434052,  0.909090936
  42823,  -17.4974804,   65.8907471,  0.909090936
  42824,  -17.9978142,   65.3217621,  0.909090936
  42825,  -18.4796524,     64.73703,  0.909090936
  42826,   -18.942503,   64.1371613,  0.909090936
  42827,  -19.3858891,   63.5227585,  0.909090936
  42828,  -19.8093548,   62.8944626,  0.909090936
  42829,  -20.2124653,   62.2529144,  0.909090936
  42830,  -20.5948067,   61.5987778,  0.909090936
  42831,  -20.9559822,    60.932724,  0.909090936
  42832,  -21.2956295,   60.2554321,  0.909090936
  42833,  -21.6133919,   59.5676079,  0.909090936
  42834,  -21.9089413,   58.8699455,  0.909090936
  42835,  -22.1819782,   58.1631737,  0.909090936
  42836,  -22.4322262,   57.4480133,  0.909090936
  42837,  -22.6594219,   56.7251968,  0.909090936
  42838,  -22.8633327,    55.995472,  0.909090936
  42839,  -23.0437508,   55.2595863,  0.909090936
  42840,   -23.200489,   54.5182953,  0.909090936
  42841,  -23.3333874,   53.7723618,  0.909090936
  42842,  -23.4423103,   53.0225525,  0.909090936
  42843,  -23.5271454,   52.2696342,  0.909090936
  42844,   -23.587801,   51.5143852,  0.909090936
  42845,  -23.6242199,   50.7575836,  0.909090936
  42846,   23.6242199,   50.7575836,   1.81818187
  42847,    23.587801,   51.5143852,   1.81818187
  42848,   23.5271454,   52.2696342,   1.81818187
  42849,   23.4423103,   53.0225525,   1.81818187
  42850,   23.3333874,   53.7723618,   1.81818187
  42851,    23.200489,   54.5182953,   1.81818187
  42852,   23.0437508,   55.2595863,   1.81818187
  42853,   22.8633327,    55.995472,   1.81818187
  42854,   22.6594219,   56.7251968,   1.81818187
  42855,   22.4322262,   57.4480133,   1.81818187
  42856,   22.1819782,   58.1631737,   1.81818187
  42857,   21.9089413,   58.8699455,   1.81818187
  42858,   21.6133919,   59.5676079,   1.81818187
  42859,   21.2956295,   60.2554321,   1.81818187
  42860,   20.9559822,    60.932724,   1.81818187
  42861,   20.5948067,   61.5987778,   1.81818187
  42862,   20.2124653,   62.2529144,   1.81818187
  42863,   19.8093548,   62.8944626,   1.81818187
  42864,   19.3858891,   63.5227585,   1.81818187
  42865,    18.942503,   64.1371613,   1.81818187
  42866,   18.4796524,     64.73703,   1.81818187
  42867,   17.9978142,   65.3217621,   1.81818187
  42868,   17.4974804,   65.8907471,   1.81818187
  42869,    16.979166,   66.4434052,   1.81818187
  42870,   16.4434032,   66.9791641,   1.81818187
  42871,    15.890748,   67.4974823,   1.81818187
  42872,   15.3217621,   67.9978104,   1.81818187
  42873,   14.7370329,   68.4796524,   1.81818187
  42874,   14.1371574,   68.9425049,   1.81818187
  42875,   13.5227575,   69.3858871,   1.81818187
  42876,   12.8944607,   69.8093567,   1.81818187
  42877,   12.2529173,   70.2124634,   1.81818187
  42878,   11.5987778,   70.5948029,   1.81818187
  42879,    10.932723,    70.955986,   1.81818187
  42880,   10.2554331,   71.2956314,   1.81818187
  42881,   9.56760502,   71.6133881,   1.81818187
  42882,   8.86994648,   71.9089432,   1.81818187
  42883,   8.16317272,   72.1819839,   1.81818187
  42884,   7.44801188,   72.4322281,   1.81818187
  42885,   6.72519779,   72.6594238,   1.81818187
  42886,   5.99547291,   72.8633347,   1.81818187
  42887,   5.25958538,   73.0437469,   1.81818187
  42888,   4.51829529,   73.2004929,   1.81818187
  42889,    3.7723608,   73.3333893,   1.81818187
  42890,   3.02255106,   73.4423065,   1.81818187
  42891,   2.26963496,   73.5271454,   1.81818187
  42892,   1.51438701,   73.5877991,   1.81818187
  42893,  0.757582724,   73.6242218,   1.81818187
  42894,           0.,   73.6363602,   1.81818187
  42895, -0.757582724,   73.6242218,   1.81818187
  42896,  -1.51438701,   73.5877991,   1.81818187
  42897,  -2.26963496,   73.5271454,   1.81818187
  42898,  -3.02255106,   73.4423065,   1.81818187
  42899,   -3.7723608,   73.3333893,   1.81818187
  42900,  -4.51829529,   73.2004929,   1.81818187
  42901,  -5.25958538,   73.0437469,   1.81818187
  42902,  -5.99547291,   72.8633347,   1.81818187
  42903,  -6.72519779,   72.6594238,   1.81818187
  42904,  -7.44801188,   72.4322281,   1.81818187
  42905,  -8.16317272,   72.1819839,   1.81818187
  42906,  -8.86994648,   71.9089432,   1.81818187
  42907,  -9.56760502,   71.6133881,   1.81818187
  42908,  -10.2554331,   71.2956314,   1.81818187
  42909,   -10.932723,    70.955986,   1.81818187
  42910,  -11.5987778,   70.5948029,   1.81818187
  42911,  -12.2529173,   70.2124634,   1.81818187
  42912,  -12.8944607,   69.8093567,   1.81818187
  42913,  -13.5227575,   69.3858871,   1.81818187
  42914,  -14.1371574,   68.9425049,   1.81818187
  42915,  -14.7370329,   68.4796524,   1.81818187
  42916,  -15.3217621,   67.9978104,   1.81818187
  42917,   -15.890748,   67.4974823,   1.81818187
  42918,  -16.4434032,   66.9791641,   1.81818187
  42919,   -16.979166,   66.4434052,   1.81818187
  42920,  -17.4974804,   65.8907471,   1.81818187
  42921,  -17.9978142,   65.3217621,   1.81818187
  42922,  -18.4796524,     64.73703,   1.81818187
  42923,   -18.942503,   64.1371613,   1.81818187
  42924,  -19.3858891,   63.5227585,   1.81818187
  42925,  -19.8093548,   62.8944626,   1.81818187
  42926,  -20.2124653,   62.2529144,   1.81818187
  42927,  -20.5948067,   61.5987778,   1.81818187
  42928,  -20.9559822,    60.932724,   1.81818187
  42929,  -21.2956295,   60.2554321,   1.81818187
  42930,  -21.6133919,   59.5676079,   1.81818187
  42931,  -21.9089413,   58.8699455,   1.81818187
  42932,  -22.1819782,   58.1631737,   1.81818187
  42933,  -22.4322262,   57.4480133,   1.81818187
  42934,  -22.6594219,   56.7251968,   1.81818187
  42935,  -22.8633327,    55.995472,   1.81818187
  42936,  -23.0437508,   55.2595863,   1.81818187
  42937,   -23.200489,   54.5182953,   1.81818187
  42938,  -23.3333874,   53.7723618,   1.81818187
  42939,  -23.4423103,   53.0225525,   1.81818187
  42940,  -23.5271454,   52.2696342,   1.81818187
  42941,   -23.587801,   51.5143852,   1.81818187
  42942,  -23.6242199,   50.7575836,   1.81818187
  42943,   23.6242199,   50.7575836,   2.72727275
  42944,    23.587801,   51.5143852,   2.72727275
  42945,   23.5271454,   52.2696342,   2.72727275
  42946,   23.4423103,   53.0225525,   2.72727275
  42947,   23.3333874,   53.7723618,   2.72727275
  42948,    23.200489,   54.5182953,   2.72727275
  42949,   23.0437508,   55.2595863,   2.72727275
  42950,   22.8633327,    55.995472,   2.72727275
  42951,   22.6594219,   56.7251968,   2.72727275
  42952,   22.4322262,   57.4480133,   2.72727275
  42953,   22.1819782,   58.1631737,   2.72727275
  42954,   21.9089413,   58.8699455,   2.72727275
  42955,   21.6133919,   59.5676079,   2.72727275
  42956,   21.2956295,   60.2554321,   2.72727275
  42957,   20.9559822,    60.932724,   2.72727275
  42958,   20.5948067,   61.5987778,   2.72727275
  42959,   20.2124653,   62.2529144,   2.72727275
  42960,   19.8093548,   62.8944626,   2.72727275
  42961,   19.3858891,   63.5227585,   2.72727275
  42962,    18.942503,   64.1371613,   2.72727275
  42963,   18.4796524,     64.73703,   2.72727275
  42964,   17.9978142,   65.3217621,   2.72727275
  42965,   17.4974804,   65.8907471,   2.72727275
  42966,    16.979166,   66.4434052,   2.72727275
  42967,   16.4434032,   66.9791641,   2.72727275
  42968,    15.890748,   67.4974823,   2.72727275
  42969,   15.3217621,   67.9978104,   2.72727275
  42970,   14.7370329,   68.4796524,   2.72727275
  42971,   14.1371574,   68.9425049,   2.72727275
  42972,   13.5227575,   69.3858871,   2.72727275
  42973,   12.8944607,   69.8093567,   2.72727275
  42974,   12.2529173,   70.2124634,   2.72727275
  42975,   11.5987778,   70.5948029,   2.72727275
  42976,    10.932723,    70.955986,   2.72727275
  42977,   10.2554331,   71.2956314,   2.72727275
  42978,   9.56760502,   71.6133881,   2.72727275
  42979,   8.86994648,   71.9089432,   2.72727275
  42980,   8.16317272,   72.1819839,   2.72727275
  42981,   7.44801188,   72.4322281,   2.72727275
  42982,   6.72519779,   72.6594238,   2.72727275
  42983,   5.99547291,   72.8633347,   2.72727275
  42984,   5.25958538,   73.0437469,   2.72727275
  42985,   4.51829529,   73.2004929,   2.72727275
  42986,    3.7723608,   73.3333893,   2.72727275
  42987,   3.02255106,   73.4423065,   2.72727275
  42988,   2.26963496,   73.5271454,   2.72727275
  42989,   1.51438701,   73.5877991,   2.72727275
  42990,  0.757582724,   73.6242218,   2.72727275
  42991,           0.,   73.6363602,   2.72727275
  42992, -0.757582724,   73.6242218,   2.72727275
  42993,  -1.51438701,   73.5877991,   2.72727275
  42994,  -2.26963496,   73.5271454,   2.72727275
  42995,  -3.02255106,   73.4423065,   2.72727275
  42996,   -3.7723608,   73.3333893,   2.72727275
  42997,  -4.51829529,   73.2004929,   2.72727275
  42998,  -5.25958538,   73.0437469,   2.72727275
  42999,  -5.99547291,   72.8633347,   2.72727275
  43000,  -6.72519779,   72.6594238,   2.72727275
  43001,  -7.44801188,   72.4322281,   2.72727275
  43002,  -8.16317272,   72.1819839,   2.72727275
  43003,  -8.86994648,   71.9089432,   2.72727275
  43004,  -9.56760502,   71.6133881,   2.72727275
  43005,  -10.2554331,   71.2956314,   2.72727275
  43006,   -10.932723,    70.955986,   2.72727275
  43007,  -11.5987778,   70.5948029,   2.72727275
  43008,  -12.2529173,   70.2124634,   2.72727275
  43009,  -12.8944607,   69.8093567,   2.72727275
  43010,  -13.5227575,   69.3858871,   2.72727275
  43011,  -14.1371574,   68.9425049,   2.72727275
  43012,  -14.7370329,   68.4796524,   2.72727275
  43013,  -15.3217621,   67.9978104,   2.72727275
  43014,   -15.890748,   67.4974823,   2.72727275
  43015,  -16.4434032,   66.9791641,   2.72727275
  43016,   -16.979166,   66.4434052,   2.72727275
  43017,  -17.4974804,   65.8907471,   2.72727275
  43018,  -17.9978142,   65.3217621,   2.72727275
  43019,  -18.4796524,     64.73703,   2.72727275
  43020,   -18.942503,   64.1371613,   2.72727275
  43021,  -19.3858891,   63.5227585,   2.72727275
  43022,  -19.8093548,   62.8944626,   2.72727275
  43023,  -20.2124653,   62.2529144,   2.72727275
  43024,  -20.5948067,   61.5987778,   2.72727275
  43025,  -20.9559822,    60.932724,   2.72727275
  43026,  -21.2956295,   60.2554321,   2.72727275
  43027,  -21.6133919,   59.5676079,   2.72727275
  43028,  -21.9089413,   58.8699455,   2.72727275
  43029,  -22.1819782,   58.1631737,   2.72727275
  43030,  -22.4322262,   57.4480133,   2.72727275
  43031,  -22.6594219,   56.7251968,   2.72727275
  43032,  -22.8633327,    55.995472,   2.72727275
  43033,  -23.0437508,   55.2595863,   2.72727275
  43034,   -23.200489,   54.5182953,   2.72727275
  43035,  -23.3333874,   53.7723618,   2.72727275
  43036,  -23.4423103,   53.0225525,   2.72727275
  43037,  -23.5271454,   52.2696342,   2.72727275
  43038,   -23.587801,   51.5143852,   2.72727275
  43039,  -23.6242199,   50.7575836,   2.72727275
  43040,   23.6242199,   50.7575836,   3.63636374
  43041,    23.587801,   51.5143852,   3.63636374
  43042,   23.5271454,   52.2696342,   3.63636374
  43043,   23.4423103,   53.0225525,   3.63636374
  43044,   23.3333874,   53.7723618,   3.63636374
  43045,    23.200489,   54.5182953,   3.63636374
  43046,   23.0437508,   55.2595863,   3.63636374
  43047,   22.8633327,    55.995472,   3.63636374
  43048,   22.6594219,   56.7251968,   3.63636374
  43049,   22.4322262,   57.4480133,   3.63636374
  43050,   22.1819782,   58.1631737,   3.63636374
  43051,   21.9089413,   58.8699455,   3.63636374
  43052,   21.6133919,   59.5676079,   3.63636374
  43053,   21.2956295,   60.2554321,   3.63636374
  43054,   20.9559822,    60.932724,   3.63636374
  43055,   20.5948067,   61.5987778,   3.63636374
  43056,   20.2124653,   62.2529144,   3.63636374
  43057,   19.8093548,   62.8944626,   3.63636374
  43058,   19.3858891,   63.5227585,   3.63636374
  43059,    18.942503,   64.1371613,   3.63636374
  43060,   18.4796524,     64.73703,   3.63636374
  43061,   17.9978142,   65.3217621,   3.63636374
  43062,   17.4974804,   65.8907471,   3.63636374
  43063,    16.979166,   66.4434052,   3.63636374
  43064,   16.4434032,   66.9791641,   3.63636374
  43065,    15.890748,   67.4974823,   3.63636374
  43066,   15.3217621,   67.9978104,   3.63636374
  43067,   14.7370329,   68.4796524,   3.63636374
  43068,   14.1371574,   68.9425049,   3.63636374
  43069,   13.5227575,   69.3858871,   3.63636374
  43070,   12.8944607,   69.8093567,   3.63636374
  43071,   12.2529173,   70.2124634,   3.63636374
  43072,   11.5987778,   70.5948029,   3.63636374
  43073,    10.932723,    70.955986,   3.63636374
  43074,   10.2554331,   71.2956314,   3.63636374
  43075,   9.56760502,   71.6133881,   3.63636374
  43076,   8.86994648,   71.9089432,   3.63636374
  43077,   8.16317272,   72.1819839,   3.63636374
  43078,   7.44801188,   72.4322281,   3.63636374
  43079,   6.72519779,   72.6594238,   3.63636374
  43080,   5.99547291,   72.8633347,   3.63636374
  43081,   5.25958538,   73.0437469,   3.63636374
  43082,   4.51829529,   73.2004929,   3.63636374
  43083,    3.7723608,   73.3333893,   3.63636374
  43084,   3.02255106,   73.4423065,   3.63636374
  43085,   2.26963496,   73.5271454,   3.63636374
  43086,   1.51438701,   73.5877991,   3.63636374
  43087,  0.757582724,   73.6242218,   3.63636374
  43088,           0.,   73.6363602,   3.63636374
  43089, -0.757582724,   73.6242218,   3.63636374
  43090,  -1.51438701,   73.5877991,   3.63636374
  43091,  -2.26963496,   73.5271454,   3.63636374
  43092,  -3.02255106,   73.4423065,   3.63636374
  43093,   -3.7723608,   73.3333893,   3.63636374
  43094,  -4.51829529,   73.2004929,   3.63636374
  43095,  -5.25958538,   73.0437469,   3.63636374
  43096,  -5.99547291,   72.8633347,   3.63636374
  43097,  -6.72519779,   72.6594238,   3.63636374
  43098,  -7.44801188,   72.4322281,   3.63636374
  43099,  -8.16317272,   72.1819839,   3.63636374
  43100,  -8.86994648,   71.9089432,   3.63636374
  43101,  -9.56760502,   71.6133881,   3.63636374
  43102,  -10.2554331,   71.2956314,   3.63636374
  43103,   -10.932723,    70.955986,   3.63636374
  43104,  -11.5987778,   70.5948029,   3.63636374
  43105,  -12.2529173,   70.2124634,   3.63636374
  43106,  -12.8944607,   69.8093567,   3.63636374
  43107,  -13.5227575,   69.3858871,   3.63636374
  43108,  -14.1371574,   68.9425049,   3.63636374
  43109,  -14.7370329,   68.4796524,   3.63636374
  43110,  -15.3217621,   67.9978104,   3.63636374
  43111,   -15.890748,   67.4974823,   3.63636374
  43112,  -16.4434032,   66.9791641,   3.63636374
  43113,   -16.979166,   66.4434052,   3.63636374
  43114,  -17.4974804,   65.8907471,   3.63636374
  43115,  -17.9978142,   65.3217621,   3.63636374
  43116,  -18.4796524,     64.73703,   3.63636374
  43117,   -18.942503,   64.1371613,   3.63636374
  43118,  -19.3858891,   63.5227585,   3.63636374
  43119,  -19.8093548,   62.8944626,   3.63636374
  43120,  -20.2124653,   62.2529144,   3.63636374
  43121,  -20.5948067,   61.5987778,   3.63636374
  43122,  -20.9559822,    60.932724,   3.63636374
  43123,  -21.2956295,   60.2554321,   3.63636374
  43124,  -21.6133919,   59.5676079,   3.63636374
  43125,  -21.9089413,   58.8699455,   3.63636374
  43126,  -22.1819782,   58.1631737,   3.63636374
  43127,  -22.4322262,   57.4480133,   3.63636374
  43128,  -22.6594219,   56.7251968,   3.63636374
  43129,  -22.8633327,    55.995472,   3.63636374
  43130,  -23.0437508,   55.2595863,   3.63636374
  43131,   -23.200489,   54.5182953,   3.63636374
  43132,  -23.3333874,   53.7723618,   3.63636374
  43133,  -23.4423103,   53.0225525,   3.63636374
  43134,  -23.5271454,   52.2696342,   3.63636374
  43135,   -23.587801,   51.5143852,   3.63636374
  43136,  -23.6242199,   50.7575836,   3.63636374
  43137,   23.6242199,   50.7575836,    4.5454545
  43138,    23.587801,   51.5143852,    4.5454545
  43139,   23.5271454,   52.2696342,    4.5454545
  43140,   23.4423103,   53.0225525,    4.5454545
  43141,   23.3333874,   53.7723618,    4.5454545
  43142,    23.200489,   54.5182953,    4.5454545
  43143,   23.0437508,   55.2595863,    4.5454545
  43144,   22.8633327,    55.995472,    4.5454545
  43145,   22.6594219,   56.7251968,    4.5454545
  43146,   22.4322262,   57.4480133,    4.5454545
  43147,   22.1819782,   58.1631737,    4.5454545
  43148,   21.9089413,   58.8699455,    4.5454545
  43149,   21.6133919,   59.5676079,    4.5454545
  43150,   21.2956295,   60.2554321,    4.5454545
  43151,   20.9559822,    60.932724,    4.5454545
  43152,   20.5948067,   61.5987778,    4.5454545
  43153,   20.2124653,   62.2529144,    4.5454545
  43154,   19.8093548,   62.8944626,    4.5454545
  43155,   19.3858891,   63.5227585,    4.5454545
  43156,    18.942503,   64.1371613,    4.5454545
  43157,   18.4796524,     64.73703,    4.5454545
  43158,   17.9978142,   65.3217621,    4.5454545
  43159,   17.4974804,   65.8907471,    4.5454545
  43160,    16.979166,   66.4434052,    4.5454545
  43161,   16.4434032,   66.9791641,    4.5454545
  43162,    15.890748,   67.4974823,    4.5454545
  43163,   15.3217621,   67.9978104,    4.5454545
  43164,   14.7370329,   68.4796524,    4.5454545
  43165,   14.1371574,   68.9425049,    4.5454545
  43166,   13.5227575,   69.3858871,    4.5454545
  43167,   12.8944607,   69.8093567,    4.5454545
  43168,   12.2529173,   70.2124634,    4.5454545
  43169,   11.5987778,   70.5948029,    4.5454545
  43170,    10.932723,    70.955986,    4.5454545
  43171,   10.2554331,   71.2956314,    4.5454545
  43172,   9.56760502,   71.6133881,    4.5454545
  43173,   8.86994648,   71.9089432,    4.5454545
  43174,   8.16317272,   72.1819839,    4.5454545
  43175,   7.44801188,   72.4322281,    4.5454545
  43176,   6.72519779,   72.6594238,    4.5454545
  43177,   5.99547291,   72.8633347,    4.5454545
  43178,   5.25958538,   73.0437469,    4.5454545
  43179,   4.51829529,   73.2004929,    4.5454545
  43180,    3.7723608,   73.3333893,    4.5454545
  43181,   3.02255106,   73.4423065,    4.5454545
  43182,   2.26963496,   73.5271454,    4.5454545
  43183,   1.51438701,   73.5877991,    4.5454545
  43184,  0.757582724,   73.6242218,    4.5454545
  43185,           0.,   73.6363602,    4.5454545
  43186, -0.757582724,   73.6242218,    4.5454545
  43187,  -1.51438701,   73.5877991,    4.5454545
  43188,  -2.26963496,   73.5271454,    4.5454545
  43189,  -3.02255106,   73.4423065,    4.5454545
  43190,   -3.7723608,   73.3333893,    4.5454545
  43191,  -4.51829529,   73.2004929,    4.5454545
  43192,  -5.25958538,   73.0437469,    4.5454545
  43193,  -5.99547291,   72.8633347,    4.5454545
  43194,  -6.72519779,   72.6594238,    4.5454545
  43195,  -7.44801188,   72.4322281,    4.5454545
  43196,  -8.16317272,   72.1819839,    4.5454545
  43197,  -8.86994648,   71.9089432,    4.5454545
  43198,  -9.56760502,   71.6133881,    4.5454545
  43199,  -10.2554331,   71.2956314,    4.5454545
  43200,   -10.932723,    70.955986,    4.5454545
  43201,  -11.5987778,   70.5948029,    4.5454545
  43202,  -12.2529173,   70.2124634,    4.5454545
  43203,  -12.8944607,   69.8093567,    4.5454545
  43204,  -13.5227575,   69.3858871,    4.5454545
  43205,  -14.1371574,   68.9425049,    4.5454545
  43206,  -14.7370329,   68.4796524,    4.5454545
  43207,  -15.3217621,   67.9978104,    4.5454545
  43208,   -15.890748,   67.4974823,    4.5454545
  43209,  -16.4434032,   66.9791641,    4.5454545
  43210,   -16.979166,   66.4434052,    4.5454545
  43211,  -17.4974804,   65.8907471,    4.5454545
  43212,  -17.9978142,   65.3217621,    4.5454545
  43213,  -18.4796524,     64.73703,    4.5454545
  43214,   -18.942503,   64.1371613,    4.5454545
  43215,  -19.3858891,   63.5227585,    4.5454545
  43216,  -19.8093548,   62.8944626,    4.5454545
  43217,  -20.2124653,   62.2529144,    4.5454545
  43218,  -20.5948067,   61.5987778,    4.5454545
  43219,  -20.9559822,    60.932724,    4.5454545
  43220,  -21.2956295,   60.2554321,    4.5454545
  43221,  -21.6133919,   59.5676079,    4.5454545
  43222,  -21.9089413,   58.8699455,    4.5454545
  43223,  -22.1819782,   58.1631737,    4.5454545
  43224,  -22.4322262,   57.4480133,    4.5454545
  43225,  -22.6594219,   56.7251968,    4.5454545
  43226,  -22.8633327,    55.995472,    4.5454545
  43227,  -23.0437508,   55.2595863,    4.5454545
  43228,   -23.200489,   54.5182953,    4.5454545
  43229,  -23.3333874,   53.7723618,    4.5454545
  43230,  -23.4423103,   53.0225525,    4.5454545
  43231,  -23.5271454,   52.2696342,    4.5454545
  43232,   -23.587801,   51.5143852,    4.5454545
  43233,  -23.6242199,   50.7575836,    4.5454545
  43234,   23.6242199,   50.7575836,    5.4545455
  43235,    23.587801,   51.5143852,    5.4545455
  43236,   23.5271454,   52.2696342,    5.4545455
  43237,   23.4423103,   53.0225525,    5.4545455
  43238,   23.3333874,   53.7723618,    5.4545455
  43239,    23.200489,   54.5182953,    5.4545455
  43240,   23.0437508,   55.2595863,    5.4545455
  43241,   22.8633327,    55.995472,    5.4545455
  43242,   22.6594219,   56.7251968,    5.4545455
  43243,   22.4322262,   57.4480133,    5.4545455
  43244,   22.1819782,   58.1631737,    5.4545455
  43245,   21.9089413,   58.8699455,    5.4545455
  43246,   21.6133919,   59.5676079,    5.4545455
  43247,   21.2956295,   60.2554321,    5.4545455
  43248,   20.9559822,    60.932724,    5.4545455
  43249,   20.5948067,   61.5987778,    5.4545455
  43250,   20.2124653,   62.2529144,    5.4545455
  43251,   19.8093548,   62.8944626,    5.4545455
  43252,   19.3858891,   63.5227585,    5.4545455
  43253,    18.942503,   64.1371613,    5.4545455
  43254,   18.4796524,     64.73703,    5.4545455
  43255,   17.9978142,   65.3217621,    5.4545455
  43256,   17.4974804,   65.8907471,    5.4545455
  43257,    16.979166,   66.4434052,    5.4545455
  43258,   16.4434032,   66.9791641,    5.4545455
  43259,    15.890748,   67.4974823,    5.4545455
  43260,   15.3217621,   67.9978104,    5.4545455
  43261,   14.7370329,   68.4796524,    5.4545455
  43262,   14.1371574,   68.9425049,    5.4545455
  43263,   13.5227575,   69.3858871,    5.4545455
  43264,   12.8944607,   69.8093567,    5.4545455
  43265,   12.2529173,   70.2124634,    5.4545455
  43266,   11.5987778,   70.5948029,    5.4545455
  43267,    10.932723,    70.955986,    5.4545455
  43268,   10.2554331,   71.2956314,    5.4545455
  43269,   9.56760502,   71.6133881,    5.4545455
  43270,   8.86994648,   71.9089432,    5.4545455
  43271,   8.16317272,   72.1819839,    5.4545455
  43272,   7.44801188,   72.4322281,    5.4545455
  43273,   6.72519779,   72.6594238,    5.4545455
  43274,   5.99547291,   72.8633347,    5.4545455
  43275,   5.25958538,   73.0437469,    5.4545455
  43276,   4.51829529,   73.2004929,    5.4545455
  43277,    3.7723608,   73.3333893,    5.4545455
  43278,   3.02255106,   73.4423065,    5.4545455
  43279,   2.26963496,   73.5271454,    5.4545455
  43280,   1.51438701,   73.5877991,    5.4545455
  43281,  0.757582724,   73.6242218,    5.4545455
  43282,           0.,   73.6363602,    5.4545455
  43283, -0.757582724,   73.6242218,    5.4545455
  43284,  -1.51438701,   73.5877991,    5.4545455
  43285,  -2.26963496,   73.5271454,    5.4545455
  43286,  -3.02255106,   73.4423065,    5.4545455
  43287,   -3.7723608,   73.3333893,    5.4545455
  43288,  -4.51829529,   73.2004929,    5.4545455
  43289,  -5.25958538,   73.0437469,    5.4545455
  43290,  -5.99547291,   72.8633347,    5.4545455
  43291,  -6.72519779,   72.6594238,    5.4545455
  43292,  -7.44801188,   72.4322281,    5.4545455
  43293,  -8.16317272,   72.1819839,    5.4545455
  43294,  -8.86994648,   71.9089432,    5.4545455
  43295,  -9.56760502,   71.6133881,    5.4545455
  43296,  -10.2554331,   71.2956314,    5.4545455
  43297,   -10.932723,    70.955986,    5.4545455
  43298,  -11.5987778,   70.5948029,    5.4545455
  43299,  -12.2529173,   70.2124634,    5.4545455
  43300,  -12.8944607,   69.8093567,    5.4545455
  43301,  -13.5227575,   69.3858871,    5.4545455
  43302,  -14.1371574,   68.9425049,    5.4545455
  43303,  -14.7370329,   68.4796524,    5.4545455
  43304,  -15.3217621,   67.9978104,    5.4545455
  43305,   -15.890748,   67.4974823,    5.4545455
  43306,  -16.4434032,   66.9791641,    5.4545455
  43307,   -16.979166,   66.4434052,    5.4545455
  43308,  -17.4974804,   65.8907471,    5.4545455
  43309,  -17.9978142,   65.3217621,    5.4545455
  43310,  -18.4796524,     64.73703,    5.4545455
  43311,   -18.942503,   64.1371613,    5.4545455
  43312,  -19.3858891,   63.5227585,    5.4545455
  43313,  -19.8093548,   62.8944626,    5.4545455
  43314,  -20.2124653,   62.2529144,    5.4545455
  43315,  -20.5948067,   61.5987778,    5.4545455
  43316,  -20.9559822,    60.932724,    5.4545455
  43317,  -21.2956295,   60.2554321,    5.4545455
  43318,  -21.6133919,   59.5676079,    5.4545455
  43319,  -21.9089413,   58.8699455,    5.4545455
  43320,  -22.1819782,   58.1631737,    5.4545455
  43321,  -22.4322262,   57.4480133,    5.4545455
  43322,  -22.6594219,   56.7251968,    5.4545455
  43323,  -22.8633327,    55.995472,    5.4545455
  43324,  -23.0437508,   55.2595863,    5.4545455
  43325,   -23.200489,   54.5182953,    5.4545455
  43326,  -23.3333874,   53.7723618,    5.4545455
  43327,  -23.4423103,   53.0225525,    5.4545455
  43328,  -23.5271454,   52.2696342,    5.4545455
  43329,   -23.587801,   51.5143852,    5.4545455
  43330,  -23.6242199,   50.7575836,    5.4545455
  43331,   23.6242199,   50.7575836,   6.36363649
  43332,    23.587801,   51.5143852,   6.36363649
  43333,   23.5271454,   52.2696342,   6.36363649
  43334,   23.4423103,   53.0225525,   6.36363649
  43335,   23.3333874,   53.7723618,   6.36363649
  43336,    23.200489,   54.5182953,   6.36363649
  43337,   23.0437508,   55.2595863,   6.36363649
  43338,   22.8633327,    55.995472,   6.36363649
  43339,   22.6594219,   56.7251968,   6.36363649
  43340,   22.4322262,   57.4480133,   6.36363649
  43341,   22.1819782,   58.1631737,   6.36363649
  43342,   21.9089413,   58.8699455,   6.36363649
  43343,   21.6133919,   59.5676079,   6.36363649
  43344,   21.2956295,   60.2554321,   6.36363649
  43345,   20.9559822,    60.932724,   6.36363649
  43346,   20.5948067,   61.5987778,   6.36363649
  43347,   20.2124653,   62.2529144,   6.36363649
  43348,   19.8093548,   62.8944626,   6.36363649
  43349,   19.3858891,   63.5227585,   6.36363649
  43350,    18.942503,   64.1371613,   6.36363649
  43351,   18.4796524,     64.73703,   6.36363649
  43352,   17.9978142,   65.3217621,   6.36363649
  43353,   17.4974804,   65.8907471,   6.36363649
  43354,    16.979166,   66.4434052,   6.36363649
  43355,   16.4434032,   66.9791641,   6.36363649
  43356,    15.890748,   67.4974823,   6.36363649
  43357,   15.3217621,   67.9978104,   6.36363649
  43358,   14.7370329,   68.4796524,   6.36363649
  43359,   14.1371574,   68.9425049,   6.36363649
  43360,   13.5227575,   69.3858871,   6.36363649
  43361,   12.8944607,   69.8093567,   6.36363649
  43362,   12.2529173,   70.2124634,   6.36363649
  43363,   11.5987778,   70.5948029,   6.36363649
  43364,    10.932723,    70.955986,   6.36363649
  43365,   10.2554331,   71.2956314,   6.36363649
  43366,   9.56760502,   71.6133881,   6.36363649
  43367,   8.86994648,   71.9089432,   6.36363649
  43368,   8.16317272,   72.1819839,   6.36363649
  43369,   7.44801188,   72.4322281,   6.36363649
  43370,   6.72519779,   72.6594238,   6.36363649
  43371,   5.99547291,   72.8633347,   6.36363649
  43372,   5.25958538,   73.0437469,   6.36363649
  43373,   4.51829529,   73.2004929,   6.36363649
  43374,    3.7723608,   73.3333893,   6.36363649
  43375,   3.02255106,   73.4423065,   6.36363649
  43376,   2.26963496,   73.5271454,   6.36363649
  43377,   1.51438701,   73.5877991,   6.36363649
  43378,  0.757582724,   73.6242218,   6.36363649
  43379,           0.,   73.6363602,   6.36363649
  43380, -0.757582724,   73.6242218,   6.36363649
  43381,  -1.51438701,   73.5877991,   6.36363649
  43382,  -2.26963496,   73.5271454,   6.36363649
  43383,  -3.02255106,   73.4423065,   6.36363649
  43384,   -3.7723608,   73.3333893,   6.36363649
  43385,  -4.51829529,   73.2004929,   6.36363649
  43386,  -5.25958538,   73.0437469,   6.36363649
  43387,  -5.99547291,   72.8633347,   6.36363649
  43388,  -6.72519779,   72.6594238,   6.36363649
  43389,  -7.44801188,   72.4322281,   6.36363649
  43390,  -8.16317272,   72.1819839,   6.36363649
  43391,  -8.86994648,   71.9089432,   6.36363649
  43392,  -9.56760502,   71.6133881,   6.36363649
  43393,  -10.2554331,   71.2956314,   6.36363649
  43394,   -10.932723,    70.955986,   6.36363649
  43395,  -11.5987778,   70.5948029,   6.36363649
  43396,  -12.2529173,   70.2124634,   6.36363649
  43397,  -12.8944607,   69.8093567,   6.36363649
  43398,  -13.5227575,   69.3858871,   6.36363649
  43399,  -14.1371574,   68.9425049,   6.36363649
  43400,  -14.7370329,   68.4796524,   6.36363649
  43401,  -15.3217621,   67.9978104,   6.36363649
  43402,   -15.890748,   67.4974823,   6.36363649
  43403,  -16.4434032,   66.9791641,   6.36363649
  43404,   -16.979166,   66.4434052,   6.36363649
  43405,  -17.4974804,   65.8907471,   6.36363649
  43406,  -17.9978142,   65.3217621,   6.36363649
  43407,  -18.4796524,     64.73703,   6.36363649
  43408,   -18.942503,   64.1371613,   6.36363649
  43409,  -19.3858891,   63.5227585,   6.36363649
  43410,  -19.8093548,   62.8944626,   6.36363649
  43411,  -20.2124653,   62.2529144,   6.36363649
  43412,  -20.5948067,   61.5987778,   6.36363649
  43413,  -20.9559822,    60.932724,   6.36363649
  43414,  -21.2956295,   60.2554321,   6.36363649
  43415,  -21.6133919,   59.5676079,   6.36363649
  43416,  -21.9089413,   58.8699455,   6.36363649
  43417,  -22.1819782,   58.1631737,   6.36363649
  43418,  -22.4322262,   57.4480133,   6.36363649
  43419,  -22.6594219,   56.7251968,   6.36363649
  43420,  -22.8633327,    55.995472,   6.36363649
  43421,  -23.0437508,   55.2595863,   6.36363649
  43422,   -23.200489,   54.5182953,   6.36363649
  43423,  -23.3333874,   53.7723618,   6.36363649
  43424,  -23.4423103,   53.0225525,   6.36363649
  43425,  -23.5271454,   52.2696342,   6.36363649
  43426,   -23.587801,   51.5143852,   6.36363649
  43427,  -23.6242199,   50.7575836,   6.36363649
  43428,   23.6242199,   50.7575836,   7.27272749
  43429,    23.587801,   51.5143852,   7.27272749
  43430,   23.5271454,   52.2696342,   7.27272749
  43431,   23.4423103,   53.0225525,   7.27272749
  43432,   23.3333874,   53.7723618,   7.27272749
  43433,    23.200489,   54.5182953,   7.27272749
  43434,   23.0437508,   55.2595863,   7.27272749
  43435,   22.8633327,    55.995472,   7.27272749
  43436,   22.6594219,   56.7251968,   7.27272749
  43437,   22.4322262,   57.4480133,   7.27272749
  43438,   22.1819782,   58.1631737,   7.27272749
  43439,   21.9089413,   58.8699455,   7.27272749
  43440,   21.6133919,   59.5676079,   7.27272749
  43441,   21.2956295,   60.2554321,   7.27272749
  43442,   20.9559822,    60.932724,   7.27272749
  43443,   20.5948067,   61.5987778,   7.27272749
  43444,   20.2124653,   62.2529144,   7.27272749
  43445,   19.8093548,   62.8944626,   7.27272749
  43446,   19.3858891,   63.5227585,   7.27272749
  43447,    18.942503,   64.1371613,   7.27272749
  43448,   18.4796524,     64.73703,   7.27272749
  43449,   17.9978142,   65.3217621,   7.27272749
  43450,   17.4974804,   65.8907471,   7.27272749
  43451,    16.979166,   66.4434052,   7.27272749
  43452,   16.4434032,   66.9791641,   7.27272749
  43453,    15.890748,   67.4974823,   7.27272749
  43454,   15.3217621,   67.9978104,   7.27272749
  43455,   14.7370329,   68.4796524,   7.27272749
  43456,   14.1371574,   68.9425049,   7.27272749
  43457,   13.5227575,   69.3858871,   7.27272749
  43458,   12.8944607,   69.8093567,   7.27272749
  43459,   12.2529173,   70.2124634,   7.27272749
  43460,   11.5987778,   70.5948029,   7.27272749
  43461,    10.932723,    70.955986,   7.27272749
  43462,   10.2554331,   71.2956314,   7.27272749
  43463,   9.56760502,   71.6133881,   7.27272749
  43464,   8.86994648,   71.9089432,   7.27272749
  43465,   8.16317272,   72.1819839,   7.27272749
  43466,   7.44801188,   72.4322281,   7.27272749
  43467,   6.72519779,   72.6594238,   7.27272749
  43468,   5.99547291,   72.8633347,   7.27272749
  43469,   5.25958538,   73.0437469,   7.27272749
  43470,   4.51829529,   73.2004929,   7.27272749
  43471,    3.7723608,   73.3333893,   7.27272749
  43472,   3.02255106,   73.4423065,   7.27272749
  43473,   2.26963496,   73.5271454,   7.27272749
  43474,   1.51438701,   73.5877991,   7.27272749
  43475,  0.757582724,   73.6242218,   7.27272749
  43476,           0.,   73.6363602,   7.27272749
  43477, -0.757582724,   73.6242218,   7.27272749
  43478,  -1.51438701,   73.5877991,   7.27272749
  43479,  -2.26963496,   73.5271454,   7.27272749
  43480,  -3.02255106,   73.4423065,   7.27272749
  43481,   -3.7723608,   73.3333893,   7.27272749
  43482,  -4.51829529,   73.2004929,   7.27272749
  43483,  -5.25958538,   73.0437469,   7.27272749
  43484,  -5.99547291,   72.8633347,   7.27272749
  43485,  -6.72519779,   72.6594238,   7.27272749
  43486,  -7.44801188,   72.4322281,   7.27272749
  43487,  -8.16317272,   72.1819839,   7.27272749
  43488,  -8.86994648,   71.9089432,   7.27272749
  43489,  -9.56760502,   71.6133881,   7.27272749
  43490,  -10.2554331,   71.2956314,   7.27272749
  43491,   -10.932723,    70.955986,   7.27272749
  43492,  -11.5987778,   70.5948029,   7.27272749
  43493,  -12.2529173,   70.2124634,   7.27272749
  43494,  -12.8944607,   69.8093567,   7.27272749
  43495,  -13.5227575,   69.3858871,   7.27272749
  43496,  -14.1371574,   68.9425049,   7.27272749
  43497,  -14.7370329,   68.4796524,   7.27272749
  43498,  -15.3217621,   67.9978104,   7.27272749
  43499,   -15.890748,   67.4974823,   7.27272749
  43500,  -16.4434032,   66.9791641,   7.27272749
  43501,   -16.979166,   66.4434052,   7.27272749
  43502,  -17.4974804,   65.8907471,   7.27272749
  43503,  -17.9978142,   65.3217621,   7.27272749
  43504,  -18.4796524,     64.73703,   7.27272749
  43505,   -18.942503,   64.1371613,   7.27272749
  43506,  -19.3858891,   63.5227585,   7.27272749
  43507,  -19.8093548,   62.8944626,   7.27272749
  43508,  -20.2124653,   62.2529144,   7.27272749
  43509,  -20.5948067,   61.5987778,   7.27272749
  43510,  -20.9559822,    60.932724,   7.27272749
  43511,  -21.2956295,   60.2554321,   7.27272749
  43512,  -21.6133919,   59.5676079,   7.27272749
  43513,  -21.9089413,   58.8699455,   7.27272749
  43514,  -22.1819782,   58.1631737,   7.27272749
  43515,  -22.4322262,   57.4480133,   7.27272749
  43516,  -22.6594219,   56.7251968,   7.27272749
  43517,  -22.8633327,    55.995472,   7.27272749
  43518,  -23.0437508,   55.2595863,   7.27272749
  43519,   -23.200489,   54.5182953,   7.27272749
  43520,  -23.3333874,   53.7723618,   7.27272749
  43521,  -23.4423103,   53.0225525,   7.27272749
  43522,  -23.5271454,   52.2696342,   7.27272749
  43523,   -23.587801,   51.5143852,   7.27272749
  43524,  -23.6242199,   50.7575836,   7.27272749
  43525,   23.6242199,   50.7575836,   8.18181801
  43526,    23.587801,   51.5143852,   8.18181801
  43527,   23.5271454,   52.2696342,   8.18181801
  43528,   23.4423103,   53.0225525,   8.18181801
  43529,   23.3333874,   53.7723618,   8.18181801
  43530,    23.200489,   54.5182953,   8.18181801
  43531,   23.0437508,   55.2595863,   8.18181801
  43532,   22.8633327,    55.995472,   8.18181801
  43533,   22.6594219,   56.7251968,   8.18181801
  43534,   22.4322262,   57.4480133,   8.18181801
  43535,   22.1819782,   58.1631737,   8.18181801
  43536,   21.9089413,   58.8699455,   8.18181801
  43537,   21.6133919,   59.5676079,   8.18181801
  43538,   21.2956295,   60.2554321,   8.18181801
  43539,   20.9559822,    60.932724,   8.18181801
  43540,   20.5948067,   61.5987778,   8.18181801
  43541,   20.2124653,   62.2529144,   8.18181801
  43542,   19.8093548,   62.8944626,   8.18181801
  43543,   19.3858891,   63.5227585,   8.18181801
  43544,    18.942503,   64.1371613,   8.18181801
  43545,   18.4796524,     64.73703,   8.18181801
  43546,   17.9978142,   65.3217621,   8.18181801
  43547,   17.4974804,   65.8907471,   8.18181801
  43548,    16.979166,   66.4434052,   8.18181801
  43549,   16.4434032,   66.9791641,   8.18181801
  43550,    15.890748,   67.4974823,   8.18181801
  43551,   15.3217621,   67.9978104,   8.18181801
  43552,   14.7370329,   68.4796524,   8.18181801
  43553,   14.1371574,   68.9425049,   8.18181801
  43554,   13.5227575,   69.3858871,   8.18181801
  43555,   12.8944607,   69.8093567,   8.18181801
  43556,   12.2529173,   70.2124634,   8.18181801
  43557,   11.5987778,   70.5948029,   8.18181801
  43558,    10.932723,    70.955986,   8.18181801
  43559,   10.2554331,   71.2956314,   8.18181801
  43560,   9.56760502,   71.6133881,   8.18181801
  43561,   8.86994648,   71.9089432,   8.18181801
  43562,   8.16317272,   72.1819839,   8.18181801
  43563,   7.44801188,   72.4322281,   8.18181801
  43564,   6.72519779,   72.6594238,   8.18181801
  43565,   5.99547291,   72.8633347,   8.18181801
  43566,   5.25958538,   73.0437469,   8.18181801
  43567,   4.51829529,   73.2004929,   8.18181801
  43568,    3.7723608,   73.3333893,   8.18181801
  43569,   3.02255106,   73.4423065,   8.18181801
  43570,   2.26963496,   73.5271454,   8.18181801
  43571,   1.51438701,   73.5877991,   8.18181801
  43572,  0.757582724,   73.6242218,   8.18181801
  43573,           0.,   73.6363602,   8.18181801
  43574, -0.757582724,   73.6242218,   8.18181801
  43575,  -1.51438701,   73.5877991,   8.18181801
  43576,  -2.26963496,   73.5271454,   8.18181801
  43577,  -3.02255106,   73.4423065,   8.18181801
  43578,   -3.7723608,   73.3333893,   8.18181801
  43579,  -4.51829529,   73.2004929,   8.18181801
  43580,  -5.25958538,   73.0437469,   8.18181801
  43581,  -5.99547291,   72.8633347,   8.18181801
  43582,  -6.72519779,   72.6594238,   8.18181801
  43583,  -7.44801188,   72.4322281,   8.18181801
  43584,  -8.16317272,   72.1819839,   8.18181801
  43585,  -8.86994648,   71.9089432,   8.18181801
  43586,  -9.56760502,   71.6133881,   8.18181801
  43587,  -10.2554331,   71.2956314,   8.18181801
  43588,   -10.932723,    70.955986,   8.18181801
  43589,  -11.5987778,   70.5948029,   8.18181801
  43590,  -12.2529173,   70.2124634,   8.18181801
  43591,  -12.8944607,   69.8093567,   8.18181801
  43592,  -13.5227575,   69.3858871,   8.18181801
  43593,  -14.1371574,   68.9425049,   8.18181801
  43594,  -14.7370329,   68.4796524,   8.18181801
  43595,  -15.3217621,   67.9978104,   8.18181801
  43596,   -15.890748,   67.4974823,   8.18181801
  43597,  -16.4434032,   66.9791641,   8.18181801
  43598,   -16.979166,   66.4434052,   8.18181801
  43599,  -17.4974804,   65.8907471,   8.18181801
  43600,  -17.9978142,   65.3217621,   8.18181801
  43601,  -18.4796524,     64.73703,   8.18181801
  43602,   -18.942503,   64.1371613,   8.18181801
  43603,  -19.3858891,   63.5227585,   8.18181801
  43604,  -19.8093548,   62.8944626,   8.18181801
  43605,  -20.2124653,   62.2529144,   8.18181801
  43606,  -20.5948067,   61.5987778,   8.18181801
  43607,  -20.9559822,    60.932724,   8.18181801
  43608,  -21.2956295,   60.2554321,   8.18181801
  43609,  -21.6133919,   59.5676079,   8.18181801
  43610,  -21.9089413,   58.8699455,   8.18181801
  43611,  -22.1819782,   58.1631737,   8.18181801
  43612,  -22.4322262,   57.4480133,   8.18181801
  43613,  -22.6594219,   56.7251968,   8.18181801
  43614,  -22.8633327,    55.995472,   8.18181801
  43615,  -23.0437508,   55.2595863,   8.18181801
  43616,   -23.200489,   54.5182953,   8.18181801
  43617,  -23.3333874,   53.7723618,   8.18181801
  43618,  -23.4423103,   53.0225525,   8.18181801
  43619,  -23.5271454,   52.2696342,   8.18181801
  43620,   -23.587801,   51.5143852,   8.18181801
  43621,  -23.6242199,   50.7575836,   8.18181801
  43622,   23.6242199,   50.7575836,     9.090909
  43623,    23.587801,   51.5143852,     9.090909
  43624,   23.5271454,   52.2696342,     9.090909
  43625,   23.4423103,   53.0225525,     9.090909
  43626,   23.3333874,   53.7723618,     9.090909
  43627,    23.200489,   54.5182953,     9.090909
  43628,   23.0437508,   55.2595863,     9.090909
  43629,   22.8633327,    55.995472,     9.090909
  43630,   22.6594219,   56.7251968,     9.090909
  43631,   22.4322262,   57.4480133,     9.090909
  43632,   22.1819782,   58.1631737,     9.090909
  43633,   21.9089413,   58.8699455,     9.090909
  43634,   21.6133919,   59.5676079,     9.090909
  43635,   21.2956295,   60.2554321,     9.090909
  43636,   20.9559822,    60.932724,     9.090909
  43637,   20.5948067,   61.5987778,     9.090909
  43638,   20.2124653,   62.2529144,     9.090909
  43639,   19.8093548,   62.8944626,     9.090909
  43640,   19.3858891,   63.5227585,     9.090909
  43641,    18.942503,   64.1371613,     9.090909
  43642,   18.4796524,     64.73703,     9.090909
  43643,   17.9978142,   65.3217621,     9.090909
  43644,   17.4974804,   65.8907471,     9.090909
  43645,    16.979166,   66.4434052,     9.090909
  43646,   16.4434032,   66.9791641,     9.090909
  43647,    15.890748,   67.4974823,     9.090909
  43648,   15.3217621,   67.9978104,     9.090909
  43649,   14.7370329,   68.4796524,     9.090909
  43650,   14.1371574,   68.9425049,     9.090909
  43651,   13.5227575,   69.3858871,     9.090909
  43652,   12.8944607,   69.8093567,     9.090909
  43653,   12.2529173,   70.2124634,     9.090909
  43654,   11.5987778,   70.5948029,     9.090909
  43655,    10.932723,    70.955986,     9.090909
  43656,   10.2554331,   71.2956314,     9.090909
  43657,   9.56760502,   71.6133881,     9.090909
  43658,   8.86994648,   71.9089432,     9.090909
  43659,   8.16317272,   72.1819839,     9.090909
  43660,   7.44801188,   72.4322281,     9.090909
  43661,   6.72519779,   72.6594238,     9.090909
  43662,   5.99547291,   72.8633347,     9.090909
  43663,   5.25958538,   73.0437469,     9.090909
  43664,   4.51829529,   73.2004929,     9.090909
  43665,    3.7723608,   73.3333893,     9.090909
  43666,   3.02255106,   73.4423065,     9.090909
  43667,   2.26963496,   73.5271454,     9.090909
  43668,   1.51438701,   73.5877991,     9.090909
  43669,  0.757582724,   73.6242218,     9.090909
  43670,           0.,   73.6363602,     9.090909
  43671, -0.757582724,   73.6242218,     9.090909
  43672,  -1.51438701,   73.5877991,     9.090909
  43673,  -2.26963496,   73.5271454,     9.090909
  43674,  -3.02255106,   73.4423065,     9.090909
  43675,   -3.7723608,   73.3333893,     9.090909
  43676,  -4.51829529,   73.2004929,     9.090909
  43677,  -5.25958538,   73.0437469,     9.090909
  43678,  -5.99547291,   72.8633347,     9.090909
  43679,  -6.72519779,   72.6594238,     9.090909
  43680,  -7.44801188,   72.4322281,     9.090909
  43681,  -8.16317272,   72.1819839,     9.090909
  43682,  -8.86994648,   71.9089432,     9.090909
  43683,  -9.56760502,   71.6133881,     9.090909
  43684,  -10.2554331,   71.2956314,     9.090909
  43685,   -10.932723,    70.955986,     9.090909
  43686,  -11.5987778,   70.5948029,     9.090909
  43687,  -12.2529173,   70.2124634,     9.090909
  43688,  -12.8944607,   69.8093567,     9.090909
  43689,  -13.5227575,   69.3858871,     9.090909
  43690,  -14.1371574,   68.9425049,     9.090909
  43691,  -14.7370329,   68.4796524,     9.090909
  43692,  -15.3217621,   67.9978104,     9.090909
  43693,   -15.890748,   67.4974823,     9.090909
  43694,  -16.4434032,   66.9791641,     9.090909
  43695,   -16.979166,   66.4434052,     9.090909
  43696,  -17.4974804,   65.8907471,     9.090909
  43697,  -17.9978142,   65.3217621,     9.090909
  43698,  -18.4796524,     64.73703,     9.090909
  43699,   -18.942503,   64.1371613,     9.090909
  43700,  -19.3858891,   63.5227585,     9.090909
  43701,  -19.8093548,   62.8944626,     9.090909
  43702,  -20.2124653,   62.2529144,     9.090909
  43703,  -20.5948067,   61.5987778,     9.090909
  43704,  -20.9559822,    60.932724,     9.090909
  43705,  -21.2956295,   60.2554321,     9.090909
  43706,  -21.6133919,   59.5676079,     9.090909
  43707,  -21.9089413,   58.8699455,     9.090909
  43708,  -22.1819782,   58.1631737,     9.090909
  43709,  -22.4322262,   57.4480133,     9.090909
  43710,  -22.6594219,   56.7251968,     9.090909
  43711,  -22.8633327,    55.995472,     9.090909
  43712,  -23.0437508,   55.2595863,     9.090909
  43713,   -23.200489,   54.5182953,     9.090909
  43714,  -23.3333874,   53.7723618,     9.090909
  43715,  -23.4423103,   53.0225525,     9.090909
  43716,  -23.5271454,   52.2696342,     9.090909
  43717,   -23.587801,   51.5143852,     9.090909
  43718,  -23.6242199,   50.7575836,     9.090909
  43719,   22.7155952,   50.7284431,  0.909090936
  43720,   22.6805763,   51.4561424,  0.909090936
  43721,   22.6222553,   52.1823425,  0.909090936
  43722,   22.5406818,   52.9062996,  0.909090936
  43723,   22.4359493,   53.6272697,  0.909090936
  43724,   22.3081627,   54.3445129,  0.909090936
  43725,   22.1574516,   55.0572929,  0.909090936
  43726,   21.9839745,   55.7648773,  0.909090936
  43727,   21.7879066,   56.4665375,  0.909090936
  43728,   21.5694485,   57.1615486,  0.909090936
  43729,    21.328825,    57.849205,  0.909090936
  43730,   21.0662899,   58.5287971,  0.909090936
  43731,   20.7821064,   59.1996231,  0.909090936
  43732,   20.4765663,   59.8609924,  0.909090936
  43733,   20.1499825,   60.5122337,  0.909090936
  43734,   19.8026981,   61.1526718,  0.909090936
  43735,   19.4350624,   61.7816505,  0.909090936
  43736,   19.0474567,   62.3985214,  0.909090936
  43737,   18.6402779,   63.0026512,  0.909090936
  43738,   18.2139454,   63.5934219,  0.909090936
  43739,    17.768898,   64.1702194,  0.909090936
  43740,   17.3055897,     64.73246,  0.909090936
  43741,   16.8244991,   65.2795639,  0.909090936
  43742,   16.3261223,   65.8109665,  0.909090936
  43743,   15.8109665,   66.3261185,  0.909090936
  43744,   15.2795658,    66.824501,  0.909090936
  43745,   14.7324638,   67.3055878,  0.909090936
  43746,   14.1702242,    67.768898,  0.909090936
  43747,     13.59342,   68.2139435,  0.909090936
  43748,   13.0026512,   68.6402817,  0.909090936
  43749,   12.3985195,   69.0474548,  0.909090936
  43750,   11.7816515,   69.4350662,  0.909090936
  43751,   11.1526709,   69.8026962,  0.909090936
  43752,   10.5122337,   70.1499863,  0.909090936
  43753,   9.86099339,   70.4765625,  0.909090936
  43754,   9.19962025,   70.7821045,  0.909090936
  43755,   8.52879429,   71.0662918,  0.909090936
  43756,   7.84920549,   71.3288269,  0.909090936
  43757,   7.16155005,   71.5694504,  0.909090936
  43758,   6.46653652,   71.7879028,  0.909090936
  43759,    5.7648778,   71.9839706,  0.909090936
  43760,   5.05729342,   72.1574554,  0.909090936
  43761,   4.34451485,   72.3081589,  0.909090936
  43762,   3.62727022,   72.4359512,  0.909090936
  43763,   2.90629911,   72.5406799,  0.909090936
  43764,   2.18234134,   72.6222534,  0.909090936
  43765,   1.45614135,   72.6805801,  0.909090936
  43766,  0.728444934,   72.7155991,  0.909090936
  43767,           0.,    72.727272,  0.909090936
  43768, -0.728444934,   72.7155991,  0.909090936
  43769,  -1.45614135,   72.6805801,  0.909090936
  43770,  -2.18234134,   72.6222534,  0.909090936
  43771,  -2.90629911,   72.5406799,  0.909090936
  43772,  -3.62727022,   72.4359512,  0.909090936
  43773,  -4.34451485,   72.3081589,  0.909090936
  43774,  -5.05729342,   72.1574554,  0.909090936
  43775,   -5.7648778,   71.9839706,  0.909090936
  43776,  -6.46653652,   71.7879028,  0.909090936
  43777,  -7.16155005,   71.5694504,  0.909090936
  43778,  -7.84920549,   71.3288269,  0.909090936
  43779,  -8.52879429,   71.0662918,  0.909090936
  43780,  -9.19962025,   70.7821045,  0.909090936
  43781,  -9.86099339,   70.4765625,  0.909090936
  43782,  -10.5122337,   70.1499863,  0.909090936
  43783,  -11.1526709,   69.8026962,  0.909090936
  43784,  -11.7816515,   69.4350662,  0.909090936
  43785,  -12.3985195,   69.0474548,  0.909090936
  43786,  -13.0026512,   68.6402817,  0.909090936
  43787,    -13.59342,   68.2139435,  0.909090936
  43788,  -14.1702242,    67.768898,  0.909090936
  43789,  -14.7324638,   67.3055878,  0.909090936
  43790,  -15.2795658,    66.824501,  0.909090936
  43791,  -15.8109665,   66.3261185,  0.909090936
  43792,  -16.3261223,   65.8109665,  0.909090936
  43793,  -16.8244991,   65.2795639,  0.909090936
  43794,  -17.3055897,     64.73246,  0.909090936
  43795,   -17.768898,   64.1702194,  0.909090936
  43796,  -18.2139454,   63.5934219,  0.909090936
  43797,  -18.6402779,   63.0026512,  0.909090936
  43798,  -19.0474567,   62.3985214,  0.909090936
  43799,  -19.4350624,   61.7816505,  0.909090936
  43800,  -19.8026981,   61.1526718,  0.909090936
  43801,  -20.1499825,   60.5122337,  0.909090936
  43802,  -20.4765663,   59.8609924,  0.909090936
  43803,  -20.7821064,   59.1996231,  0.909090936
  43804,  -21.0662899,   58.5287971,  0.909090936
  43805,   -21.328825,    57.849205,  0.909090936
  43806,  -21.5694485,   57.1615486,  0.909090936
  43807,  -21.7879066,   56.4665375,  0.909090936
  43808,  -21.9839745,   55.7648773,  0.909090936
  43809,  -22.1574516,   55.0572929,  0.909090936
  43810,  -22.3081627,   54.3445129,  0.909090936
  43811,  -22.4359493,   53.6272697,  0.909090936
  43812,  -22.5406818,   52.9062996,  0.909090936
  43813,  -22.6222553,   52.1823425,  0.909090936
  43814,  -22.6805763,   51.4561424,  0.909090936
  43815,  -22.7155952,   50.7284431,  0.909090936
  43816,   22.7155952,   50.7284431,   1.81818187
  43817,   22.6805763,   51.4561424,   1.81818187
  43818,   22.6222553,   52.1823425,   1.81818187
  43819,   22.5406818,   52.9062996,   1.81818187
  43820,   22.4359493,   53.6272697,   1.81818187
  43821,   22.3081627,   54.3445129,   1.81818187
  43822,   22.1574516,   55.0572929,   1.81818187
  43823,   21.9839745,   55.7648773,   1.81818187
  43824,   21.7879066,   56.4665375,   1.81818187
  43825,   21.5694485,   57.1615486,   1.81818187
  43826,    21.328825,    57.849205,   1.81818187
  43827,   21.0662899,   58.5287971,   1.81818187
  43828,   20.7821064,   59.1996231,   1.81818187
  43829,   20.4765663,   59.8609924,   1.81818187
  43830,   20.1499825,   60.5122337,   1.81818187
  43831,   19.8026981,   61.1526718,   1.81818187
  43832,   19.4350624,   61.7816505,   1.81818187
  43833,   19.0474567,   62.3985214,   1.81818187
  43834,   18.6402779,   63.0026512,   1.81818187
  43835,   18.2139454,   63.5934219,   1.81818187
  43836,    17.768898,   64.1702194,   1.81818187
  43837,   17.3055897,     64.73246,   1.81818187
  43838,   16.8244991,   65.2795639,   1.81818187
  43839,   16.3261223,   65.8109665,   1.81818187
  43840,   15.8109665,   66.3261185,   1.81818187
  43841,   15.2795658,    66.824501,   1.81818187
  43842,   14.7324638,   67.3055878,   1.81818187
  43843,   14.1702242,    67.768898,   1.81818187
  43844,     13.59342,   68.2139435,   1.81818187
  43845,   13.0026512,   68.6402817,   1.81818187
  43846,   12.3985195,   69.0474548,   1.81818187
  43847,   11.7816515,   69.4350662,   1.81818187
  43848,   11.1526709,   69.8026962,   1.81818187
  43849,   10.5122337,   70.1499863,   1.81818187
  43850,   9.86099339,   70.4765625,   1.81818187
  43851,   9.19962025,   70.7821045,   1.81818187
  43852,   8.52879429,   71.0662918,   1.81818187
  43853,   7.84920549,   71.3288269,   1.81818187
  43854,   7.16155005,   71.5694504,   1.81818187
  43855,   6.46653652,   71.7879028,   1.81818187
  43856,    5.7648778,   71.9839706,   1.81818187
  43857,   5.05729342,   72.1574554,   1.81818187
  43858,   4.34451485,   72.3081589,   1.81818187
  43859,   3.62727022,   72.4359512,   1.81818187
  43860,   2.90629911,   72.5406799,   1.81818187
  43861,   2.18234134,   72.6222534,   1.81818187
  43862,   1.45614135,   72.6805801,   1.81818187
  43863,  0.728444934,   72.7155991,   1.81818187
  43864,           0.,    72.727272,   1.81818187
  43865, -0.728444934,   72.7155991,   1.81818187
  43866,  -1.45614135,   72.6805801,   1.81818187
  43867,  -2.18234134,   72.6222534,   1.81818187
  43868,  -2.90629911,   72.5406799,   1.81818187
  43869,  -3.62727022,   72.4359512,   1.81818187
  43870,  -4.34451485,   72.3081589,   1.81818187
  43871,  -5.05729342,   72.1574554,   1.81818187
  43872,   -5.7648778,   71.9839706,   1.81818187
  43873,  -6.46653652,   71.7879028,   1.81818187
  43874,  -7.16155005,   71.5694504,   1.81818187
  43875,  -7.84920549,   71.3288269,   1.81818187
  43876,  -8.52879429,   71.0662918,   1.81818187
  43877,  -9.19962025,   70.7821045,   1.81818187
  43878,  -9.86099339,   70.4765625,   1.81818187
  43879,  -10.5122337,   70.1499863,   1.81818187
  43880,  -11.1526709,   69.8026962,   1.81818187
  43881,  -11.7816515,   69.4350662,   1.81818187
  43882,  -12.3985195,   69.0474548,   1.81818187
  43883,  -13.0026512,   68.6402817,   1.81818187
  43884,    -13.59342,   68.2139435,   1.81818187
  43885,  -14.1702242,    67.768898,   1.81818187
  43886,  -14.7324638,   67.3055878,   1.81818187
  43887,  -15.2795658,    66.824501,   1.81818187
  43888,  -15.8109665,   66.3261185,   1.81818187
  43889,  -16.3261223,   65.8109665,   1.81818187
  43890,  -16.8244991,   65.2795639,   1.81818187
  43891,  -17.3055897,     64.73246,   1.81818187
  43892,   -17.768898,   64.1702194,   1.81818187
  43893,  -18.2139454,   63.5934219,   1.81818187
  43894,  -18.6402779,   63.0026512,   1.81818187
  43895,  -19.0474567,   62.3985214,   1.81818187
  43896,  -19.4350624,   61.7816505,   1.81818187
  43897,  -19.8026981,   61.1526718,   1.81818187
  43898,  -20.1499825,   60.5122337,   1.81818187
  43899,  -20.4765663,   59.8609924,   1.81818187
  43900,  -20.7821064,   59.1996231,   1.81818187
  43901,  -21.0662899,   58.5287971,   1.81818187
  43902,   -21.328825,    57.849205,   1.81818187
  43903,  -21.5694485,   57.1615486,   1.81818187
  43904,  -21.7879066,   56.4665375,   1.81818187
  43905,  -21.9839745,   55.7648773,   1.81818187
  43906,  -22.1574516,   55.0572929,   1.81818187
  43907,  -22.3081627,   54.3445129,   1.81818187
  43908,  -22.4359493,   53.6272697,   1.81818187
  43909,  -22.5406818,   52.9062996,   1.81818187
  43910,  -22.6222553,   52.1823425,   1.81818187
  43911,  -22.6805763,   51.4561424,   1.81818187
  43912,  -22.7155952,   50.7284431,   1.81818187
  43913,   22.7155952,   50.7284431,   2.72727275
  43914,   22.6805763,   51.4561424,   2.72727275
  43915,   22.6222553,   52.1823425,   2.72727275
  43916,   22.5406818,   52.9062996,   2.72727275
  43917,   22.4359493,   53.6272697,   2.72727275
  43918,   22.3081627,   54.3445129,   2.72727275
  43919,   22.1574516,   55.0572929,   2.72727275
  43920,   21.9839745,   55.7648773,   2.72727275
  43921,   21.7879066,   56.4665375,   2.72727275
  43922,   21.5694485,   57.1615486,   2.72727275
  43923,    21.328825,    57.849205,   2.72727275
  43924,   21.0662899,   58.5287971,   2.72727275
  43925,   20.7821064,   59.1996231,   2.72727275
  43926,   20.4765663,   59.8609924,   2.72727275
  43927,   20.1499825,   60.5122337,   2.72727275
  43928,   19.8026981,   61.1526718,   2.72727275
  43929,   19.4350624,   61.7816505,   2.72727275
  43930,   19.0474567,   62.3985214,   2.72727275
  43931,   18.6402779,   63.0026512,   2.72727275
  43932,   18.2139454,   63.5934219,   2.72727275
  43933,    17.768898,   64.1702194,   2.72727275
  43934,   17.3055897,     64.73246,   2.72727275
  43935,   16.8244991,   65.2795639,   2.72727275
  43936,   16.3261223,   65.8109665,   2.72727275
  43937,   15.8109665,   66.3261185,   2.72727275
  43938,   15.2795658,    66.824501,   2.72727275
  43939,   14.7324638,   67.3055878,   2.72727275
  43940,   14.1702242,    67.768898,   2.72727275
  43941,     13.59342,   68.2139435,   2.72727275
  43942,   13.0026512,   68.6402817,   2.72727275
  43943,   12.3985195,   69.0474548,   2.72727275
  43944,   11.7816515,   69.4350662,   2.72727275
  43945,   11.1526709,   69.8026962,   2.72727275
  43946,   10.5122337,   70.1499863,   2.72727275
  43947,   9.86099339,   70.4765625,   2.72727275
  43948,   9.19962025,   70.7821045,   2.72727275
  43949,   8.52879429,   71.0662918,   2.72727275
  43950,   7.84920549,   71.3288269,   2.72727275
  43951,   7.16155005,   71.5694504,   2.72727275
  43952,   6.46653652,   71.7879028,   2.72727275
  43953,    5.7648778,   71.9839706,   2.72727275
  43954,   5.05729342,   72.1574554,   2.72727275
  43955,   4.34451485,   72.3081589,   2.72727275
  43956,   3.62727022,   72.4359512,   2.72727275
  43957,   2.90629911,   72.5406799,   2.72727275
  43958,   2.18234134,   72.6222534,   2.72727275
  43959,   1.45614135,   72.6805801,   2.72727275
  43960,  0.728444934,   72.7155991,   2.72727275
  43961,           0.,    72.727272,   2.72727275
  43962, -0.728444934,   72.7155991,   2.72727275
  43963,  -1.45614135,   72.6805801,   2.72727275
  43964,  -2.18234134,   72.6222534,   2.72727275
  43965,  -2.90629911,   72.5406799,   2.72727275
  43966,  -3.62727022,   72.4359512,   2.72727275
  43967,  -4.34451485,   72.3081589,   2.72727275
  43968,  -5.05729342,   72.1574554,   2.72727275
  43969,   -5.7648778,   71.9839706,   2.72727275
  43970,  -6.46653652,   71.7879028,   2.72727275
  43971,  -7.16155005,   71.5694504,   2.72727275
  43972,  -7.84920549,   71.3288269,   2.72727275
  43973,  -8.52879429,   71.0662918,   2.72727275
  43974,  -9.19962025,   70.7821045,   2.72727275
  43975,  -9.86099339,   70.4765625,   2.72727275
  43976,  -10.5122337,   70.1499863,   2.72727275
  43977,  -11.1526709,   69.8026962,   2.72727275
  43978,  -11.7816515,   69.4350662,   2.72727275
  43979,  -12.3985195,   69.0474548,   2.72727275
  43980,  -13.0026512,   68.6402817,   2.72727275
  43981,    -13.59342,   68.2139435,   2.72727275
  43982,  -14.1702242,    67.768898,   2.72727275
  43983,  -14.7324638,   67.3055878,   2.72727275
  43984,  -15.2795658,    66.824501,   2.72727275
  43985,  -15.8109665,   66.3261185,   2.72727275
  43986,  -16.3261223,   65.8109665,   2.72727275
  43987,  -16.8244991,   65.2795639,   2.72727275
  43988,  -17.3055897,     64.73246,   2.72727275
  43989,   -17.768898,   64.1702194,   2.72727275
  43990,  -18.2139454,   63.5934219,   2.72727275
  43991,  -18.6402779,   63.0026512,   2.72727275
  43992,  -19.0474567,   62.3985214,   2.72727275
  43993,  -19.4350624,   61.7816505,   2.72727275
  43994,  -19.8026981,   61.1526718,   2.72727275
