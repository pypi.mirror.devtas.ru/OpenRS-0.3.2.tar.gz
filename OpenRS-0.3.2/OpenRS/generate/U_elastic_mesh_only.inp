  51995,  -23.5104294,   45.8931427,   2.72727275
  51996,   -22.632822,   45.8931427,   2.72727275
  51997,  -21.7552147,   45.8931427,   2.72727275
  51998,  -20.8776073,   45.8931427,   2.72727275
  51999,   -29.046833,   46.7145119,   2.72727275
  52000,  -28.0936642,   46.7145119,   2.72727275
  52001,  -27.1404972,   46.7145119,   2.72727275
  52002,  -26.1873283,   46.7145119,   2.72727275
  52003,  -25.3034248,   46.7145119,   2.72727275
  52004,  -24.4195194,   46.7145119,   2.72727275
  52005,  -23.5356159,   46.7145119,   2.72727275
  52006,  -22.6517124,   46.7145119,   2.72727275
  52007,  -21.7678089,   46.7145119,   2.72727275
  52008,  -20.8839035,   46.7145119,   2.72727275
  52009,  -29.0578518,   47.5358849,   2.72727275
  52010,  -28.1157036,   47.5358849,   2.72727275
  52011,  -27.1735535,   47.5358849,   2.72727275
  52012,  -26.2314053,   47.5358849,   2.72727275
  52013,  -25.3412056,   47.5358849,   2.72727275
  52014,   -24.451004,   47.5358849,   2.72727275
  52015,  -23.5608025,   47.5358849,   2.72727275
  52016,  -22.6706028,   47.5358849,   2.72727275
  52017,  -21.7804012,   47.5358849,   2.72727275
  52018,  -20.8902016,   47.5358849,   2.72727275
  52019,  -29.0688705,   48.3572578,   2.72727275
  52020,  -28.1377411,   48.3572578,   2.72727275
  52021,  -27.2066116,   48.3572578,   2.72727275
  52022,  -26.2754822,   48.3572578,   2.72727275
  52023,  -25.3789845,   48.3572578,   2.72727275
  52024,  -24.4824867,   48.3572578,   2.72727275
  52025,   -23.585989,   48.3572578,   2.72727275
  52026,  -22.6894932,   48.3572578,   2.72727275
  52027,  -21.7929955,   48.3572578,   2.72727275
  52028,  -20.8964977,   48.3572578,   2.72727275
  52029,  -29.0798912,    49.178627,   2.72727275
  52030,  -28.1597805,    49.178627,   2.72727275
  52031,  -27.2396698,    49.178627,   2.72727275
  52032,  -26.3195591,    49.178627,   2.72727275
  52033,  -25.4167652,    49.178627,   2.72727275
  52034,  -24.5139713,    49.178627,   2.72727275
  52035,  -23.6111774,    49.178627,   2.72727275
  52036,  -22.7083817,    49.178627,   2.72727275
  52037,  -21.8055878,    49.178627,   2.72727275
  52038,  -20.9027939,    49.178627,   2.72727275
  52039,  -29.0826454,   20.7416267,   3.63636374
  52040,  -28.1652889,   20.7416267,   3.63636374
  52041,  -27.2479343,   20.7416267,   3.63636374
  52042,  -26.3305779,   20.7416267,   3.63636374
  52043,  -25.4262104,   20.7416267,   3.63636374
  52044,   -24.521841,   20.7416267,   3.63636374
  52045,  -23.6174736,   20.7416267,   3.63636374
  52046,  -22.7131042,   20.7416267,   3.63636374
  52047,  -21.8087368,   20.7416267,   3.63636374
  52048,  -20.9043694,   20.7416267,   3.63636374
  52049,  -29.0743809,   21.4832535,   3.63636374
  52050,  -28.1487598,   21.4832535,   3.63636374
  52051,  -27.2231407,   21.4832535,   3.63636374
  52052,  -26.2975216,   21.4832535,   3.63636374
  52053,  -25.3978748,   21.4832535,   3.63636374
  52054,  -24.4982281,   21.4832535,   3.63636374
  52055,  -23.5985832,   21.4832535,   3.63636374
  52056,  -22.6989365,   21.4832535,   3.63636374
  52057,  -21.7992916,   21.4832535,   3.63636374
  52058,  -20.8996449,   21.4832535,   3.63636374
  52059,  -29.0661163,   22.2248802,   3.63636374
  52060,  -28.1322308,   22.2248802,   3.63636374
  52061,  -27.1983471,   22.2248802,   3.63636374
  52062,  -26.2644634,   22.2248802,   3.63636374
  52063,  -25.3695393,   22.2248802,   3.63636374
  52064,   -24.474617,   22.2248802,   3.63636374
  52065,  -23.5796928,   22.2248802,   3.63636374
  52066,  -22.6847687,   22.2248802,   3.63636374
  52067,  -21.7898464,   22.2248802,   3.63636374
  52068,  -20.8949223,   22.2248802,   3.63636374
  52069,  -29.0578518,    22.966507,   3.63636374
  52070,  -28.1157036,    22.966507,   3.63636374
  52071,  -27.1735535,    22.966507,   3.63636374
  52072,  -26.2314053,    22.966507,   3.63636374
  52073,  -25.3412037,    22.966507,   3.63636374
  52074,   -24.451004,    22.966507,   3.63636374
  52075,  -23.5608025,    22.966507,   3.63636374
  52076,  -22.6706028,    22.966507,   3.63636374
  52077,  -21.7804012,    22.966507,   3.63636374
  52078,  -20.8901997,    22.966507,   3.63636374
  52079,  -29.0495872,   23.7081337,   3.63636374
  52080,  -28.0991745,   23.7081337,   3.63636374
  52081,  -27.1487617,   23.7081337,   3.63636374
  52082,  -26.1983471,   23.7081337,   3.63636374
  52083,  -25.3128681,   23.7081337,   3.63636374
  52084,  -24.4273911,   23.7081337,   3.63636374
  52085,  -23.5419121,   23.7081337,   3.63636374
  52086,   -22.656435,   23.7081337,   3.63636374
  52087,   -21.770956,   23.7081337,   3.63636374
  52088,  -20.8854771,   23.7081337,   3.63636374
  52089,  -29.0413227,   24.4497604,   3.63636374
  52090,  -28.0826454,   24.4497604,   3.63636374
  52091,  -27.1239681,   24.4497604,   3.63636374
  52092,  -26.1652889,   24.4497604,   3.63636374
  52093,  -25.2845345,   24.4497604,   3.63636374
  52094,  -24.4037781,   24.4497604,   3.63636374
  52095,  -23.5230217,   24.4497604,   3.63636374
  52096,  -22.6422672,   24.4497604,   3.63636374
  52097,  -21.7615108,   24.4497604,   3.63636374
  52098,  -20.8807564,   24.4497604,   3.63636374
  52099,  -29.0330582,   25.1913872,   3.63636374
  52100,  -28.0661163,   25.1913872,   3.63636374
  52101,  -27.0991745,   25.1913872,   3.63636374
  52102,  -26.1322308,   25.1913872,   3.63636374
  52103,  -25.2561989,   25.1913872,   3.63636374
  52104,  -24.3801651,   25.1913872,   3.63636374
  52105,  -23.5041332,   25.1913872,   3.63636374
  52106,  -22.6280994,   25.1913872,   3.63636374
  52107,  -21.7520657,   25.1913872,   3.63636374
  52108,  -20.8760338,   25.1913872,   3.63636374
  52109,  -29.0330582,   25.9875603,   3.63636374
  52110,  -28.0661163,   25.9875603,   3.63636374
  52111,  -27.0991745,   25.9875603,   3.63636374
  52112,  -26.1322308,   25.9875603,   3.63636374
  52113,  -25.2561989,   25.9875603,   3.63636374
  52114,  -24.3801651,   25.9875603,   3.63636374
  52115,  -23.5041332,   25.9875603,   3.63636374
  52116,  -22.6280994,   25.9875603,   3.63636374
  52117,  -21.7520657,   25.9875603,   3.63636374
  52118,  -20.8760338,   25.9875603,   3.63636374
  52119,  -29.0330582,   26.7837315,   3.63636374
  52120,  -28.0661163,   26.7837315,   3.63636374
  52121,  -27.0991745,   26.7837315,   3.63636374
  52122,  -26.1322308,   26.7837315,   3.63636374
  52123,  -25.2561989,   26.7837315,   3.63636374
  52124,  -24.3801651,   26.7837315,   3.63636374
  52125,  -23.5041332,   26.7837315,   3.63636374
  52126,  -22.6280994,   26.7837315,   3.63636374
  52127,  -21.7520657,   26.7837315,   3.63636374
  52128,  -20.8760338,   26.7837315,   3.63636374
  52129,  -29.0330582,   27.5799046,   3.63636374
  52130,  -28.0661163,   27.5799046,   3.63636374
  52131,  -27.0991745,   27.5799046,   3.63636374
  52132,  -26.1322308,   27.5799046,   3.63636374
  52133,  -25.2561989,   27.5799046,   3.63636374
  52134,  -24.3801651,   27.5799046,   3.63636374
  52135,  -23.5041332,   27.5799046,   3.63636374
  52136,  -22.6280994,   27.5799046,   3.63636374
  52137,  -21.7520657,   27.5799046,   3.63636374
  52138,  -20.8760338,   27.5799046,   3.63636374
  52139,  -29.0330582,   28.3760757,   3.63636374
  52140,  -28.0661163,   28.3760757,   3.63636374
  52141,  -27.0991745,   28.3760757,   3.63636374
  52142,  -26.1322308,   28.3760757,   3.63636374
  52143,  -25.2561989,   28.3760757,   3.63636374
  52144,  -24.3801651,   28.3760757,   3.63636374
  52145,  -23.5041332,   28.3760757,   3.63636374
  52146,  -22.6280994,   28.3760757,   3.63636374
  52147,  -21.7520657,   28.3760757,   3.63636374
  52148,  -20.8760338,   28.3760757,   3.63636374
  52149,  -29.0330582,   29.1722488,   3.63636374
  52150,  -28.0661163,   29.1722488,   3.63636374
  52151,  -27.0991745,   29.1722488,   3.63636374
  52152,  -26.1322308,   29.1722488,   3.63636374
  52153,  -25.2561989,   29.1722488,   3.63636374
  52154,  -24.3801651,   29.1722488,   3.63636374
  52155,  -23.5041332,   29.1722488,   3.63636374
  52156,  -22.6280994,   29.1722488,   3.63636374
  52157,  -21.7520657,   29.1722488,   3.63636374
  52158,  -20.8760338,   29.1722488,   3.63636374
  52159,  -29.0330582,   29.9684219,   3.63636374
  52160,  -28.0661163,   29.9684219,   3.63636374
  52161,  -27.0991745,   29.9684219,   3.63636374
  52162,  -26.1322308,   29.9684219,   3.63636374
  52163,  -25.2561989,   29.9684219,   3.63636374
  52164,  -24.3801651,   29.9684219,   3.63636374
  52165,  -23.5041332,   29.9684219,   3.63636374
  52166,  -22.6280994,   29.9684219,   3.63636374
  52167,  -21.7520657,   29.9684219,   3.63636374
  52168,  -20.8760338,   29.9684219,   3.63636374
  52169,  -29.0330582,   30.7645931,   3.63636374
  52170,  -28.0661163,   30.7645931,   3.63636374
  52171,  -27.0991745,   30.7645931,   3.63636374
  52172,  -26.1322308,   30.7645931,   3.63636374
  52173,  -25.2561989,   30.7645931,   3.63636374
  52174,  -24.3801651,   30.7645931,   3.63636374
  52175,  -23.5041332,   30.7645931,   3.63636374
  52176,  -22.6280994,   30.7645931,   3.63636374
  52177,  -21.7520657,   30.7645931,   3.63636374
  52178,  -20.8760338,   30.7645931,   3.63636374
  52179,  -29.0330582,   31.5607662,   3.63636374
  52180,  -28.0661163,   31.5607662,   3.63636374
  52181,  -27.0991745,   31.5607662,   3.63636374
  52182,  -26.1322308,   31.5607662,   3.63636374
  52183,  -25.2561989,   31.5607662,   3.63636374
  52184,  -24.3801651,   31.5607662,   3.63636374
  52185,  -23.5041332,   31.5607662,   3.63636374
  52186,  -22.6280994,   31.5607662,   3.63636374
  52187,  -21.7520657,   31.5607662,   3.63636374
  52188,  -20.8760338,   31.5607662,   3.63636374
  52189,  -29.0330582,   32.3569374,   3.63636374
  52190,  -28.0661163,   32.3569374,   3.63636374
  52191,  -27.0991745,   32.3569374,   3.63636374
  52192,  -26.1322308,   32.3569374,   3.63636374
  52193,  -25.2561989,   32.3569374,   3.63636374
  52194,  -24.3801651,   32.3569374,   3.63636374
  52195,  -23.5041332,   32.3569374,   3.63636374
  52196,  -22.6280994,   32.3569374,   3.63636374
  52197,  -21.7520657,   32.3569374,   3.63636374
  52198,  -20.8760338,   32.3569374,   3.63636374
  52199,  -29.0330582,   33.1531105,   3.63636374
  52200,  -28.0661163,   33.1531105,   3.63636374
  52201,  -27.0991745,   33.1531105,   3.63636374
  52202,  -26.1322308,   33.1531105,   3.63636374
  52203,  -25.2561989,   33.1531105,   3.63636374
  52204,  -24.3801651,   33.1531105,   3.63636374
  52205,  -23.5041332,   33.1531105,   3.63636374
  52206,  -22.6280994,   33.1531105,   3.63636374
  52207,  -21.7520657,   33.1531105,   3.63636374
  52208,  -20.8760338,   33.1531105,   3.63636374
  52209,  -29.0330582,   33.9492836,   3.63636374
  52210,  -28.0661163,   33.9492836,   3.63636374
  52211,  -27.0991745,   33.9492836,   3.63636374
  52212,  -26.1322308,   33.9492836,   3.63636374
  52213,  -25.2561989,   33.9492836,   3.63636374
  52214,  -24.3801651,   33.9492836,   3.63636374
  52215,  -23.5041332,   33.9492836,   3.63636374
  52216,  -22.6280994,   33.9492836,   3.63636374
  52217,  -21.7520657,   33.9492836,   3.63636374
  52218,  -20.8760338,   33.9492836,   3.63636374
  52219,  -29.0330582,   34.7454529,   3.63636374
  52220,  -28.0661163,   34.7454529,   3.63636374
  52221,  -27.0991745,   34.7454529,   3.63636374
  52222,  -26.1322308,   34.7454529,   3.63636374
  52223,  -25.2561989,   34.7454529,   3.63636374
  52224,  -24.3801651,   34.7454529,   3.63636374
  52225,  -23.5041332,   34.7454529,   3.63636374
  52226,  -22.6280994,   34.7454529,   3.63636374
  52227,  -21.7520657,   34.7454529,   3.63636374
  52228,  -20.8760338,   34.7454529,   3.63636374
  52229,  -29.0330582,    35.541626,   3.63636374
  52230,  -28.0661163,    35.541626,   3.63636374
  52231,  -27.0991745,    35.541626,   3.63636374
  52232,  -26.1322308,    35.541626,   3.63636374
  52233,  -25.2561989,    35.541626,   3.63636374
  52234,  -24.3801651,    35.541626,   3.63636374
  52235,  -23.5041332,    35.541626,   3.63636374
  52236,  -22.6280994,    35.541626,   3.63636374
  52237,  -21.7520657,    35.541626,   3.63636374
  52238,  -20.8760338,    35.541626,   3.63636374
  52239,  -29.0330582,   36.3377991,   3.63636374
  52240,  -28.0661163,   36.3377991,   3.63636374
  52241,  -27.0991745,   36.3377991,   3.63636374
  52242,  -26.1322308,   36.3377991,   3.63636374
  52243,  -25.2561989,   36.3377991,   3.63636374
  52244,  -24.3801651,   36.3377991,   3.63636374
  52245,  -23.5041332,   36.3377991,   3.63636374
  52246,  -22.6280994,   36.3377991,   3.63636374
  52247,  -21.7520657,   36.3377991,   3.63636374
  52248,  -20.8760338,   36.3377991,   3.63636374
  52249,  -29.0330582,   37.1339722,   3.63636374
  52250,  -28.0661163,   37.1339722,   3.63636374
  52251,  -27.0991745,   37.1339722,   3.63636374
  52252,  -26.1322308,   37.1339722,   3.63636374
  52253,  -25.2561989,   37.1339722,   3.63636374
  52254,  -24.3801651,   37.1339722,   3.63636374
  52255,  -23.5041332,   37.1339722,   3.63636374
  52256,  -22.6280994,   37.1339722,   3.63636374
  52257,  -21.7520657,   37.1339722,   3.63636374
  52258,  -20.8760338,   37.1339722,   3.63636374
  52259,  -29.0330582,   37.9301453,   3.63636374
  52260,  -28.0661163,   37.9301453,   3.63636374
  52261,  -27.0991745,   37.9301453,   3.63636374
  52262,  -26.1322308,   37.9301453,   3.63636374
  52263,  -25.2561989,   37.9301453,   3.63636374
  52264,  -24.3801651,   37.9301453,   3.63636374
  52265,  -23.5041332,   37.9301453,   3.63636374
  52266,  -22.6280994,   37.9301453,   3.63636374
  52267,  -21.7520657,   37.9301453,   3.63636374
  52268,  -20.8760338,   37.9301453,   3.63636374
  52269,  -29.0330582,   38.7263145,   3.63636374
  52270,  -28.0661163,   38.7263145,   3.63636374
  52271,  -27.0991745,   38.7263145,   3.63636374
  52272,  -26.1322308,   38.7263145,   3.63636374
  52273,  -25.2561989,   38.7263145,   3.63636374
  52274,  -24.3801651,   38.7263145,   3.63636374
  52275,  -23.5041332,   38.7263145,   3.63636374
  52276,  -22.6280994,   38.7263145,   3.63636374
  52277,  -21.7520657,   38.7263145,   3.63636374
  52278,  -20.8760338,   38.7263145,   3.63636374
  52279,  -29.0330582,   39.5224876,   3.63636374
  52280,  -28.0661163,   39.5224876,   3.63636374
  52281,  -27.0991745,   39.5224876,   3.63636374
  52282,  -26.1322308,   39.5224876,   3.63636374
  52283,  -25.2561989,   39.5224876,   3.63636374
  52284,  -24.3801651,   39.5224876,   3.63636374
  52285,  -23.5041332,   39.5224876,   3.63636374
  52286,  -22.6280994,   39.5224876,   3.63636374
  52287,  -21.7520657,   39.5224876,   3.63636374
  52288,  -20.8760338,   39.5224876,   3.63636374
  52289,  -29.0330582,   40.3186607,   3.63636374
  52290,  -28.0661163,   40.3186607,   3.63636374
  52291,  -27.0991745,   40.3186607,   3.63636374
  52292,  -26.1322308,   40.3186607,   3.63636374
  52293,  -25.2561989,   40.3186607,   3.63636374
  52294,  -24.3801651,   40.3186607,   3.63636374
  52295,  -23.5041332,   40.3186607,   3.63636374
  52296,  -22.6280994,   40.3186607,   3.63636374
  52297,  -21.7520657,   40.3186607,   3.63636374
  52298,  -20.8760338,   40.3186607,   3.63636374
  52299,  -29.0330582,   41.1148338,   3.63636374
  52300,  -28.0661163,   41.1148338,   3.63636374
  52301,  -27.0991745,   41.1148338,   3.63636374
  52302,  -26.1322308,   41.1148338,   3.63636374
  52303,  -25.2561989,   41.1148338,   3.63636374
  52304,  -24.3801651,   41.1148338,   3.63636374
  52305,  -23.5041332,   41.1148338,   3.63636374
  52306,  -22.6280994,   41.1148338,   3.63636374
  52307,  -21.7520657,   41.1148338,   3.63636374
  52308,  -20.8760338,   41.1148338,   3.63636374
  52309,  -29.0330582,   41.9110031,   3.63636374
  52310,  -28.0661163,   41.9110031,   3.63636374
  52311,  -27.0991745,   41.9110031,   3.63636374
  52312,  -26.1322308,   41.9110031,   3.63636374
  52313,  -25.2561989,   41.9110031,   3.63636374
  52314,  -24.3801651,   41.9110031,   3.63636374
  52315,  -23.5041332,   41.9110031,   3.63636374
  52316,  -22.6280994,   41.9110031,   3.63636374
  52317,  -21.7520657,   41.9110031,   3.63636374
  52318,  -20.8760338,   41.9110031,   3.63636374
  52319,  -29.0330582,   42.7071762,   3.63636374
  52320,  -28.0661163,   42.7071762,   3.63636374
  52321,  -27.0991745,   42.7071762,   3.63636374
  52322,  -26.1322308,   42.7071762,   3.63636374
  52323,  -25.2561989,   42.7071762,   3.63636374
  52324,  -24.3801651,   42.7071762,   3.63636374
  52325,  -23.5041332,   42.7071762,   3.63636374
  52326,  -22.6280994,   42.7071762,   3.63636374
  52327,  -21.7520657,   42.7071762,   3.63636374
  52328,  -20.8760338,   42.7071762,   3.63636374
  52329,  -29.0330582,   43.5033493,   3.63636374
  52330,  -28.0661163,   43.5033493,   3.63636374
  52331,  -27.0991745,   43.5033493,   3.63636374
  52332,  -26.1322308,   43.5033493,   3.63636374
  52333,  -25.2561989,   43.5033493,   3.63636374
  52334,  -24.3801651,   43.5033493,   3.63636374
  52335,  -23.5041332,   43.5033493,   3.63636374
  52336,  -22.6280994,   43.5033493,   3.63636374
  52337,  -21.7520657,   43.5033493,   3.63636374
  52338,  -20.8760338,   43.5033493,   3.63636374
  52339,  -29.0330582,   44.2995224,   3.63636374
  52340,  -28.0661163,   44.2995224,   3.63636374
  52341,  -27.0991745,   44.2995224,   3.63636374
  52342,  -26.1322308,   44.2995224,   3.63636374
  52343,  -25.2561989,   44.2995224,   3.63636374
  52344,  -24.3801651,   44.2995224,   3.63636374
  52345,  -23.5041332,   44.2995224,   3.63636374
  52346,  -22.6280994,   44.2995224,   3.63636374
  52347,  -21.7520657,   44.2995224,   3.63636374
  52348,  -20.8760338,   44.2995224,   3.63636374
  52349,  -29.0330582,   45.0956955,   3.63636374
  52350,  -28.0661163,   45.0956955,   3.63636374
  52351,  -27.0991745,   45.0956955,   3.63636374
  52352,  -26.1322308,   45.0956955,   3.63636374
  52353,  -25.2561989,   45.0956955,   3.63636374
  52354,  -24.3801651,   45.0956955,   3.63636374
  52355,  -23.5041332,   45.0956955,   3.63636374
  52356,  -22.6280994,   45.0956955,   3.63636374
  52357,  -21.7520657,   45.0956955,   3.63636374
  52358,  -20.8760338,   45.0956955,   3.63636374
  52359,  -29.0426998,   45.9130783,   3.63636374
  52360,  -28.0853996,   45.9130783,   3.63636374
  52361,  -27.1280994,   45.9130783,   3.63636374
  52362,  -26.1707993,   45.9130783,   3.63636374
  52363,   -25.289257,   45.9130783,   3.63636374
  52364,  -24.4077129,   45.9130783,   3.63636374
  52365,  -23.5261707,   45.9130783,   3.63636374
  52366,  -22.6446285,   45.9130783,   3.63636374
  52367,  -21.7630863,   45.9130783,   3.63636374
  52368,  -20.8815422,   45.9130783,   3.63636374
  52369,  -29.0523434,   46.7304611,   3.63636374
  52370,  -28.1046829,   46.7304611,   3.63636374
  52371,  -27.1570263,   46.7304611,   3.63636374
  52372,  -26.2093658,   46.7304611,   3.63636374
  52373,  -25.3223152,   46.7304611,   3.63636374
  52374,  -24.4352608,   46.7304611,   3.63636374
  52375,  -23.5482101,   46.7304611,   3.63636374
  52376,  -22.6611576,   46.7304611,   3.63636374
  52377,  -21.7741051,   46.7304611,   3.63636374
  52378,  -20.8870525,   46.7304611,   3.63636374
  52379,  -29.0619831,   47.5478477,   3.63636374
  52380,  -28.1239681,   47.5478477,   3.63636374
  52381,  -27.1859512,   47.5478477,   3.63636374
  52382,  -26.2479343,   47.5478477,   3.63636374
  52383,  -25.3553734,   47.5478477,   3.63636374
  52384,  -24.4628105,   47.5478477,   3.63636374
  52385,  -23.5702477,   47.5478477,   3.63636374
  52386,  -22.6776867,   47.5478477,   3.63636374
  52387,  -21.7851238,   47.5478477,   3.63636374
  52388,  -20.8925629,   47.5478477,   3.63636374
  52389,  -29.0716248,   48.3652306,   3.63636374
  52390,  -28.1432514,   48.3652306,   3.63636374
  52391,  -27.2148762,   48.3652306,   3.63636374
  52392,  -26.2865009,   48.3652306,   3.63636374
  52393,  -25.3884296,   48.3652306,   3.63636374
  52394,  -24.4903584,   48.3652306,   3.63636374
  52395,  -23.5922852,   48.3652306,   3.63636374
  52396,  -22.6942158,   48.3652306,   3.63636374
  52397,  -21.7961445,   48.3652306,   3.63636374
  52398,  -20.8980713,   48.3652306,   3.63636374
  52399,  -29.0812683,   49.1826172,   3.63636374
  52400,  -28.1625347,   49.1826172,   3.63636374
  52401,  -27.2438011,   49.1826172,   3.63636374
  52402,  -26.3250694,   49.1826172,   3.63636374
  52403,  -25.4214878,   49.1826172,   3.63636374
  52404,  -24.5179062,   49.1826172,   3.63636374
  52405,  -23.6143265,   49.1826172,   3.63636374
  52406,   -22.710743,   49.1826172,   3.63636374
  52407,  -21.8071613,   49.1826172,   3.63636374
  52408,  -20.9035816,   49.1826172,   3.63636374
  52409,  -29.0838261,   20.7484627,    4.5454545
  52410,  -28.1676502,   20.7484627,    4.5454545
  52411,  -27.2514763,   20.7484627,    4.5454545
  52412,  -26.3353004,   20.7484627,    4.5454545
  52413,  -25.4302578,   20.7484627,    4.5454545
  52414,  -24.5252151,   20.7484627,    4.5454545
  52415,  -23.6201725,   20.7484627,    4.5454545
  52416,  -22.7151279,   20.7484627,    4.5454545
  52417,  -21.8100853,   20.7484627,    4.5454545
  52418,  -20.9050426,   20.7484627,    4.5454545
  52419,  -29.0767422,   21.4969234,    4.5454545
  52420,  -28.1534824,   21.4969234,    4.5454545
  52421,  -27.2302246,   21.4969234,    4.5454545
  52422,  -26.3069668,   21.4969234,    4.5454545
  52423,  -25.4059715,   21.4969234,    4.5454545
  52424,  -24.5049744,   21.4969234,    4.5454545
  52425,   -23.603981,   21.4969234,    4.5454545
  52426,  -22.7029839,   21.4969234,    4.5454545
  52427,  -21.8019905,   21.4969234,    4.5454545
  52428,  -20.9009953,   21.4969234,    4.5454545
  52429,  -29.0696583,   22.2453861,    4.5454545
  52430,  -28.1393147,   22.2453861,    4.5454545
  52431,  -27.2089729,   22.2453861,    4.5454545
  52432,  -26.2786312,   22.2453861,    4.5454545
  52433,  -25.3816833,   22.2453861,    4.5454545
  52434,  -24.4847355,   22.2453861,    4.5454545
  52435,  -23.5877895,   22.2453861,    4.5454545
  52436,  -22.6908417,   22.2453861,    4.5454545
  52437,  -21.7938938,   22.2453861,    4.5454545
  52438,   -20.896946,   22.2453861,    4.5454545
  52439,  -29.0625744,   22.9938488,    4.5454545
  52440,  -28.1251488,   22.9938488,    4.5454545
  52441,  -27.1877213,   22.9938488,    4.5454545
  52442,  -26.2502956,   22.9938488,    4.5454545
  52443,  -25.3573952,   22.9938488,    4.5454545
  52444,  -24.4644966,   22.9938488,    4.5454545
  52445,  -23.5715981,   22.9938488,    4.5454545
  52446,  -22.6786976,   22.9938488,    4.5454545
  52447,   -21.785799,   22.9938488,    4.5454545
  52448,  -20.8928986,   22.9938488,    4.5454545
  52449,  -29.0554905,   23.7423096,    4.5454545
  52450,   -28.110981,   23.7423096,    4.5454545
  52451,  -27.1664715,   23.7423096,    4.5454545
  52452,  -26.2219601,   23.7423096,    4.5454545
  52453,  -25.3331089,   23.7423096,    4.5454545
  52454,  -24.4442577,   23.7423096,    4.5454545
  52455,  -23.5554047,   23.7423096,    4.5454545
  52456,  -22.6665535,   23.7423096,    4.5454545
  52457,  -21.7777023,   23.7423096,    4.5454545
  52458,  -20.8888512,   23.7423096,    4.5454545
  52459,  -29.0484066,   24.4907722,    4.5454545
  52460,  -28.0968132,   24.4907722,    4.5454545
  52461,  -27.1452198,   24.4907722,    4.5454545
  52462,  -26.1936245,   24.4907722,    4.5454545
  52463,  -25.3088207,   24.4907722,    4.5454545
  52464,   -24.424017,   24.4907722,    4.5454545
  52465,  -23.5392132,   24.4907722,    4.5454545
  52466,  -22.6544113,   24.4907722,    4.5454545
  52467,  -21.7696075,   24.4907722,    4.5454545
  52468,  -20.8848038,   24.4907722,    4.5454545
  52469,  -29.0413227,   25.2392349,    4.5454545
  52470,  -28.0826454,   25.2392349,    4.5454545
  52471,  -27.1239681,   25.2392349,    4.5454545
  52472,  -26.1652889,   25.2392349,    4.5454545
  52473,  -25.2845345,   25.2392349,    4.5454545
  52474,  -24.4037781,   25.2392349,    4.5454545
  52475,  -23.5230236,   25.2392349,    4.5454545
  52476,  -22.6422672,   25.2392349,    4.5454545
  52477,  -21.7615108,   25.2392349,    4.5454545
  52478,  -20.8807564,   25.2392349,    4.5454545
  52479,  -29.0413227,   26.0344505,    4.5454545
  52480,  -28.0826454,   26.0344505,    4.5454545
  52481,  -27.1239681,   26.0344505,    4.5454545
  52482,  -26.1652889,   26.0344505,    4.5454545
  52483,  -25.2845345,   26.0344505,    4.5454545
  52484,  -24.4037781,   26.0344505,    4.5454545
  52485,  -23.5230236,   26.0344505,    4.5454545
  52486,  -22.6422672,   26.0344505,    4.5454545
  52487,  -21.7615108,   26.0344505,    4.5454545
  52488,  -20.8807564,   26.0344505,    4.5454545
  52489,  -29.0413227,   26.8296642,    4.5454545
  52490,  -28.0826454,   26.8296642,    4.5454545
  52491,  -27.1239681,   26.8296642,    4.5454545
  52492,  -26.1652889,   26.8296642,    4.5454545
  52493,  -25.2845345,   26.8296642,    4.5454545
  52494,  -24.4037781,   26.8296642,    4.5454545
  52495,  -23.5230236,   26.8296642,    4.5454545
  52496,  -22.6422672,   26.8296642,    4.5454545
  52497,  -21.7615108,   26.8296642,    4.5454545
  52498,  -20.8807564,   26.8296642,    4.5454545
  52499,  -29.0413227,   27.6248798,    4.5454545
  52500,  -28.0826454,   27.6248798,    4.5454545
  52501,  -27.1239681,   27.6248798,    4.5454545
  52502,  -26.1652889,   27.6248798,    4.5454545
  52503,  -25.2845345,   27.6248798,    4.5454545
  52504,  -24.4037781,   27.6248798,    4.5454545
  52505,  -23.5230236,   27.6248798,    4.5454545
  52506,  -22.6422672,   27.6248798,    4.5454545
  52507,  -21.7615108,   27.6248798,    4.5454545
  52508,  -20.8807564,   27.6248798,    4.5454545
  52509,  -29.0413227,   28.4200954,    4.5454545
  52510,  -28.0826454,   28.4200954,    4.5454545
  52511,  -27.1239681,   28.4200954,    4.5454545
  52512,  -26.1652889,   28.4200954,    4.5454545
  52513,  -25.2845345,   28.4200954,    4.5454545
  52514,  -24.4037781,   28.4200954,    4.5454545
  52515,  -23.5230236,   28.4200954,    4.5454545
  52516,  -22.6422672,   28.4200954,    4.5454545
  52517,  -21.7615108,   28.4200954,    4.5454545
  52518,  -20.8807564,   28.4200954,    4.5454545
  52519,  -29.0413227,   29.2153111,    4.5454545
  52520,  -28.0826454,   29.2153111,    4.5454545
  52521,  -27.1239681,   29.2153111,    4.5454545
  52522,  -26.1652889,   29.2153111,    4.5454545
  52523,  -25.2845345,   29.2153111,    4.5454545
  52524,  -24.4037781,   29.2153111,    4.5454545
  52525,  -23.5230236,   29.2153111,    4.5454545
  52526,  -22.6422672,   29.2153111,    4.5454545
  52527,  -21.7615108,   29.2153111,    4.5454545
  52528,  -20.8807564,   29.2153111,    4.5454545
  52529,  -29.0413227,   30.0105267,    4.5454545
  52530,  -28.0826454,   30.0105267,    4.5454545
  52531,  -27.1239681,   30.0105267,    4.5454545
  52532,  -26.1652889,   30.0105267,    4.5454545
  52533,  -25.2845345,   30.0105267,    4.5454545
  52534,  -24.4037781,   30.0105267,    4.5454545
  52535,  -23.5230236,   30.0105267,    4.5454545
  52536,  -22.6422672,   30.0105267,    4.5454545
  52537,  -21.7615108,   30.0105267,    4.5454545
  52538,  -20.8807564,   30.0105267,    4.5454545
  52539,  -29.0413227,   30.8057423,    4.5454545
  52540,  -28.0826454,   30.8057423,    4.5454545
  52541,  -27.1239681,   30.8057423,    4.5454545
  52542,  -26.1652889,   30.8057423,    4.5454545
  52543,  -25.2845345,   30.8057423,    4.5454545
  52544,  -24.4037781,   30.8057423,    4.5454545
  52545,  -23.5230236,   30.8057423,    4.5454545
  52546,  -22.6422672,   30.8057423,    4.5454545
  52547,  -21.7615108,   30.8057423,    4.5454545
  52548,  -20.8807564,   30.8057423,    4.5454545
  52549,  -29.0413227,   31.6009579,    4.5454545
  52550,  -28.0826454,   31.6009579,    4.5454545
  52551,  -27.1239681,   31.6009579,    4.5454545
  52552,  -26.1652889,   31.6009579,    4.5454545
  52553,  -25.2845345,   31.6009579,    4.5454545
  52554,  -24.4037781,   31.6009579,    4.5454545
  52555,  -23.5230236,   31.6009579,    4.5454545
  52556,  -22.6422672,   31.6009579,    4.5454545
  52557,  -21.7615108,   31.6009579,    4.5454545
  52558,  -20.8807564,   31.6009579,    4.5454545
  52559,  -29.0413227,   32.3961716,    4.5454545
  52560,  -28.0826454,   32.3961716,    4.5454545
  52561,  -27.1239681,   32.3961716,    4.5454545
  52562,  -26.1652889,   32.3961716,    4.5454545
  52563,  -25.2845345,   32.3961716,    4.5454545
  52564,  -24.4037781,   32.3961716,    4.5454545
  52565,  -23.5230236,   32.3961716,    4.5454545
  52566,  -22.6422672,   32.3961716,    4.5454545
  52567,  -21.7615108,   32.3961716,    4.5454545
  52568,  -20.8807564,   32.3961716,    4.5454545
  52569,  -29.0413227,   33.1913872,    4.5454545
  52570,  -28.0826454,   33.1913872,    4.5454545
  52571,  -27.1239681,   33.1913872,    4.5454545
  52572,  -26.1652889,   33.1913872,    4.5454545
  52573,  -25.2845345,   33.1913872,    4.5454545
  52574,  -24.4037781,   33.1913872,    4.5454545
  52575,  -23.5230236,   33.1913872,    4.5454545
  52576,  -22.6422672,   33.1913872,    4.5454545
  52577,  -21.7615108,   33.1913872,    4.5454545
  52578,  -20.8807564,   33.1913872,    4.5454545
  52579,  -29.0413227,   33.9866028,    4.5454545
  52580,  -28.0826454,   33.9866028,    4.5454545
  52581,  -27.1239681,   33.9866028,    4.5454545
  52582,  -26.1652889,   33.9866028,    4.5454545
  52583,  -25.2845345,   33.9866028,    4.5454545
  52584,  -24.4037781,   33.9866028,    4.5454545
  52585,  -23.5230236,   33.9866028,    4.5454545
  52586,  -22.6422672,   33.9866028,    4.5454545
  52587,  -21.7615108,   33.9866028,    4.5454545
  52588,  -20.8807564,   33.9866028,    4.5454545
  52589,  -29.0413227,   34.7818184,    4.5454545
  52590,  -28.0826454,   34.7818184,    4.5454545
  52591,  -27.1239681,   34.7818184,    4.5454545
  52592,  -26.1652889,   34.7818184,    4.5454545
  52593,  -25.2845345,   34.7818184,    4.5454545
  52594,  -24.4037781,   34.7818184,    4.5454545
  52595,  -23.5230236,   34.7818184,    4.5454545
  52596,  -22.6422672,   34.7818184,    4.5454545
  52597,  -21.7615108,   34.7818184,    4.5454545
  52598,  -20.8807564,   34.7818184,    4.5454545
  52599,  -29.0413227,    35.577034,    4.5454545
  52600,  -28.0826454,    35.577034,    4.5454545
  52601,  -27.1239681,    35.577034,    4.5454545
  52602,  -26.1652889,    35.577034,    4.5454545
  52603,  -25.2845345,    35.577034,    4.5454545
  52604,  -24.4037781,    35.577034,    4.5454545
  52605,  -23.5230236,    35.577034,    4.5454545
  52606,  -22.6422672,    35.577034,    4.5454545
  52607,  -21.7615108,    35.577034,    4.5454545
  52608,  -20.8807564,    35.577034,    4.5454545
  52609,  -29.0413227,   36.3722496,    4.5454545
  52610,  -28.0826454,   36.3722496,    4.5454545
  52611,  -27.1239681,   36.3722496,    4.5454545
  52612,  -26.1652889,   36.3722496,    4.5454545
  52613,  -25.2845345,   36.3722496,    4.5454545
  52614,  -24.4037781,   36.3722496,    4.5454545
  52615,  -23.5230236,   36.3722496,    4.5454545
  52616,  -22.6422672,   36.3722496,    4.5454545
  52617,  -21.7615108,   36.3722496,    4.5454545
  52618,  -20.8807564,   36.3722496,    4.5454545
  52619,  -29.0413227,   37.1674652,    4.5454545
  52620,  -28.0826454,   37.1674652,    4.5454545
  52621,  -27.1239681,   37.1674652,    4.5454545
  52622,  -26.1652889,   37.1674652,    4.5454545
  52623,  -25.2845345,   37.1674652,    4.5454545
  52624,  -24.4037781,   37.1674652,    4.5454545
  52625,  -23.5230236,   37.1674652,    4.5454545
  52626,  -22.6422672,   37.1674652,    4.5454545
  52627,  -21.7615108,   37.1674652,    4.5454545
  52628,  -20.8807564,   37.1674652,    4.5454545
  52629,  -29.0413227,   37.9626808,    4.5454545
  52630,  -28.0826454,   37.9626808,    4.5454545
  52631,  -27.1239681,   37.9626808,    4.5454545
  52632,  -26.1652889,   37.9626808,    4.5454545
  52633,  -25.2845345,   37.9626808,    4.5454545
  52634,  -24.4037781,   37.9626808,    4.5454545
  52635,  -23.5230236,   37.9626808,    4.5454545
  52636,  -22.6422672,   37.9626808,    4.5454545
  52637,  -21.7615108,   37.9626808,    4.5454545
  52638,  -20.8807564,   37.9626808,    4.5454545
  52639,  -29.0413227,   38.7578964,    4.5454545
  52640,  -28.0826454,   38.7578964,    4.5454545
  52641,  -27.1239681,   38.7578964,    4.5454545
  52642,  -26.1652889,   38.7578964,    4.5454545
  52643,  -25.2845345,   38.7578964,    4.5454545
  52644,  -24.4037781,   38.7578964,    4.5454545
  52645,  -23.5230236,   38.7578964,    4.5454545
  52646,  -22.6422672,   38.7578964,    4.5454545
  52647,  -21.7615108,   38.7578964,    4.5454545
  52648,  -20.8807564,   38.7578964,    4.5454545
  52649,  -29.0413227,   39.5531082,    4.5454545
  52650,  -28.0826454,   39.5531082,    4.5454545
  52651,  -27.1239681,   39.5531082,    4.5454545
  52652,  -26.1652889,   39.5531082,    4.5454545
  52653,  -25.2845345,   39.5531082,    4.5454545
  52654,  -24.4037781,   39.5531082,    4.5454545
  52655,  -23.5230236,   39.5531082,    4.5454545
  52656,  -22.6422672,   39.5531082,    4.5454545
  52657,  -21.7615108,   39.5531082,    4.5454545
  52658,  -20.8807564,   39.5531082,    4.5454545
  52659,  -29.0413227,   40.3483238,    4.5454545
  52660,  -28.0826454,   40.3483238,    4.5454545
  52661,  -27.1239681,   40.3483238,    4.5454545
  52662,  -26.1652889,   40.3483238,    4.5454545
  52663,  -25.2845345,   40.3483238,    4.5454545
  52664,  -24.4037781,   40.3483238,    4.5454545
  52665,  -23.5230236,   40.3483238,    4.5454545
  52666,  -22.6422672,   40.3483238,    4.5454545
  52667,  -21.7615108,   40.3483238,    4.5454545
  52668,  -20.8807564,   40.3483238,    4.5454545
  52669,  -29.0413227,   41.1435394,    4.5454545
  52670,  -28.0826454,   41.1435394,    4.5454545
  52671,  -27.1239681,   41.1435394,    4.5454545
  52672,  -26.1652889,   41.1435394,    4.5454545
  52673,  -25.2845345,   41.1435394,    4.5454545
  52674,  -24.4037781,   41.1435394,    4.5454545
  52675,  -23.5230236,   41.1435394,    4.5454545
  52676,  -22.6422672,   41.1435394,    4.5454545
  52677,  -21.7615108,   41.1435394,    4.5454545
  52678,  -20.8807564,   41.1435394,    4.5454545
  52679,  -29.0413227,    41.938755,    4.5454545
  52680,  -28.0826454,    41.938755,    4.5454545
  52681,  -27.1239681,    41.938755,    4.5454545
  52682,  -26.1652889,    41.938755,    4.5454545
  52683,  -25.2845345,    41.938755,    4.5454545
  52684,  -24.4037781,    41.938755,    4.5454545
  52685,  -23.5230236,    41.938755,    4.5454545
  52686,  -22.6422672,    41.938755,    4.5454545
  52687,  -21.7615108,    41.938755,    4.5454545
  52688,  -20.8807564,    41.938755,    4.5454545
  52689,  -29.0413227,   42.7339706,    4.5454545
  52690,  -28.0826454,   42.7339706,    4.5454545
  52691,  -27.1239681,   42.7339706,    4.5454545
  52692,  -26.1652889,   42.7339706,    4.5454545
  52693,  -25.2845345,   42.7339706,    4.5454545
  52694,  -24.4037781,   42.7339706,    4.5454545
  52695,  -23.5230236,   42.7339706,    4.5454545
  52696,  -22.6422672,   42.7339706,    4.5454545
  52697,  -21.7615108,   42.7339706,    4.5454545
  52698,  -20.8807564,   42.7339706,    4.5454545
  52699,  -29.0413227,   43.5291862,    4.5454545
  52700,  -28.0826454,   43.5291862,    4.5454545
  52701,  -27.1239681,   43.5291862,    4.5454545
  52702,  -26.1652889,   43.5291862,    4.5454545
  52703,  -25.2845345,   43.5291862,    4.5454545
  52704,  -24.4037781,   43.5291862,    4.5454545
  52705,  -23.5230236,   43.5291862,    4.5454545
  52706,  -22.6422672,   43.5291862,    4.5454545
  52707,  -21.7615108,   43.5291862,    4.5454545
  52708,  -20.8807564,   43.5291862,    4.5454545
  52709,  -29.0413227,   44.3244019,    4.5454545
  52710,  -28.0826454,   44.3244019,    4.5454545
  52711,  -27.1239681,   44.3244019,    4.5454545
  52712,  -26.1652889,   44.3244019,    4.5454545
  52713,  -25.2845345,   44.3244019,    4.5454545
  52714,  -24.4037781,   44.3244019,    4.5454545
  52715,  -23.5230236,   44.3244019,    4.5454545
  52716,  -22.6422672,   44.3244019,    4.5454545
  52717,  -21.7615108,   44.3244019,    4.5454545
  52718,  -20.8807564,   44.3244019,    4.5454545
  52719,  -29.0413227,   45.1196175,    4.5454545
  52720,  -28.0826454,   45.1196175,    4.5454545
  52721,  -27.1239681,   45.1196175,    4.5454545
  52722,  -26.1652889,   45.1196175,    4.5454545
  52723,  -25.2845345,   45.1196175,    4.5454545
  52724,  -24.4037781,   45.1196175,    4.5454545
  52725,  -23.5230236,   45.1196175,    4.5454545
  52726,  -22.6422672,   45.1196175,    4.5454545
  52727,  -21.7615108,   45.1196175,    4.5454545
  52728,  -20.8807564,   45.1196175,    4.5454545
  52729,  -29.0495872,   45.9330139,    4.5454545
  52730,  -28.0991745,   45.9330139,    4.5454545
  52731,  -27.1487598,   45.9330139,    4.5454545
  52732,  -26.1983471,   45.9330139,    4.5454545
  52733,    -25.31287,   45.9330139,    4.5454545
  52734,  -24.4273911,   45.9330139,    4.5454545
  52735,  -23.5419121,   45.9330139,    4.5454545
  52736,   -22.656435,   45.9330139,    4.5454545
  52737,   -21.770956,   45.9330139,    4.5454545
  52738,  -20.8854771,   45.9330139,    4.5454545
  52739,  -29.0578518,   46.7464104,    4.5454545
  52740,  -28.1157017,   46.7464104,    4.5454545
  52741,  -27.1735554,   46.7464104,    4.5454545
  52742,  -26.2314053,   46.7464104,    4.5454545
  52743,  -25.3412056,   46.7464104,    4.5454545
  52744,  -24.4510021,   46.7464104,    4.5454545
  52745,  -23.5608025,   46.7464104,    4.5454545
  52746,  -22.6706028,   46.7464104,    4.5454545
  52747,  -21.7804012,   46.7464104,    4.5454545
  52748,  -20.8901997,   46.7464104,    4.5454545
  52749,  -29.0661163,   47.5598068,    4.5454545
  52750,  -28.1322327,   47.5598068,    4.5454545
  52751,  -27.1983471,   47.5598068,    4.5454545
  52752,  -26.2644634,   47.5598068,    4.5454545
  52753,  -25.3695412,   47.5598068,    4.5454545
  52754,   -24.474617,   47.5598068,    4.5454545
  52755,  -23.5796928,   47.5598068,    4.5454545
  52756,  -22.6847706,   47.5598068,    4.5454545
  52757,  -21.7898464,   47.5598068,    4.5454545
  52758,  -20.8949242,   47.5598068,    4.5454545
  52759,  -29.0743809,   48.3732071,    4.5454545
  52760,  -28.1487598,   48.3732071,    4.5454545
  52761,  -27.2231407,   48.3732071,    4.5454545
  52762,  -26.2975197,   48.3732071,    4.5454545
  52763,  -25.3978748,   48.3732071,    4.5454545
  52764,  -24.4982281,   48.3732071,    4.5454545
  52765,  -23.5985832,   48.3732071,    4.5454545
  52766,  -22.6989384,   48.3732071,    4.5454545
  52767,  -21.7992916,   48.3732071,    4.5454545
  52768,  -20.8996449,   48.3732071,    4.5454545
  52769,  -29.0826454,   49.1866035,    4.5454545
  52770,  -28.1652889,   49.1866035,    4.5454545
  52771,  -27.2479343,   49.1866035,    4.5454545
  52772,  -26.3305779,   49.1866035,    4.5454545
  52773,  -25.4262104,   49.1866035,    4.5454545
  52774,   -24.521841,   49.1866035,    4.5454545
  52775,  -23.6174736,   49.1866035,    4.5454545
  52776,  -22.7131042,   49.1866035,    4.5454545
  52777,  -21.8087368,   49.1866035,    4.5454545
  52778,  -20.9043674,   49.1866035,    4.5454545
  52779,  -29.0850067,   20.7552967,    5.4545455
  52780,  -28.1700115,   20.7552967,    5.4545455
  52781,  -27.2550182,   20.7552967,    5.4545455
  52782,   -26.340023,   20.7552967,    5.4545455
  52783,  -25.4343071,   20.7552967,    5.4545455
  52784,  -24.5285873,   20.7552967,    5.4545455
  52785,  -23.6228714,   20.7552967,    5.4545455
  52786,  -22.7171535,   20.7552967,    5.4545455
  52787,  -21.8114357,   20.7552967,    5.4545455
  52788,  -20.9057178,   20.7552967,    5.4545455
  52789,  -29.0791035,   21.5105953,    5.4545455
  52790,   -28.158205,   21.5105953,    5.4545455
  52791,  -27.2373085,   21.5105953,    5.4545455
  52792,  -26.3164101,   21.5105953,    5.4545455
  52793,  -25.4140663,   21.5105953,    5.4545455
  52794,  -24.5117226,   21.5105953,    5.4545455
  52795,  -23.6093769,   21.5105953,    5.4545455
  52796,  -22.7070332,   21.5105953,    5.4545455
  52797,  -21.8046894,   21.5105953,    5.4545455
  52798,  -20.9023438,   21.5105953,    5.4545455
  52799,  -29.0732002,    22.265892,    5.4545455
  52800,  -28.1463985,    22.265892,    5.4545455
  52801,  -27.2195988,    22.265892,    5.4545455
  52802,  -26.2927971,    22.265892,    5.4545455
  52803,  -25.3938274,    22.265892,    5.4545455
  52804,  -24.4948559,    22.265892,    5.4545455
  52805,  -23.5958843,    22.265892,    5.4545455
  52806,  -22.6969128,    22.265892,    5.4545455
  52807,  -21.7979431,    22.265892,    5.4545455
  52808,  -20.8989716,    22.265892,    5.4545455
  52809,   -29.067297,   23.0211887,    5.4545455
  52810,  -28.1345921,   23.0211887,    5.4545455
  52811,   -27.201889,   23.0211887,    5.4545455
  52812,  -26.2691841,   23.0211887,    5.4545455
  52813,  -25.3735886,   23.0211887,    5.4545455
  52814,  -24.4779892,   23.0211887,    5.4545455
  52815,  -23.5823917,   23.0211887,    5.4545455
  52816,  -22.6867943,   23.0211887,    5.4545455
  52817,  -21.7911949,   23.0211887,    5.4545455
  52818,  -20.8955975,   23.0211887,    5.4545455
  52819,  -29.0613937,   23.7764874,    5.4545455
  52820,  -28.1227856,   23.7764874,    5.4545455
  52821,  -27.1841793,   23.7764874,    5.4545455
  52822,  -26.2455711,   23.7764874,    5.4545455
  52823,  -25.3533478,   23.7764874,    5.4545455
  52824,  -24.4611225,   23.7764874,    5.4545455
  52825,  -23.5688992,   23.7764874,    5.4545455
  52826,  -22.6766739,   23.7764874,    5.4545455
  52827,  -21.7844505,   23.7764874,    5.4545455
  52828,  -20.8922234,   23.7764874,    5.4545455
  52829,  -29.0554905,   24.5317841,    5.4545455
  52830,  -28.1109791,   24.5317841,    5.4545455
  52831,  -27.1664696,   24.5317841,    5.4545455
  52832,  -26.2219601,   24.5317841,    5.4545455
  52833,  -25.3331089,   24.5317841,    5.4545455
  52834,  -24.4442577,   24.5317841,    5.4545455
  52835,  -23.5554066,   24.5317841,    5.4545455
  52836,  -22.6665535,   24.5317841,    5.4545455
  52837,  -21.7777023,   24.5317841,    5.4545455
  52838,  -20.8888512,   24.5317841,    5.4545455
  52839,  -29.0495872,   25.2870808,    5.4545455
  52840,  -28.0991726,   25.2870808,    5.4545455
  52841,  -27.1487598,   25.2870808,    5.4545455
  52842,  -26.1983471,   25.2870808,    5.4545455
  52843,  -25.3128681,   25.2870808,    5.4545455
  52844,  -24.4273911,   25.2870808,    5.4545455
  52845,  -23.5419121,   25.2870808,    5.4545455
  52846,  -22.6564331,   25.2870808,    5.4545455
  52847,   -21.770956,   25.2870808,    5.4545455
  52848,  -20.8854771,   25.2870808,    5.4545455
  52849,  -29.0495872,   26.0813389,    5.4545455
  52850,  -28.0991726,   26.0813389,    5.4545455
  52851,  -27.1487598,   26.0813389,    5.4545455
  52852,  -26.1983471,   26.0813389,    5.4545455
  52853,  -25.3128681,   26.0813389,    5.4545455
  52854,  -24.4273911,   26.0813389,    5.4545455
  52855,  -23.5419121,   26.0813389,    5.4545455
  52856,  -22.6564331,   26.0813389,    5.4545455
  52857,   -21.770956,   26.0813389,    5.4545455
  52858,  -20.8854771,   26.0813389,    5.4545455
  52859,  -29.0495872,   26.8755989,    5.4545455
  52860,  -28.0991726,   26.8755989,    5.4545455
  52861,  -27.1487598,   26.8755989,    5.4545455
  52862,  -26.1983471,   26.8755989,    5.4545455
  52863,  -25.3128681,   26.8755989,    5.4545455
  52864,  -24.4273911,   26.8755989,    5.4545455
  52865,  -23.5419121,   26.8755989,    5.4545455
  52866,  -22.6564331,   26.8755989,    5.4545455
  52867,   -21.770956,   26.8755989,    5.4545455
  52868,  -20.8854771,   26.8755989,    5.4545455
  52869,  -29.0495872,    27.669857,    5.4545455
  52870,  -28.0991726,    27.669857,    5.4545455
  52871,  -27.1487598,    27.669857,    5.4545455
  52872,  -26.1983471,    27.669857,    5.4545455
  52873,  -25.3128681,    27.669857,    5.4545455
  52874,  -24.4273911,    27.669857,    5.4545455
  52875,  -23.5419121,    27.669857,    5.4545455
  52876,  -22.6564331,    27.669857,    5.4545455
  52877,   -21.770956,    27.669857,    5.4545455
  52878,  -20.8854771,    27.669857,    5.4545455
  52879,  -29.0495872,   28.4641151,    5.4545455
  52880,  -28.0991726,   28.4641151,    5.4545455
  52881,  -27.1487598,   28.4641151,    5.4545455
  52882,  -26.1983471,   28.4641151,    5.4545455
  52883,  -25.3128681,   28.4641151,    5.4545455
  52884,  -24.4273911,   28.4641151,    5.4545455
  52885,  -23.5419121,   28.4641151,    5.4545455
  52886,  -22.6564331,   28.4641151,    5.4545455
  52887,   -21.770956,   28.4641151,    5.4545455
  52888,  -20.8854771,   28.4641151,    5.4545455
  52889,  -29.0495872,   29.2583733,    5.4545455
  52890,  -28.0991726,   29.2583733,    5.4545455
  52891,  -27.1487598,   29.2583733,    5.4545455
  52892,  -26.1983471,   29.2583733,    5.4545455
  52893,  -25.3128681,   29.2583733,    5.4545455
  52894,  -24.4273911,   29.2583733,    5.4545455
  52895,  -23.5419121,   29.2583733,    5.4545455
  52896,  -22.6564331,   29.2583733,    5.4545455
  52897,   -21.770956,   29.2583733,    5.4545455
  52898,  -20.8854771,   29.2583733,    5.4545455
  52899,  -29.0495872,   30.0526314,    5.4545455
  52900,  -28.0991726,   30.0526314,    5.4545455
  52901,  -27.1487598,   30.0526314,    5.4545455
  52902,  -26.1983471,   30.0526314,    5.4545455
  52903,  -25.3128681,   30.0526314,    5.4545455
  52904,  -24.4273911,   30.0526314,    5.4545455
  52905,  -23.5419121,   30.0526314,    5.4545455
  52906,  -22.6564331,   30.0526314,    5.4545455
  52907,   -21.770956,   30.0526314,    5.4545455
  52908,  -20.8854771,   30.0526314,    5.4545455
  52909,  -29.0495872,   30.8468895,    5.4545455
  52910,  -28.0991726,   30.8468895,    5.4545455
  52911,  -27.1487598,   30.8468895,    5.4545455
  52912,  -26.1983471,   30.8468895,    5.4545455
  52913,  -25.3128681,   30.8468895,    5.4545455
  52914,  -24.4273911,   30.8468895,    5.4545455
  52915,  -23.5419121,   30.8468895,    5.4545455
  52916,  -22.6564331,   30.8468895,    5.4545455
  52917,   -21.770956,   30.8468895,    5.4545455
  52918,  -20.8854771,   30.8468895,    5.4545455
  52919,  -29.0495872,   31.6411476,    5.4545455
  52920,  -28.0991726,   31.6411476,    5.4545455
  52921,  -27.1487598,   31.6411476,    5.4545455
  52922,  -26.1983471,   31.6411476,    5.4545455
  52923,  -25.3128681,   31.6411476,    5.4545455
  52924,  -24.4273911,   31.6411476,    5.4545455
  52925,  -23.5419121,   31.6411476,    5.4545455
  52926,  -22.6564331,   31.6411476,    5.4545455
  52927,   -21.770956,   31.6411476,    5.4545455
  52928,  -20.8854771,   31.6411476,    5.4545455
  52929,  -29.0495872,   32.4354057,    5.4545455
  52930,  -28.0991726,   32.4354057,    5.4545455
  52931,  -27.1487598,   32.4354057,    5.4545455
  52932,  -26.1983471,   32.4354057,    5.4545455
  52933,  -25.3128681,   32.4354057,    5.4545455
  52934,  -24.4273911,   32.4354057,    5.4545455
  52935,  -23.5419121,   32.4354057,    5.4545455
  52936,  -22.6564331,   32.4354057,    5.4545455
  52937,   -21.770956,   32.4354057,    5.4545455
  52938,  -20.8854771,   32.4354057,    5.4545455
  52939,  -29.0495872,   33.2296638,    5.4545455
  52940,  -28.0991726,   33.2296638,    5.4545455
  52941,  -27.1487598,   33.2296638,    5.4545455
  52942,  -26.1983471,   33.2296638,    5.4545455
  52943,  -25.3128681,   33.2296638,    5.4545455
  52944,  -24.4273911,   33.2296638,    5.4545455
  52945,  -23.5419121,   33.2296638,    5.4545455
  52946,  -22.6564331,   33.2296638,    5.4545455
  52947,   -21.770956,   33.2296638,    5.4545455
  52948,  -20.8854771,   33.2296638,    5.4545455
  52949,  -29.0495872,    34.023922,    5.4545455
  52950,  -28.0991726,    34.023922,    5.4545455
  52951,  -27.1487598,    34.023922,    5.4545455
  52952,  -26.1983471,    34.023922,    5.4545455
  52953,  -25.3128681,    34.023922,    5.4545455
  52954,  -24.4273911,    34.023922,    5.4545455
  52955,  -23.5419121,    34.023922,    5.4545455
  52956,  -22.6564331,    34.023922,    5.4545455
  52957,   -21.770956,    34.023922,    5.4545455
  52958,  -20.8854771,    34.023922,    5.4545455
  52959,  -29.0495872,   34.8181801,    5.4545455
  52960,  -28.0991726,   34.8181801,    5.4545455
  52961,  -27.1487598,   34.8181801,    5.4545455
  52962,  -26.1983471,   34.8181801,    5.4545455
  52963,  -25.3128681,   34.8181801,    5.4545455
  52964,  -24.4273911,   34.8181801,    5.4545455
  52965,  -23.5419121,   34.8181801,    5.4545455
  52966,  -22.6564331,   34.8181801,    5.4545455
  52967,   -21.770956,   34.8181801,    5.4545455
  52968,  -20.8854771,   34.8181801,    5.4545455
  52969,  -29.0495872,    35.612442,    5.4545455
  52970,  -28.0991726,    35.612442,    5.4545455
  52971,  -27.1487598,    35.612442,    5.4545455
  52972,  -26.1983471,    35.612442,    5.4545455
  52973,  -25.3128681,    35.612442,    5.4545455
  52974,  -24.4273911,    35.612442,    5.4545455
  52975,  -23.5419121,    35.612442,    5.4545455
  52976,  -22.6564331,    35.612442,    5.4545455
  52977,   -21.770956,    35.612442,    5.4545455
  52978,  -20.8854771,    35.612442,    5.4545455
  52979,  -29.0495872,   36.4067001,    5.4545455
  52980,  -28.0991726,   36.4067001,    5.4545455
  52981,  -27.1487598,   36.4067001,    5.4545455
  52982,  -26.1983471,   36.4067001,    5.4545455
  52983,  -25.3128681,   36.4067001,    5.4545455
  52984,  -24.4273911,   36.4067001,    5.4545455
  52985,  -23.5419121,   36.4067001,    5.4545455
  52986,  -22.6564331,   36.4067001,    5.4545455
  52987,   -21.770956,   36.4067001,    5.4545455
  52988,  -20.8854771,   36.4067001,    5.4545455
  52989,  -29.0495872,   37.2009583,    5.4545455
  52990,  -28.0991726,   37.2009583,    5.4545455
  52991,  -27.1487598,   37.2009583,    5.4545455
  52992,  -26.1983471,   37.2009583,    5.4545455
  52993,  -25.3128681,   37.2009583,    5.4545455
  52994,  -24.4273911,   37.2009583,    5.4545455
  52995,  -23.5419121,   37.2009583,    5.4545455
  52996,  -22.6564331,   37.2009583,    5.4545455
  52997,   -21.770956,   37.2009583,    5.4545455
  52998,  -20.8854771,   37.2009583,    5.4545455
  52999,  -29.0495872,   37.9952164,    5.4545455
  53000,  -28.0991726,   37.9952164,    5.4545455
  53001,  -27.1487598,   37.9952164,    5.4545455
  53002,  -26.1983471,   37.9952164,    5.4545455
  53003,  -25.3128681,   37.9952164,    5.4545455
  53004,  -24.4273911,   37.9952164,    5.4545455
  53005,  -23.5419121,   37.9952164,    5.4545455
  53006,  -22.6564331,   37.9952164,    5.4545455
  53007,   -21.770956,   37.9952164,    5.4545455
  53008,  -20.8854771,   37.9952164,    5.4545455
  53009,  -29.0495872,   38.7894745,    5.4545455
  53010,  -28.0991726,   38.7894745,    5.4545455
  53011,  -27.1487598,   38.7894745,    5.4545455
  53012,  -26.1983471,   38.7894745,    5.4545455
  53013,  -25.3128681,   38.7894745,    5.4545455
  53014,  -24.4273911,   38.7894745,    5.4545455
  53015,  -23.5419121,   38.7894745,    5.4545455
  53016,  -22.6564331,   38.7894745,    5.4545455
  53017,   -21.770956,   38.7894745,    5.4545455
  53018,  -20.8854771,   38.7894745,    5.4545455
  53019,  -29.0495872,   39.5837326,    5.4545455
  53020,  -28.0991726,   39.5837326,    5.4545455
  53021,  -27.1487598,   39.5837326,    5.4545455
  53022,  -26.1983471,   39.5837326,    5.4545455
  53023,  -25.3128681,   39.5837326,    5.4545455
  53024,  -24.4273911,   39.5837326,    5.4545455
  53025,  -23.5419121,   39.5837326,    5.4545455
  53026,  -22.6564331,   39.5837326,    5.4545455
  53027,   -21.770956,   39.5837326,    5.4545455
  53028,  -20.8854771,   39.5837326,    5.4545455
  53029,  -29.0495872,   40.3779907,    5.4545455
  53030,  -28.0991726,   40.3779907,    5.4545455
  53031,  -27.1487598,   40.3779907,    5.4545455
  53032,  -26.1983471,   40.3779907,    5.4545455
  53033,  -25.3128681,   40.3779907,    5.4545455
  53034,  -24.4273911,   40.3779907,    5.4545455
  53035,  -23.5419121,   40.3779907,    5.4545455
  53036,  -22.6564331,   40.3779907,    5.4545455
  53037,   -21.770956,   40.3779907,    5.4545455
  53038,  -20.8854771,   40.3779907,    5.4545455
  53039,  -29.0495872,   41.1722488,    5.4545455
  53040,  -28.0991726,   41.1722488,    5.4545455
  53041,  -27.1487598,   41.1722488,    5.4545455
  53042,  -26.1983471,   41.1722488,    5.4545455
  53043,  -25.3128681,   41.1722488,    5.4545455
  53044,  -24.4273911,   41.1722488,    5.4545455
  53045,  -23.5419121,   41.1722488,    5.4545455
  53046,  -22.6564331,   41.1722488,    5.4545455
  53047,   -21.770956,   41.1722488,    5.4545455
  53048,  -20.8854771,   41.1722488,    5.4545455
  53049,  -29.0495872,    41.966507,    5.4545455
  53050,  -28.0991726,    41.966507,    5.4545455
  53051,  -27.1487598,    41.966507,    5.4545455
  53052,  -26.1983471,    41.966507,    5.4545455
  53053,  -25.3128681,    41.966507,    5.4545455
  53054,  -24.4273911,    41.966507,    5.4545455
  53055,  -23.5419121,    41.966507,    5.4545455
  53056,  -22.6564331,    41.966507,    5.4545455
  53057,   -21.770956,    41.966507,    5.4545455
  53058,  -20.8854771,    41.966507,    5.4545455
  53059,  -29.0495872,   42.7607651,    5.4545455
  53060,  -28.0991726,   42.7607651,    5.4545455
  53061,  -27.1487598,   42.7607651,    5.4545455
  53062,  -26.1983471,   42.7607651,    5.4545455
  53063,  -25.3128681,   42.7607651,    5.4545455
  53064,  -24.4273911,   42.7607651,    5.4545455
  53065,  -23.5419121,   42.7607651,    5.4545455
  53066,  -22.6564331,   42.7607651,    5.4545455
  53067,   -21.770956,   42.7607651,    5.4545455
  53068,  -20.8854771,   42.7607651,    5.4545455
  53069,  -29.0495872,   43.5550232,    5.4545455
  53070,  -28.0991726,   43.5550232,    5.4545455
  53071,  -27.1487598,   43.5550232,    5.4545455
  53072,  -26.1983471,   43.5550232,    5.4545455
  53073,  -25.3128681,   43.5550232,    5.4545455
  53074,  -24.4273911,   43.5550232,    5.4545455
  53075,  -23.5419121,   43.5550232,    5.4545455
  53076,  -22.6564331,   43.5550232,    5.4545455
  53077,   -21.770956,   43.5550232,    5.4545455
  53078,  -20.8854771,   43.5550232,    5.4545455
  53079,  -29.0495872,   44.3492813,    5.4545455
  53080,  -28.0991726,   44.3492813,    5.4545455
  53081,  -27.1487598,   44.3492813,    5.4545455
  53082,  -26.1983471,   44.3492813,    5.4545455
  53083,  -25.3128681,   44.3492813,    5.4545455
  53084,  -24.4273911,   44.3492813,    5.4545455
  53085,  -23.5419121,   44.3492813,    5.4545455
  53086,  -22.6564331,   44.3492813,    5.4545455
  53087,   -21.770956,   44.3492813,    5.4545455
  53088,  -20.8854771,   44.3492813,    5.4545455
  53089,  -29.0495872,   45.1435394,    5.4545455
  53090,  -28.0991726,   45.1435394,    5.4545455
  53091,  -27.1487598,   45.1435394,    5.4545455
  53092,  -26.1983471,   45.1435394,    5.4545455
  53093,  -25.3128681,   45.1435394,    5.4545455
  53094,  -24.4273911,   45.1435394,    5.4545455
  53095,  -23.5419121,   45.1435394,    5.4545455
  53096,  -22.6564331,   45.1435394,    5.4545455
  53097,   -21.770956,   45.1435394,    5.4545455
  53098,  -20.8854771,   45.1435394,    5.4545455
  53099,  -29.0564747,   45.9529495,    5.4545455
  53100,  -28.1129475,   45.9529495,    5.4545455
  53101,  -27.1694221,   45.9529495,    5.4545455
  53102,  -26.2258949,   45.9529495,    5.4545455
  53103,  -25.3364811,   45.9529495,    5.4545455
  53104,  -24.4470673,   45.9529495,    5.4545455
  53105,  -23.5576553,   45.9529495,    5.4545455
  53106,  -22.6682396,   45.9529495,    5.4545455
  53107,  -21.7788277,   45.9529495,    5.4545455
  53108,  -20.8894138,   45.9529495,    5.4545455
  53109,  -29.0633621,   46.7623596,    5.4545455
  53110,  -28.1267223,   46.7623596,    5.4545455
  53111,  -27.1900826,   46.7623596,    5.4545455
  53112,  -26.2534428,   46.7623596,    5.4545455
  53113,  -25.3600941,   46.7623596,    5.4545455
  53114,  -24.4667454,   46.7623596,    5.4545455
  53115,  -23.5733967,   46.7623596,    5.4545455
  53116,  -22.6800461,   46.7623596,    5.4545455
  53117,  -21.7866993,   46.7623596,    5.4545455
  53118,  -20.8933487,   46.7623596,    5.4545455
  53119,  -29.0702477,   47.5717697,    5.4545455
  53120,  -28.1404953,   47.5717697,    5.4545455
  53121,  -27.2107449,   47.5717697,    5.4545455
  53122,  -26.2809906,   47.5717697,    5.4545455
  53123,   -25.383707,   47.5717697,    5.4545455
  53124,  -24.4864216,   47.5717697,    5.4545455
  53125,   -23.589138,   47.5717697,    5.4545455
  53126,  -22.6918526,   47.5717697,    5.4545455
  53127,   -21.794569,   47.5717697,    5.4545455
  53128,  -20.8972836,   47.5717697,    5.4545455
  53129,  -29.0771351,   48.3811798,    5.4545455
  53130,  -28.1542702,   48.3811798,    5.4545455
  53131,  -27.2314053,   48.3811798,    5.4545455
  53132,  -26.3085403,   48.3811798,    5.4545455
  53133,    -25.40732,   48.3811798,    5.4545455
  53134,  -24.5060997,   48.3811798,    5.4545455
  53135,  -23.6048794,   48.3811798,    5.4545455
  53136,  -22.7036591,   48.3811798,    5.4545455
  53137,  -21.8024406,   48.3811798,    5.4545455
  53138,  -20.9012203,   48.3811798,    5.4545455
  53139,  -29.0840225,   49.1905899,    5.4545455
  53140,   -28.168045,   49.1905899,    5.4545455
  53141,  -27.2520657,   49.1905899,    5.4545455
  53142,  -26.3360882,   49.1905899,    5.4545455
  53143,   -25.430933,   49.1905899,    5.4545455
  53144,  -24.5257778,   49.1905899,    5.4545455
  53145,  -23.6206226,   49.1905899,    5.4545455
  53146,  -22.7154655,   49.1905899,    5.4545455
  53147,  -21.8103104,   49.1905899,    5.4545455
  53148,  -20.9051552,   49.1905899,    5.4545455
  53149,  -29.0861874,   20.7621326,   6.36363649
  53150,  -28.1723728,   20.7621326,   6.36363649
  53151,  -27.2585602,   20.7621326,   6.36363649
  53152,  -26.3447456,   20.7621326,   6.36363649
  53153,  -25.4383545,   20.7621326,   6.36363649
  53154,  -24.5319614,   20.7621326,   6.36363649
  53155,  -23.6255703,   20.7621326,   6.36363649
  53156,  -22.7191772,   20.7621326,   6.36363649
  53157,  -21.8127842,   20.7621326,   6.36363649
  53158,  -20.9063911,   20.7621326,   6.36363649
  53159,  -29.0814648,   21.5242653,   6.36363649
  53160,  -28.1629276,   21.5242653,   6.36363649
  53161,  -27.2443924,   21.5242653,   6.36363649
  53162,  -26.3258553,   21.5242653,   6.36363649
  53163,   -25.422163,   21.5242653,   6.36363649
  53164,  -24.5184689,   21.5242653,   6.36363649
  53165,  -23.6147747,   21.5242653,   6.36363649
  53166,  -22.7110806,   21.5242653,   6.36363649
  53167,  -21.8073883,   21.5242653,   6.36363649
  53168,  -20.9036942,   21.5242653,   6.36363649
  53169,  -29.0767422,   22.2863979,   6.36363649
  53170,  -28.1534824,   22.2863979,   6.36363649
  53171,  -27.2302246,   22.2863979,   6.36363649
  53172,  -26.3069649,   22.2863979,   6.36363649
  53173,  -25.4059715,   22.2863979,   6.36363649
  53174,  -24.5049744,   22.2863979,   6.36363649
  53175,   -23.603981,   22.2863979,   6.36363649
  53176,  -22.7029858,   22.2863979,   6.36363649
  53177,  -21.8019905,   22.2863979,   6.36363649
  53178,  -20.9009953,   22.2863979,   6.36363649
  53179,  -29.0720196,   23.0485306,   6.36363649
  53180,  -28.1440372,   23.0485306,   6.36363649
  53181,  -27.2160568,   23.0485306,   6.36363649
  53182,  -26.2880745,   23.0485306,   6.36363649
  53183,    -25.38978,   23.0485306,   6.36363649
  53184,  -24.4914818,   23.0485306,   6.36363649
  53185,  -23.5931873,   23.0485306,   6.36363649
  53186,  -22.6948891,   23.0485306,   6.36363649
  53187,  -21.7965927,   23.0485306,   6.36363649
  53188,  -20.8982964,   23.0485306,   6.36363649
  53189,   -29.067297,   23.8106632,   6.36363649
  53190,  -28.1345921,   23.8106632,   6.36363649
  53191,   -27.201889,   23.8106632,   6.36363649
  53192,  -26.2691841,   23.8106632,   6.36363649
  53193,  -25.3735886,   23.8106632,   6.36363649
  53194,  -24.4779892,   23.8106632,   6.36363649
  53195,  -23.5823917,   23.8106632,   6.36363649
  53196,  -22.6867924,   23.8106632,   6.36363649
  53197,  -21.7911968,   23.8106632,   6.36363649
  53198,  -20.8955975,   23.8106632,   6.36363649
  53199,  -29.0625744,   24.5727959,   6.36363649
  53200,  -28.1251469,   24.5727959,   6.36363649
  53201,  -27.1877213,   24.5727959,   6.36363649
  53202,  -26.2502956,   24.5727959,   6.36363649
  53203,  -25.3573952,   24.5727959,   6.36363649
  53204,  -24.4644966,   24.5727959,   6.36363649
  53205,  -23.5715981,   24.5727959,   6.36363649
  53206,  -22.6786976,   24.5727959,   6.36363649
  53207,   -21.785799,   24.5727959,   6.36363649
  53208,  -20.8928986,   24.5727959,   6.36363649
  53209,  -29.0578518,   25.3349285,   6.36363649
  53210,  -28.1157017,   25.3349285,   6.36363649
  53211,  -27.1735535,   25.3349285,   6.36363649
  53212,  -26.2314053,   25.3349285,   6.36363649
  53213,  -25.3412037,   25.3349285,   6.36363649
  53214,   -24.451004,   25.3349285,   6.36363649
  53215,  -23.5608025,   25.3349285,   6.36363649
  53216,  -22.6706009,   25.3349285,   6.36363649
  53217,  -21.7804012,   25.3349285,   6.36363649
  53218,  -20.8901997,   25.3349285,   6.36363649
  53219,  -29.0578518,   26.1282291,   6.36363649
  53220,  -28.1157017,   26.1282291,   6.36363649
  53221,  -27.1735535,   26.1282291,   6.36363649
  53222,  -26.2314053,   26.1282291,   6.36363649
  53223,  -25.3412037,   26.1282291,   6.36363649
  53224,   -24.451004,   26.1282291,   6.36363649
  53225,  -23.5608025,   26.1282291,   6.36363649
  53226,  -22.6706009,   26.1282291,   6.36363649
  53227,  -21.7804012,   26.1282291,   6.36363649
  53228,  -20.8901997,   26.1282291,   6.36363649
  53229,  -29.0578518,   26.9215317,   6.36363649
  53230,  -28.1157017,   26.9215317,   6.36363649
  53231,  -27.1735535,   26.9215317,   6.36363649
  53232,  -26.2314053,   26.9215317,   6.36363649
  53233,  -25.3412037,   26.9215317,   6.36363649
  53234,   -24.451004,   26.9215317,   6.36363649
  53235,  -23.5608025,   26.9215317,   6.36363649
  53236,  -22.6706009,   26.9215317,   6.36363649
  53237,  -21.7804012,   26.9215317,   6.36363649
  53238,  -20.8901997,   26.9215317,   6.36363649
  53239,  -29.0578518,   27.7148323,   6.36363649
  53240,  -28.1157017,   27.7148323,   6.36363649
  53241,  -27.1735535,   27.7148323,   6.36363649
  53242,  -26.2314053,   27.7148323,   6.36363649
  53243,  -25.3412037,   27.7148323,   6.36363649
  53244,   -24.451004,   27.7148323,   6.36363649
  53245,  -23.5608025,   27.7148323,   6.36363649
  53246,  -22.6706009,   27.7148323,   6.36363649
  53247,  -21.7804012,   27.7148323,   6.36363649
  53248,  -20.8901997,   27.7148323,   6.36363649
  53249,  -29.0578518,   28.5081348,   6.36363649
  53250,  -28.1157017,   28.5081348,   6.36363649
  53251,  -27.1735535,   28.5081348,   6.36363649
  53252,  -26.2314053,   28.5081348,   6.36363649
  53253,  -25.3412037,   28.5081348,   6.36363649
  53254,   -24.451004,   28.5081348,   6.36363649
  53255,  -23.5608025,   28.5081348,   6.36363649
  53256,  -22.6706009,   28.5081348,   6.36363649
  53257,  -21.7804012,   28.5081348,   6.36363649
  53258,  -20.8901997,   28.5081348,   6.36363649
  53259,  -29.0578518,   29.3014355,   6.36363649
  53260,  -28.1157017,   29.3014355,   6.36363649
  53261,  -27.1735535,   29.3014355,   6.36363649
  53262,  -26.2314053,   29.3014355,   6.36363649
  53263,  -25.3412037,   29.3014355,   6.36363649
  53264,   -24.451004,   29.3014355,   6.36363649
  53265,  -23.5608025,   29.3014355,   6.36363649
  53266,  -22.6706009,   29.3014355,   6.36363649
  53267,  -21.7804012,   29.3014355,   6.36363649
  53268,  -20.8901997,   29.3014355,   6.36363649
  53269,  -29.0578518,   30.0947361,   6.36363649
  53270,  -28.1157017,   30.0947361,   6.36363649
  53271,  -27.1735535,   30.0947361,   6.36363649
  53272,  -26.2314053,   30.0947361,   6.36363649
  53273,  -25.3412037,   30.0947361,   6.36363649
  53274,   -24.451004,   30.0947361,   6.36363649
  53275,  -23.5608025,   30.0947361,   6.36363649
  53276,  -22.6706009,   30.0947361,   6.36363649
  53277,  -21.7804012,   30.0947361,   6.36363649
  53278,  -20.8901997,   30.0947361,   6.36363649
  53279,  -29.0578518,   30.8880386,   6.36363649
  53280,  -28.1157017,   30.8880386,   6.36363649
  53281,  -27.1735535,   30.8880386,   6.36363649
  53282,  -26.2314053,   30.8880386,   6.36363649
  53283,  -25.3412037,   30.8880386,   6.36363649
  53284,   -24.451004,   30.8880386,   6.36363649
  53285,  -23.5608025,   30.8880386,   6.36363649
  53286,  -22.6706009,   30.8880386,   6.36363649
  53287,  -21.7804012,   30.8880386,   6.36363649
  53288,  -20.8901997,   30.8880386,   6.36363649
  53289,  -29.0578518,   31.6813393,   6.36363649
  53290,  -28.1157017,   31.6813393,   6.36363649
  53291,  -27.1735535,   31.6813393,   6.36363649
  53292,  -26.2314053,   31.6813393,   6.36363649
  53293,  -25.3412037,   31.6813393,   6.36363649
  53294,   -24.451004,   31.6813393,   6.36363649
  53295,  -23.5608025,   31.6813393,   6.36363649
  53296,  -22.6706009,   31.6813393,   6.36363649
  53297,  -21.7804012,   31.6813393,   6.36363649
  53298,  -20.8901997,   31.6813393,   6.36363649
  53299,  -29.0578518,   32.4746399,   6.36363649
  53300,  -28.1157017,   32.4746399,   6.36363649
  53301,  -27.1735535,   32.4746399,   6.36363649
  53302,  -26.2314053,   32.4746399,   6.36363649
  53303,  -25.3412037,   32.4746399,   6.36363649
  53304,   -24.451004,   32.4746399,   6.36363649
  53305,  -23.5608025,   32.4746399,   6.36363649
  53306,  -22.6706009,   32.4746399,   6.36363649
  53307,  -21.7804012,   32.4746399,   6.36363649
  53308,  -20.8901997,   32.4746399,   6.36363649
  53309,  -29.0578518,   33.2679443,   6.36363649
  53310,  -28.1157017,   33.2679443,   6.36363649
  53311,  -27.1735535,   33.2679443,   6.36363649
  53312,  -26.2314053,   33.2679443,   6.36363649
  53313,  -25.3412037,   33.2679443,   6.36363649
  53314,   -24.451004,   33.2679443,   6.36363649
  53315,  -23.5608025,   33.2679443,   6.36363649
  53316,  -22.6706009,   33.2679443,   6.36363649
  53317,  -21.7804012,   33.2679443,   6.36363649
  53318,  -20.8901997,   33.2679443,   6.36363649
  53319,  -29.0578518,    34.061245,   6.36363649
  53320,  -28.1157017,    34.061245,   6.36363649
  53321,  -27.1735535,    34.061245,   6.36363649
  53322,  -26.2314053,    34.061245,   6.36363649
  53323,  -25.3412037,    34.061245,   6.36363649
  53324,   -24.451004,    34.061245,   6.36363649
  53325,  -23.5608025,    34.061245,   6.36363649
  53326,  -22.6706009,    34.061245,   6.36363649
  53327,  -21.7804012,    34.061245,   6.36363649
  53328,  -20.8901997,    34.061245,   6.36363649
  53329,  -29.0578518,   34.8545456,   6.36363649
  53330,  -28.1157017,   34.8545456,   6.36363649
  53331,  -27.1735535,   34.8545456,   6.36363649
  53332,  -26.2314053,   34.8545456,   6.36363649
  53333,  -25.3412037,   34.8545456,   6.36363649
  53334,   -24.451004,   34.8545456,   6.36363649
  53335,  -23.5608025,   34.8545456,   6.36363649
  53336,  -22.6706009,   34.8545456,   6.36363649
  53337,  -21.7804012,   34.8545456,   6.36363649
  53338,  -20.8901997,   34.8545456,   6.36363649
  53339,  -29.0578518,   35.6478462,   6.36363649
  53340,  -28.1157017,   35.6478462,   6.36363649
  53341,  -27.1735535,   35.6478462,   6.36363649
  53342,  -26.2314053,   35.6478462,   6.36363649
  53343,  -25.3412037,   35.6478462,   6.36363649
  53344,   -24.451004,   35.6478462,   6.36363649
  53345,  -23.5608025,   35.6478462,   6.36363649
  53346,  -22.6706009,   35.6478462,   6.36363649
  53347,  -21.7804012,   35.6478462,   6.36363649
  53348,  -20.8901997,   35.6478462,   6.36363649
  53349,  -29.0578518,   36.4411469,   6.36363649
  53350,  -28.1157017,   36.4411469,   6.36363649
  53351,  -27.1735535,   36.4411469,   6.36363649
  53352,  -26.2314053,   36.4411469,   6.36363649
  53353,  -25.3412037,   36.4411469,   6.36363649
  53354,   -24.451004,   36.4411469,   6.36363649
  53355,  -23.5608025,   36.4411469,   6.36363649
  53356,  -22.6706009,   36.4411469,   6.36363649
  53357,  -21.7804012,   36.4411469,   6.36363649
  53358,  -20.8901997,   36.4411469,   6.36363649
  53359,  -29.0578518,   37.2344513,   6.36363649
  53360,  -28.1157017,   37.2344513,   6.36363649
  53361,  -27.1735535,   37.2344513,   6.36363649
  53362,  -26.2314053,   37.2344513,   6.36363649
  53363,  -25.3412037,   37.2344513,   6.36363649
  53364,   -24.451004,   37.2344513,   6.36363649
  53365,  -23.5608025,   37.2344513,   6.36363649
  53366,  -22.6706009,   37.2344513,   6.36363649
  53367,  -21.7804012,   37.2344513,   6.36363649
  53368,  -20.8901997,   37.2344513,   6.36363649
  53369,  -29.0578518,   38.0277519,   6.36363649
  53370,  -28.1157017,   38.0277519,   6.36363649
  53371,  -27.1735535,   38.0277519,   6.36363649
  53372,  -26.2314053,   38.0277519,   6.36363649
  53373,  -25.3412037,   38.0277519,   6.36363649
  53374,   -24.451004,   38.0277519,   6.36363649
  53375,  -23.5608025,   38.0277519,   6.36363649
  53376,  -22.6706009,   38.0277519,   6.36363649
  53377,  -21.7804012,   38.0277519,   6.36363649
  53378,  -20.8901997,   38.0277519,   6.36363649
  53379,  -29.0578518,   38.8210526,   6.36363649
  53380,  -28.1157017,   38.8210526,   6.36363649
  53381,  -27.1735535,   38.8210526,   6.36363649
  53382,  -26.2314053,   38.8210526,   6.36363649
  53383,  -25.3412037,   38.8210526,   6.36363649
  53384,   -24.451004,   38.8210526,   6.36363649
  53385,  -23.5608025,   38.8210526,   6.36363649
  53386,  -22.6706009,   38.8210526,   6.36363649
  53387,  -21.7804012,   38.8210526,   6.36363649
  53388,  -20.8901997,   38.8210526,   6.36363649
  53389,  -29.0578518,   39.6143532,   6.36363649
  53390,  -28.1157017,   39.6143532,   6.36363649
  53391,  -27.1735535,   39.6143532,   6.36363649
  53392,  -26.2314053,   39.6143532,   6.36363649
  53393,  -25.3412037,   39.6143532,   6.36363649
  53394,   -24.451004,   39.6143532,   6.36363649
  53395,  -23.5608025,   39.6143532,   6.36363649
  53396,  -22.6706009,   39.6143532,   6.36363649
  53397,  -21.7804012,   39.6143532,   6.36363649
  53398,  -20.8901997,   39.6143532,   6.36363649
  53399,  -29.0578518,   40.4076538,   6.36363649
  53400,  -28.1157017,   40.4076538,   6.36363649
  53401,  -27.1735535,   40.4076538,   6.36363649
  53402,  -26.2314053,   40.4076538,   6.36363649
  53403,  -25.3412037,   40.4076538,   6.36363649
  53404,   -24.451004,   40.4076538,   6.36363649
  53405,  -23.5608025,   40.4076538,   6.36363649
  53406,  -22.6706009,   40.4076538,   6.36363649
  53407,  -21.7804012,   40.4076538,   6.36363649
  53408,  -20.8901997,   40.4076538,   6.36363649
  53409,  -29.0578518,   41.2009583,   6.36363649
  53410,  -28.1157017,   41.2009583,   6.36363649
  53411,  -27.1735535,   41.2009583,   6.36363649
  53412,  -26.2314053,   41.2009583,   6.36363649
  53413,  -25.3412037,   41.2009583,   6.36363649
  53414,   -24.451004,   41.2009583,   6.36363649
  53415,  -23.5608025,   41.2009583,   6.36363649
  53416,  -22.6706009,   41.2009583,   6.36363649
  53417,  -21.7804012,   41.2009583,   6.36363649
  53418,  -20.8901997,   41.2009583,   6.36363649
  53419,  -29.0578518,   41.9942589,   6.36363649
  53420,  -28.1157017,   41.9942589,   6.36363649
  53421,  -27.1735535,   41.9942589,   6.36363649
  53422,  -26.2314053,   41.9942589,   6.36363649
  53423,  -25.3412037,   41.9942589,   6.36363649
  53424,   -24.451004,   41.9942589,   6.36363649
  53425,  -23.5608025,   41.9942589,   6.36363649
  53426,  -22.6706009,   41.9942589,   6.36363649
  53427,  -21.7804012,   41.9942589,   6.36363649
  53428,  -20.8901997,   41.9942589,   6.36363649
  53429,  -29.0578518,   42.7875595,   6.36363649
  53430,  -28.1157017,   42.7875595,   6.36363649
  53431,  -27.1735535,   42.7875595,   6.36363649
  53432,  -26.2314053,   42.7875595,   6.36363649
  53433,  -25.3412037,   42.7875595,   6.36363649
  53434,   -24.451004,   42.7875595,   6.36363649
  53435,  -23.5608025,   42.7875595,   6.36363649
  53436,  -22.6706009,   42.7875595,   6.36363649
  53437,  -21.7804012,   42.7875595,   6.36363649
  53438,  -20.8901997,   42.7875595,   6.36363649
  53439,  -29.0578518,   43.5808601,   6.36363649
  53440,  -28.1157017,   43.5808601,   6.36363649
  53441,  -27.1735535,   43.5808601,   6.36363649
  53442,  -26.2314053,   43.5808601,   6.36363649
  53443,  -25.3412037,   43.5808601,   6.36363649
  53444,   -24.451004,   43.5808601,   6.36363649
  53445,  -23.5608025,   43.5808601,   6.36363649
  53446,  -22.6706009,   43.5808601,   6.36363649
  53447,  -21.7804012,   43.5808601,   6.36363649
  53448,  -20.8901997,   43.5808601,   6.36363649
  53449,  -29.0578518,   44.3741646,   6.36363649
  53450,  -28.1157017,   44.3741646,   6.36363649
  53451,  -27.1735535,   44.3741646,   6.36363649
  53452,  -26.2314053,   44.3741646,   6.36363649
  53453,  -25.3412037,   44.3741646,   6.36363649
  53454,   -24.451004,   44.3741646,   6.36363649
  53455,  -23.5608025,   44.3741646,   6.36363649
  53456,  -22.6706009,   44.3741646,   6.36363649
  53457,  -21.7804012,   44.3741646,   6.36363649
  53458,  -20.8901997,   44.3741646,   6.36363649
  53459,  -29.0578518,   45.1674652,   6.36363649
  53460,  -28.1157017,   45.1674652,   6.36363649
  53461,  -27.1735535,   45.1674652,   6.36363649
  53462,  -26.2314053,   45.1674652,   6.36363649
  53463,  -25.3412037,   45.1674652,   6.36363649
  53464,   -24.451004,   45.1674652,   6.36363649
  53465,  -23.5608025,   45.1674652,   6.36363649
  53466,  -22.6706009,   45.1674652,   6.36363649
  53467,  -21.7804012,   45.1674652,   6.36363649
  53468,  -20.8901997,   45.1674652,   6.36363649
  53469,  -29.0633621,   45.9728851,   6.36363649
  53470,  -28.1267223,   45.9728851,   6.36363649
  53471,  -27.1900826,   45.9728851,   6.36363649
  53472,  -26.2534428,   45.9728851,   6.36363649
  53473,  -25.3600941,   45.9728851,   6.36363649
  53474,  -24.4667454,   45.9728851,   6.36363649
  53475,  -23.5733967,   45.9728851,   6.36363649
  53476,  -22.6800461,   45.9728851,   6.36363649
  53477,  -21.7866974,   45.9728851,   6.36363649
  53478,  -20.8933487,   45.9728851,   6.36363649
  53479,  -29.0688705,   46.7783089,   6.36363649
  53480,  -28.1377411,   46.7783089,   6.36363649
  53481,  -27.2066116,   46.7783089,   6.36363649
  53482,  -26.2754822,   46.7783089,   6.36363649
  53483,  -25.3789845,   46.7783089,   6.36363649
  53484,  -24.4824867,   46.7783089,   6.36363649
  53485,   -23.585989,   46.7783089,   6.36363649
  53486,  -22.6894913,   46.7783089,   6.36363649
  53487,  -21.7929955,   46.7783089,   6.36363649
  53488,  -20.8964958,   46.7783089,   6.36363649
  53489,  -29.0743809,   47.5837326,   6.36363649
  53490,  -28.1487598,   47.5837326,   6.36363649
  53491,  -27.2231407,   47.5837326,   6.36363649
  53492,  -26.2975197,   47.5837326,   6.36363649
  53493,  -25.3978748,   47.5837326,   6.36363649
  53494,  -24.4982281,   47.5837326,   6.36363649
  53495,  -23.5985832,   47.5837326,   6.36363649
  53496,  -22.6989365,   47.5837326,   6.36363649
  53497,  -21.7992916,   47.5837326,   6.36363649
  53498,  -20.8996449,   47.5837326,   6.36363649
  53499,  -29.0798912,   48.3891563,   6.36363649
  53500,  -28.1597786,   48.3891563,   6.36363649
  53501,  -27.2396698,   48.3891563,   6.36363649
  53502,  -26.3195591,   48.3891563,   6.36363649
  53503,  -25.4167652,   48.3891563,   6.36363649
  53504,  -24.5139694,   48.3891563,   6.36363649
  53505,  -23.6111774,   48.3891563,   6.36363649
  53506,  -22.7083817,   48.3891563,   6.36363649
  53507,  -21.8055878,   48.3891563,   6.36363649
  53508,  -20.9027939,   48.3891563,   6.36363649
  53509,  -29.0853996,   49.1945763,   6.36363649
  53510,  -28.1707993,   49.1945763,   6.36363649
  53511,  -27.2561989,   49.1945763,   6.36363649
  53512,  -26.3415966,   49.1945763,   6.36363649
  53513,  -25.4356556,   49.1945763,   6.36363649
  53514,  -24.5297127,   49.1945763,   6.36363649
  53515,  -23.6237698,   49.1945763,   6.36363649
  53516,  -22.7178268,   49.1945763,   6.36363649
  53517,  -21.8118858,   49.1945763,   6.36363649
  53518,   -20.905941,   49.1945763,   6.36363649
  53519,   -29.087368,   20.7689686,   7.27272749
  53520,  -28.1747341,   20.7689686,   7.27272749
  53521,  -27.2621021,   20.7689686,   7.27272749
  53522,  -26.3494682,   20.7689686,   7.27272749
  53523,  -25.4424019,   20.7689686,   7.27272749
  53524,  -24.5353336,   20.7689686,   7.27272749
  53525,  -23.6282692,   20.7689686,   7.27272749
  53526,  -22.7212009,   20.7689686,   7.27272749
  53527,  -21.8141346,   20.7689686,   7.27272749
  53528,  -20.9070663,   20.7689686,   7.27272749
  53529,  -29.0838261,   21.5379353,   7.27272749
  53530,  -28.1676502,   21.5379353,   7.27272749
  53531,  -27.2514763,   21.5379353,   7.27272749
  53532,  -26.3353004,   21.5379353,   7.27272749
  53533,  -25.4302578,   21.5379353,   7.27272749
  53534,  -24.5252151,   21.5379353,   7.27272749
  53535,  -23.6201725,   21.5379353,   7.27272749
  53536,  -22.7151279,   21.5379353,   7.27272749
  53537,  -21.8100872,   21.5379353,   7.27272749
  53538,  -20.9050426,   21.5379353,   7.27272749
  53539,  -29.0802841,   22.3069038,   7.27272749
  53540,  -28.1605663,   22.3069038,   7.27272749
  53541,  -27.2408504,   22.3069038,   7.27272749
  53542,  -26.3211327,   22.3069038,   7.27272749
  53543,  -25.4181156,   22.3069038,   7.27272749
  53544,  -24.5150948,   22.3069038,   7.27272749
  53545,  -23.6120758,   22.3069038,   7.27272749
  53546,  -22.7090569,   22.3069038,   7.27272749
  53547,  -21.8060379,   22.3069038,   7.27272749
  53548,   -20.903019,   22.3069038,   7.27272749
  53549,  -29.0767422,   23.0758724,   7.27272749
  53550,  -28.1534824,   23.0758724,   7.27272749
  53551,  -27.2302246,   23.0758724,   7.27272749
  53552,  -26.3069649,   23.0758724,   7.27272749
  53553,  -25.4059715,   23.0758724,   7.27272749
  53554,  -24.5049744,   23.0758724,   7.27272749
  53555,   -23.603981,   23.0758724,   7.27272749
  53556,  -22.7029858,   23.0758724,   7.27272749
  53557,  -21.8019905,   23.0758724,   7.27272749
  53558,  -20.9009953,   23.0758724,   7.27272749
  53559,  -29.0732002,   23.8448391,   7.27272749
  53560,  -28.1463985,   23.8448391,   7.27272749
  53561,  -27.2195988,   23.8448391,   7.27272749
  53562,  -26.2927971,   23.8448391,   7.27272749
  53563,  -25.3938274,   23.8448391,   7.27272749
  53564,  -24.4948559,   23.8448391,   7.27272749
  53565,  -23.5958843,   23.8448391,   7.27272749
  53566,  -22.6969128,   23.8448391,   7.27272749
  53567,  -21.7979431,   23.8448391,   7.27272749
  53568,  -20.8989697,   23.8448391,   7.27272749
  53569,  -29.0696583,   24.6138077,   7.27272749
  53570,  -28.1393147,   24.6138077,   7.27272749
  53571,  -27.2089729,   24.6138077,   7.27272749
  53572,  -26.2786312,   24.6138077,   7.27272749
  53573,  -25.3816833,   24.6138077,   7.27272749
  53574,  -24.4847355,   24.6138077,   7.27272749
  53575,  -23.5877895,   24.6138077,   7.27272749
  53576,  -22.6908417,   24.6138077,   7.27272749
  53577,  -21.7938938,   24.6138077,   7.27272749
  53578,   -20.896946,   24.6138077,   7.27272749
  53579,  -29.0661163,   25.3827744,   7.27272749
  53580,  -28.1322308,   25.3827744,   7.27272749
  53581,  -27.1983471,   25.3827744,   7.27272749
  53582,  -26.2644634,   25.3827744,   7.27272749
  53583,  -25.3695393,   25.3827744,   7.27272749
  53584,   -24.474617,   25.3827744,   7.27272749
  53585,  -23.5796928,   25.3827744,   7.27272749
  53586,  -22.6847687,   25.3827744,   7.27272749
  53587,  -21.7898464,   25.3827744,   7.27272749
  53588,  -20.8949223,   25.3827744,   7.27272749
  53589,  -29.0661163,   26.1751194,   7.27272749
  53590,  -28.1322308,   26.1751194,   7.27272749
  53591,  -27.1983471,   26.1751194,   7.27272749
  53592,  -26.2644634,   26.1751194,   7.27272749
  53593,  -25.3695393,   26.1751194,   7.27272749
  53594,   -24.474617,   26.1751194,   7.27272749
  53595,  -23.5796928,   26.1751194,   7.27272749
  53596,  -22.6847687,   26.1751194,   7.27272749
  53597,  -21.7898464,   26.1751194,   7.27272749
  53598,  -20.8949223,   26.1751194,   7.27272749
  53599,  -29.0661163,   26.9674644,   7.27272749
  53600,  -28.1322308,   26.9674644,   7.27272749
  53601,  -27.1983471,   26.9674644,   7.27272749
  53602,  -26.2644634,   26.9674644,   7.27272749
  53603,  -25.3695393,   26.9674644,   7.27272749
  53604,   -24.474617,   26.9674644,   7.27272749
  53605,  -23.5796928,   26.9674644,   7.27272749
  53606,  -22.6847687,   26.9674644,   7.27272749
  53607,  -21.7898464,   26.9674644,   7.27272749
  53608,  -20.8949223,   26.9674644,   7.27272749
  53609,  -29.0661163,   27.7598095,   7.27272749
  53610,  -28.1322308,   27.7598095,   7.27272749
  53611,  -27.1983471,   27.7598095,   7.27272749
  53612,  -26.2644634,   27.7598095,   7.27272749
  53613,  -25.3695393,   27.7598095,   7.27272749
  53614,   -24.474617,   27.7598095,   7.27272749
  53615,  -23.5796928,   27.7598095,   7.27272749
  53616,  -22.6847687,   27.7598095,   7.27272749
  53617,  -21.7898464,   27.7598095,   7.27272749
  53618,  -20.8949223,   27.7598095,   7.27272749
  53619,  -29.0661163,   28.5521526,   7.27272749
  53620,  -28.1322308,   28.5521526,   7.27272749
  53621,  -27.1983471,   28.5521526,   7.27272749
  53622,  -26.2644634,   28.5521526,   7.27272749
  53623,  -25.3695393,   28.5521526,   7.27272749
  53624,   -24.474617,   28.5521526,   7.27272749
  53625,  -23.5796928,   28.5521526,   7.27272749
  53626,  -22.6847687,   28.5521526,   7.27272749
  53627,  -21.7898464,   28.5521526,   7.27272749
  53628,  -20.8949223,   28.5521526,   7.27272749
  53629,  -29.0661163,   29.3444977,   7.27272749
  53630,  -28.1322308,   29.3444977,   7.27272749
  53631,  -27.1983471,   29.3444977,   7.27272749
  53632,  -26.2644634,   29.3444977,   7.27272749
  53633,  -25.3695393,   29.3444977,   7.27272749
  53634,   -24.474617,   29.3444977,   7.27272749
  53635,  -23.5796928,   29.3444977,   7.27272749
  53636,  -22.6847687,   29.3444977,   7.27272749
  53637,  -21.7898464,   29.3444977,   7.27272749
  53638,  -20.8949223,   29.3444977,   7.27272749
  53639,  -29.0661163,   30.1368427,   7.27272749
  53640,  -28.1322308,   30.1368427,   7.27272749
  53641,  -27.1983471,   30.1368427,   7.27272749
  53642,  -26.2644634,   30.1368427,   7.27272749
  53643,  -25.3695393,   30.1368427,   7.27272749
  53644,   -24.474617,   30.1368427,   7.27272749
  53645,  -23.5796928,   30.1368427,   7.27272749
  53646,  -22.6847687,   30.1368427,   7.27272749
  53647,  -21.7898464,   30.1368427,   7.27272749
  53648,  -20.8949223,   30.1368427,   7.27272749
  53649,  -29.0661163,   30.9291859,   7.27272749
  53650,  -28.1322308,   30.9291859,   7.27272749
  53651,  -27.1983471,   30.9291859,   7.27272749
  53652,  -26.2644634,   30.9291859,   7.27272749
  53653,  -25.3695393,   30.9291859,   7.27272749
  53654,   -24.474617,   30.9291859,   7.27272749
  53655,  -23.5796928,   30.9291859,   7.27272749
  53656,  -22.6847687,   30.9291859,   7.27272749
  53657,  -21.7898464,   30.9291859,   7.27272749
  53658,  -20.8949223,   30.9291859,   7.27272749
  53659,  -29.0661163,   31.7215309,   7.27272749
  53660,  -28.1322308,   31.7215309,   7.27272749
  53661,  -27.1983471,   31.7215309,   7.27272749
  53662,  -26.2644634,   31.7215309,   7.27272749
  53663,  -25.3695393,   31.7215309,   7.27272749
  53664,   -24.474617,   31.7215309,   7.27272749
  53665,  -23.5796928,   31.7215309,   7.27272749
  53666,  -22.6847687,   31.7215309,   7.27272749
  53667,  -21.7898464,   31.7215309,   7.27272749
  53668,  -20.8949223,   31.7215309,   7.27272749
  53669,  -29.0661163,   32.5138741,   7.27272749
  53670,  -28.1322308,   32.5138741,   7.27272749
  53671,  -27.1983471,   32.5138741,   7.27272749
  53672,  -26.2644634,   32.5138741,   7.27272749
  53673,  -25.3695393,   32.5138741,   7.27272749
  53674,   -24.474617,   32.5138741,   7.27272749
  53675,  -23.5796928,   32.5138741,   7.27272749
  53676,  -22.6847687,   32.5138741,   7.27272749
  53677,  -21.7898464,   32.5138741,   7.27272749
  53678,  -20.8949223,   32.5138741,   7.27272749
  53679,  -29.0661163,    33.306221,   7.27272749
  53680,  -28.1322308,    33.306221,   7.27272749
  53681,  -27.1983471,    33.306221,   7.27272749
  53682,  -26.2644634,    33.306221,   7.27272749
  53683,  -25.3695393,    33.306221,   7.27272749
  53684,   -24.474617,    33.306221,   7.27272749
  53685,  -23.5796928,    33.306221,   7.27272749
  53686,  -22.6847687,    33.306221,   7.27272749
  53687,  -21.7898464,    33.306221,   7.27272749
  53688,  -20.8949223,    33.306221,   7.27272749
  53689,  -29.0661163,   34.0985641,   7.27272749
  53690,  -28.1322308,   34.0985641,   7.27272749
  53691,  -27.1983471,   34.0985641,   7.27272749
  53692,  -26.2644634,   34.0985641,   7.27272749
  53693,  -25.3695393,   34.0985641,   7.27272749
  53694,   -24.474617,   34.0985641,   7.27272749
  53695,  -23.5796928,   34.0985641,   7.27272749
  53696,  -22.6847687,   34.0985641,   7.27272749
  53697,  -21.7898464,   34.0985641,   7.27272749
  53698,  -20.8949223,   34.0985641,   7.27272749
  53699,  -29.0661163,   34.8909073,   7.27272749
  53700,  -28.1322308,   34.8909073,   7.27272749
  53701,  -27.1983471,   34.8909073,   7.27272749
  53702,  -26.2644634,   34.8909073,   7.27272749
  53703,  -25.3695393,   34.8909073,   7.27272749
  53704,   -24.474617,   34.8909073,   7.27272749
  53705,  -23.5796928,   34.8909073,   7.27272749
  53706,  -22.6847687,   34.8909073,   7.27272749
  53707,  -21.7898464,   34.8909073,   7.27272749
  53708,  -20.8949223,   34.8909073,   7.27272749
  53709,  -29.0661163,   35.6832542,   7.27272749
  53710,  -28.1322308,   35.6832542,   7.27272749
  53711,  -27.1983471,   35.6832542,   7.27272749
  53712,  -26.2644634,   35.6832542,   7.27272749
  53713,  -25.3695393,   35.6832542,   7.27272749
  53714,   -24.474617,   35.6832542,   7.27272749
  53715,  -23.5796928,   35.6832542,   7.27272749
  53716,  -22.6847687,   35.6832542,   7.27272749
  53717,  -21.7898464,   35.6832542,   7.27272749
  53718,  -20.8949223,   35.6832542,   7.27272749
  53719,  -29.0661163,   36.4755974,   7.27272749
  53720,  -28.1322308,   36.4755974,   7.27272749
  53721,  -27.1983471,   36.4755974,   7.27272749
  53722,  -26.2644634,   36.4755974,   7.27272749
  53723,  -25.3695393,   36.4755974,   7.27272749
  53724,   -24.474617,   36.4755974,   7.27272749
  53725,  -23.5796928,   36.4755974,   7.27272749
  53726,  -22.6847687,   36.4755974,   7.27272749
  53727,  -21.7898464,   36.4755974,   7.27272749
  53728,  -20.8949223,   36.4755974,   7.27272749
  53729,  -29.0661163,   37.2679443,   7.27272749
  53730,  -28.1322308,   37.2679443,   7.27272749
  53731,  -27.1983471,   37.2679443,   7.27272749
  53732,  -26.2644634,   37.2679443,   7.27272749
  53733,  -25.3695393,   37.2679443,   7.27272749
  53734,   -24.474617,   37.2679443,   7.27272749
  53735,  -23.5796928,   37.2679443,   7.27272749
  53736,  -22.6847687,   37.2679443,   7.27272749
  53737,  -21.7898464,   37.2679443,   7.27272749
  53738,  -20.8949223,   37.2679443,   7.27272749
  53739,  -29.0661163,   38.0602875,   7.27272749
  53740,  -28.1322308,   38.0602875,   7.27272749
  53741,  -27.1983471,   38.0602875,   7.27272749
  53742,  -26.2644634,   38.0602875,   7.27272749
  53743,  -25.3695393,   38.0602875,   7.27272749
  53744,   -24.474617,   38.0602875,   7.27272749
  53745,  -23.5796928,   38.0602875,   7.27272749
  53746,  -22.6847687,   38.0602875,   7.27272749
  53747,  -21.7898464,   38.0602875,   7.27272749
  53748,  -20.8949223,   38.0602875,   7.27272749
  53749,  -29.0661163,   38.8526306,   7.27272749
  53750,  -28.1322308,   38.8526306,   7.27272749
  53751,  -27.1983471,   38.8526306,   7.27272749
  53752,  -26.2644634,   38.8526306,   7.27272749
  53753,  -25.3695393,   38.8526306,   7.27272749
  53754,   -24.474617,   38.8526306,   7.27272749
  53755,  -23.5796928,   38.8526306,   7.27272749
  53756,  -22.6847687,   38.8526306,   7.27272749
  53757,  -21.7898464,   38.8526306,   7.27272749
  53758,  -20.8949223,   38.8526306,   7.27272749
  53759,  -29.0661163,   39.6449776,   7.27272749
  53760,  -28.1322308,   39.6449776,   7.27272749
  53761,  -27.1983471,   39.6449776,   7.27272749
  53762,  -26.2644634,   39.6449776,   7.27272749
  53763,  -25.3695393,   39.6449776,   7.27272749
  53764,   -24.474617,   39.6449776,   7.27272749
  53765,  -23.5796928,   39.6449776,   7.27272749
  53766,  -22.6847687,   39.6449776,   7.27272749
  53767,  -21.7898464,   39.6449776,   7.27272749
  53768,  -20.8949223,   39.6449776,   7.27272749
  53769,  -29.0661163,   40.4373207,   7.27272749
  53770,  -28.1322308,   40.4373207,   7.27272749
  53771,  -27.1983471,   40.4373207,   7.27272749
  53772,  -26.2644634,   40.4373207,   7.27272749
  53773,  -25.3695393,   40.4373207,   7.27272749
  53774,   -24.474617,   40.4373207,   7.27272749
  53775,  -23.5796928,   40.4373207,   7.27272749
  53776,  -22.6847687,   40.4373207,   7.27272749
  53777,  -21.7898464,   40.4373207,   7.27272749
  53778,  -20.8949223,   40.4373207,   7.27272749
  53779,  -29.0661163,   41.2296638,   7.27272749
  53780,  -28.1322308,   41.2296638,   7.27272749
  53781,  -27.1983471,   41.2296638,   7.27272749
  53782,  -26.2644634,   41.2296638,   7.27272749
  53783,  -25.3695393,   41.2296638,   7.27272749
  53784,   -24.474617,   41.2296638,   7.27272749
  53785,  -23.5796928,   41.2296638,   7.27272749
  53786,  -22.6847687,   41.2296638,   7.27272749
  53787,  -21.7898464,   41.2296638,   7.27272749
  53788,  -20.8949223,   41.2296638,   7.27272749
  53789,  -29.0661163,   42.0220108,   7.27272749
  53790,  -28.1322308,   42.0220108,   7.27272749
  53791,  -27.1983471,   42.0220108,   7.27272749
  53792,  -26.2644634,   42.0220108,   7.27272749
  53793,  -25.3695393,   42.0220108,   7.27272749
  53794,   -24.474617,   42.0220108,   7.27272749
  53795,  -23.5796928,   42.0220108,   7.27272749
  53796,  -22.6847687,   42.0220108,   7.27272749
  53797,  -21.7898464,   42.0220108,   7.27272749
  53798,  -20.8949223,   42.0220108,   7.27272749
  53799,  -29.0661163,   42.8143539,   7.27272749
  53800,  -28.1322308,   42.8143539,   7.27272749
  53801,  -27.1983471,   42.8143539,   7.27272749
  53802,  -26.2644634,   42.8143539,   7.27272749
  53803,  -25.3695393,   42.8143539,   7.27272749
  53804,   -24.474617,   42.8143539,   7.27272749
  53805,  -23.5796928,   42.8143539,   7.27272749
  53806,  -22.6847687,   42.8143539,   7.27272749
  53807,  -21.7898464,   42.8143539,   7.27272749
  53808,  -20.8949223,   42.8143539,   7.27272749
  53809,  -29.0661163,   43.6066971,   7.27272749
  53810,  -28.1322308,   43.6066971,   7.27272749
  53811,  -27.1983471,   43.6066971,   7.27272749
  53812,  -26.2644634,   43.6066971,   7.27272749
  53813,  -25.3695393,   43.6066971,   7.27272749
  53814,   -24.474617,   43.6066971,   7.27272749
  53815,  -23.5796928,   43.6066971,   7.27272749
  53816,  -22.6847687,   43.6066971,   7.27272749
  53817,  -21.7898464,   43.6066971,   7.27272749
  53818,  -20.8949223,   43.6066971,   7.27272749
  53819,  -29.0661163,    44.399044,   7.27272749
  53820,  -28.1322308,    44.399044,   7.27272749
  53821,  -27.1983471,    44.399044,   7.27272749
  53822,  -26.2644634,    44.399044,   7.27272749
  53823,  -25.3695393,    44.399044,   7.27272749
  53824,   -24.474617,    44.399044,   7.27272749
  53825,  -23.5796928,    44.399044,   7.27272749
  53826,  -22.6847687,    44.399044,   7.27272749
  53827,  -21.7898464,    44.399044,   7.27272749
  53828,  -20.8949223,    44.399044,   7.27272749
  53829,  -29.0661163,   45.1913872,   7.27272749
  53830,  -28.1322308,   45.1913872,   7.27272749
  53831,  -27.1983471,   45.1913872,   7.27272749
  53832,  -26.2644634,   45.1913872,   7.27272749
  53833,  -25.3695393,   45.1913872,   7.27272749
  53834,   -24.474617,   45.1913872,   7.27272749
  53835,  -23.5796928,   45.1913872,   7.27272749
  53836,  -22.6847687,   45.1913872,   7.27272749
  53837,  -21.7898464,   45.1913872,   7.27272749
  53838,  -20.8949223,   45.1913872,   7.27272749
  53839,  -29.0702496,   45.9928246,   7.27272749
  53840,  -28.1404953,   45.9928246,   7.27272749
  53841,  -27.2107449,   45.9928246,   7.27272749
  53842,  -26.2809906,   45.9928246,   7.27272749
  53843,   -25.383707,   45.9928246,   7.27272749
  53844,  -24.4864216,   45.9928246,   7.27272749
  53845,   -23.589138,   45.9928246,   7.27272749
  53846,  -22.6918526,   45.9928246,   7.27272749
  53847,   -21.794569,   45.9928246,   7.27272749
  53848,  -20.8972836,   45.9928246,   7.27272749
  53849,  -29.0743809,   46.7942581,   7.27272749
  53850,  -28.1487598,   46.7942581,   7.27272749
  53851,  -27.2231407,   46.7942581,   7.27272749
  53852,  -26.2975197,   46.7942581,   7.27272749
  53853,  -25.3978748,   46.7942581,   7.27272749
  53854,  -24.4982281,   46.7942581,   7.27272749
  53855,  -23.5985832,   46.7942581,   7.27272749
  53856,  -22.6989365,   46.7942581,   7.27272749
  53857,  -21.7992916,   46.7942581,   7.27272749
  53858,  -20.8996449,   46.7942581,   7.27272749
  53859,  -29.0785122,   47.5956955,   7.27272749
  53860,  -28.1570244,   47.5956955,   7.27272749
  53861,  -27.2355385,   47.5956955,   7.27272749
  53862,  -26.3140488,   47.5956955,   7.27272749
  53863,  -25.4120426,   47.5956955,   7.27272749
  53864,  -24.5100346,   47.5956955,   7.27272749
  53865,  -23.6080284,   47.5956955,   7.27272749
  53866,  -22.7060204,   47.5956955,   7.27272749
  53867,  -21.8040142,   47.5956955,   7.27272749
  53868,  -20.9020061,   47.5956955,   7.27272749
  53869,  -29.0826454,   48.3971291,   7.27272749
  53870,  -28.1652889,   48.3971291,   7.27272749
  53871,  -27.2479343,   48.3971291,   7.27272749
  53872,  -26.3305779,   48.3971291,   7.27272749
  53873,  -25.4262104,   48.3971291,   7.27272749
  53874,   -24.521841,   48.3971291,   7.27272749
  53875,  -23.6174736,   48.3971291,   7.27272749
  53876,  -22.7131042,   48.3971291,   7.27272749
  53877,  -21.8087368,   48.3971291,   7.27272749
  53878,  -20.9043674,   48.3971291,   7.27272749
  53879,  -29.0867767,   49.1985664,   7.27272749
  53880,  -28.1735535,   49.1985664,   7.27272749
  53881,  -27.2603302,   49.1985664,   7.27272749
  53882,  -26.3471069,   49.1985664,   7.27272749
  53883,  -25.4403782,   49.1985664,   7.27272749
  53884,  -24.5336475,   49.1985664,   7.27272749
  53885,  -23.6269188,   49.1985664,   7.27272749
  53886,  -22.7201881,   49.1985664,   7.27272749
  53887,  -21.8134594,   49.1985664,   7.27272749
  53888,  -20.9067287,   49.1985664,   7.27272749
  53889,  -29.0885487,   20.7758026,   8.18181801
  53890,  -28.1770954,   20.7758026,   8.18181801
  53891,  -27.2656441,   20.7758026,   8.18181801
  53892,  -26.3541908,   20.7758026,   8.18181801
  53893,  -25.4464493,   20.7758026,   8.18181801
  53894,  -24.5387077,   20.7758026,   8.18181801
  53895,  -23.6309662,   20.7758026,   8.18181801
  53896,  -22.7232246,   20.7758026,   8.18181801
  53897,  -21.8154831,   20.7758026,   8.18181801
  53898,  -20.9077415,   20.7758026,   8.18181801
  53899,  -29.0861874,   21.5516071,   8.18181801
  53900,  -28.1723728,   21.5516071,   8.18181801
  53901,  -27.2585602,   21.5516071,   8.18181801
  53902,  -26.3447456,   21.5516071,   8.18181801
  53903,  -25.4383545,   21.5516071,   8.18181801
  53904,  -24.5319614,   21.5516071,   8.18181801
  53905,  -23.6255703,   21.5516071,   8.18181801
  53906,  -22.7191753,   21.5516071,   8.18181801
  53907,  -21.8127842,   21.5516071,   8.18181801
  53908,  -20.9063911,   21.5516071,   8.18181801
  53909,  -29.0838261,   22.3274097,   8.18181801
  53910,  -28.1676502,   22.3274097,   8.18181801
  53911,  -27.2514763,   22.3274097,   8.18181801
  53912,  -26.3353004,   22.3274097,   8.18181801
  53913,  -25.4302578,   22.3274097,   8.18181801
  53914,  -24.5252151,   22.3274097,   8.18181801
  53915,  -23.6201725,   22.3274097,   8.18181801
  53916,  -22.7151279,   22.3274097,   8.18181801
  53917,  -21.8100853,   22.3274097,   8.18181801
  53918,  -20.9050426,   22.3274097,   8.18181801
  53919,  -29.0814648,   23.1032124,   8.18181801
  53920,  -28.1629276,   23.1032124,   8.18181801
  53921,  -27.2443924,   23.1032124,   8.18181801
  53922,  -26.3258553,   23.1032124,   8.18181801
  53923,   -25.422163,   23.1032124,   8.18181801
  53924,  -24.5184689,   23.1032124,   8.18181801
  53925,  -23.6147747,   23.1032124,   8.18181801
  53926,  -22.7110806,   23.1032124,   8.18181801
  53927,  -21.8073883,   23.1032124,   8.18181801
  53928,  -20.9036922,   23.1032124,   8.18181801
  53929,  -29.0791035,    23.879015,   8.18181801
  53930,   -28.158205,    23.879015,   8.18181801
  53931,  -27.2373085,    23.879015,   8.18181801
  53932,  -26.3164101,    23.879015,   8.18181801
  53933,  -25.4140663,    23.879015,   8.18181801
  53934,  -24.5117226,    23.879015,   8.18181801
  53935,  -23.6093769,    23.879015,   8.18181801
  53936,  -22.7070332,    23.879015,   8.18181801
  53937,  -21.8046894,    23.879015,   8.18181801
  53938,  -20.9023438,    23.879015,   8.18181801
  53939,  -29.0767422,   24.6548195,   8.18181801
  53940,  -28.1534824,   24.6548195,   8.18181801
  53941,  -27.2302246,   24.6548195,   8.18181801
  53942,  -26.3069649,   24.6548195,   8.18181801
  53943,  -25.4059715,   24.6548195,   8.18181801
  53944,  -24.5049744,   24.6548195,   8.18181801
  53945,   -23.603981,   24.6548195,   8.18181801
  53946,  -22.7029858,   24.6548195,   8.18181801
  53947,  -21.8019905,   24.6548195,   8.18181801
  53948,  -20.9009953,   24.6548195,   8.18181801
  53949,  -29.0743809,   25.4306221,   8.18181801
  53950,  -28.1487598,   25.4306221,   8.18181801
  53951,  -27.2231407,   25.4306221,   8.18181801
  53952,  -26.2975197,   25.4306221,   8.18181801
  53953,  -25.3978748,   25.4306221,   8.18181801
  53954,  -24.4982281,   25.4306221,   8.18181801
  53955,  -23.5985832,   25.4306221,   8.18181801
  53956,  -22.6989365,   25.4306221,   8.18181801
  53957,  -21.7992916,   25.4306221,   8.18181801
  53958,  -20.8996449,   25.4306221,   8.18181801
  53959,  -29.0743809,   26.2220097,   8.18181801
  53960,  -28.1487598,   26.2220097,   8.18181801
  53961,  -27.2231407,   26.2220097,   8.18181801
  53962,  -26.2975197,   26.2220097,   8.18181801
  53963,  -25.3978748,   26.2220097,   8.18181801
  53964,  -24.4982281,   26.2220097,   8.18181801
  53965,  -23.5985832,   26.2220097,   8.18181801
  53966,  -22.6989365,   26.2220097,   8.18181801
  53967,  -21.7992916,   26.2220097,   8.18181801
  53968,  -20.8996449,   26.2220097,   8.18181801
  53969,  -29.0743809,   27.0133972,   8.18181801
  53970,  -28.1487598,   27.0133972,   8.18181801
  53971,  -27.2231407,   27.0133972,   8.18181801
  53972,  -26.2975197,   27.0133972,   8.18181801
  53973,  -25.3978748,   27.0133972,   8.18181801
  53974,  -24.4982281,   27.0133972,   8.18181801
  53975,  -23.5985832,   27.0133972,   8.18181801
  53976,  -22.6989365,   27.0133972,   8.18181801
  53977,  -21.7992916,   27.0133972,   8.18181801
  53978,  -20.8996449,   27.0133972,   8.18181801
  53979,  -29.0743809,   27.8047848,   8.18181801
  53980,  -28.1487598,   27.8047848,   8.18181801
  53981,  -27.2231407,   27.8047848,   8.18181801
  53982,  -26.2975197,   27.8047848,   8.18181801
  53983,  -25.3978748,   27.8047848,   8.18181801
  53984,  -24.4982281,   27.8047848,   8.18181801
  53985,  -23.5985832,   27.8047848,   8.18181801
  53986,  -22.6989365,   27.8047848,   8.18181801
  53987,  -21.7992916,   27.8047848,   8.18181801
  53988,  -20.8996449,   27.8047848,   8.18181801
  53989,  -29.0743809,   28.5961723,   8.18181801
  53990,  -28.1487598,   28.5961723,   8.18181801
  53991,  -27.2231407,   28.5961723,   8.18181801
  53992,  -26.2975197,   28.5961723,   8.18181801
  53993,  -25.3978748,   28.5961723,   8.18181801
  53994,  -24.4982281,   28.5961723,   8.18181801
