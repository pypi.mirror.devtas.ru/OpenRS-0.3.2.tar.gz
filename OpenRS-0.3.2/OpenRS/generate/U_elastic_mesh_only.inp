  17995,          20.,   8.33333302,   6.36363649
  17996,          20.,   8.33333302,   7.27272749
  17997,          20.,   8.33333302,   8.18181801
  17998,          20.,   8.33333302,     9.090909
  17999,          20.,          7.5,  0.909090936
  18000,          20.,          7.5,   1.81818187
  18001,          20.,          7.5,   2.72727275
  18002,          20.,          7.5,   3.63636374
  18003,          20.,          7.5,    4.5454545
  18004,          20.,          7.5,    5.4545455
  18005,          20.,          7.5,   6.36363649
  18006,          20.,          7.5,   7.27272749
  18007,          20.,          7.5,   8.18181801
  18008,          20.,          7.5,     9.090909
  18009,          20.,   6.66666651,  0.909090936
  18010,          20.,   6.66666651,   1.81818187
  18011,          20.,   6.66666651,   2.72727275
  18012,          20.,   6.66666651,   3.63636374
  18013,          20.,   6.66666651,    4.5454545
  18014,          20.,   6.66666651,    5.4545455
  18015,          20.,   6.66666651,   6.36363649
  18016,          20.,   6.66666651,   7.27272749
  18017,          20.,   6.66666651,   8.18181801
  18018,          20.,   6.66666651,     9.090909
  18019,          20.,   5.83333349,  0.909090936
  18020,          20.,   5.83333349,   1.81818187
  18021,          20.,   5.83333349,   2.72727275
  18022,          20.,   5.83333349,   3.63636374
  18023,          20.,   5.83333349,    4.5454545
  18024,          20.,   5.83333349,    5.4545455
  18025,          20.,   5.83333349,   6.36363649
  18026,          20.,   5.83333349,   7.27272749
  18027,          20.,   5.83333349,   8.18181801
  18028,          20.,   5.83333349,     9.090909
  18029,          20.,           5.,  0.909090936
  18030,          20.,           5.,   1.81818187
  18031,          20.,           5.,   2.72727275
  18032,          20.,           5.,   3.63636374
  18033,          20.,           5.,    4.5454545
  18034,          20.,           5.,    5.4545455
  18035,          20.,           5.,   6.36363649
  18036,          20.,           5.,   7.27272749
  18037,          20.,           5.,   8.18181801
  18038,          20.,           5.,     9.090909
  18039,          20.,   4.16666651,  0.909090936
  18040,          20.,   4.16666651,   1.81818187
  18041,          20.,   4.16666651,   2.72727275
  18042,          20.,   4.16666651,   3.63636374
  18043,          20.,   4.16666651,    4.5454545
  18044,          20.,   4.16666651,    5.4545455
  18045,          20.,   4.16666651,   6.36363649
  18046,          20.,   4.16666651,   7.27272749
  18047,          20.,   4.16666651,   8.18181801
  18048,          20.,   4.16666651,     9.090909
  18049,          20.,   3.33333325,  0.909090936
  18050,          20.,   3.33333325,   1.81818187
  18051,          20.,   3.33333325,   2.72727275
  18052,          20.,   3.33333325,   3.63636374
  18053,          20.,   3.33333325,    4.5454545
  18054,          20.,   3.33333325,    5.4545455
  18055,          20.,   3.33333325,   6.36363649
  18056,          20.,   3.33333325,   7.27272749
  18057,          20.,   3.33333325,   8.18181801
  18058,          20.,   3.33333325,     9.090909
  18059,          20.,          2.5,  0.909090936
  18060,          20.,          2.5,   1.81818187
  18061,          20.,          2.5,   2.72727275
  18062,          20.,          2.5,   3.63636374
  18063,          20.,          2.5,    4.5454545
  18064,          20.,          2.5,    5.4545455
  18065,          20.,          2.5,   6.36363649
  18066,          20.,          2.5,   7.27272749
  18067,          20.,          2.5,   8.18181801
  18068,          20.,          2.5,     9.090909
  18069,          20.,   1.66666663,  0.909090936
  18070,          20.,   1.66666663,   1.81818187
  18071,          20.,   1.66666663,   2.72727275
  18072,          20.,   1.66666663,   3.63636374
  18073,          20.,   1.66666663,    4.5454545
  18074,          20.,   1.66666663,    5.4545455
  18075,          20.,   1.66666663,   6.36363649
  18076,          20.,   1.66666663,   7.27272749
  18077,          20.,   1.66666663,   8.18181801
  18078,          20.,   1.66666663,     9.090909
  18079,          20.,  0.833333313,  0.909090936
  18080,          20.,  0.833333313,   1.81818187
  18081,          20.,  0.833333313,   2.72727275
  18082,          20.,  0.833333313,   3.63636374
  18083,          20.,  0.833333313,    4.5454545
  18084,          20.,  0.833333313,    5.4545455
  18085,          20.,  0.833333313,   6.36363649
  18086,          20.,  0.833333313,   7.27272749
  18087,          20.,  0.833333313,   8.18181801
  18088,          20.,  0.833333313,     9.090909
  18089,     29.09091,   9.16666698,           0.
  18090,    28.181818,   9.16666698,           0.
  18091,    27.272728,   9.16666698,           0.
  18092,    26.363636,   9.16666698,           0.
  18093,    25.454546,   9.16666698,           0.
  18094,    24.545454,   9.16666698,           0.
  18095,    23.636364,   9.16666698,           0.
  18096,    22.727272,   9.16666698,           0.
  18097,    21.818182,   9.16666698,           0.
  18098,     20.90909,   9.16666698,           0.
  18099,     29.09091,   8.33333302,           0.
  18100,    28.181818,   8.33333302,           0.
  18101,    27.272728,   8.33333302,           0.
  18102,    26.363636,   8.33333302,           0.
  18103,    25.454546,   8.33333302,           0.
  18104,    24.545454,   8.33333302,           0.
  18105,    23.636364,   8.33333302,           0.
  18106,    22.727272,   8.33333302,           0.
  18107,    21.818182,   8.33333302,           0.
  18108,     20.90909,   8.33333302,           0.
  18109,     29.09091,          7.5,           0.
  18110,    28.181818,          7.5,           0.
  18111,    27.272728,          7.5,           0.
  18112,    26.363636,          7.5,           0.
  18113,    25.454546,          7.5,           0.
  18114,    24.545454,          7.5,           0.
  18115,    23.636364,          7.5,           0.
  18116,    22.727272,          7.5,           0.
  18117,    21.818182,          7.5,           0.
  18118,     20.90909,          7.5,           0.
  18119,     29.09091,   6.66666651,           0.
  18120,    28.181818,   6.66666651,           0.
  18121,    27.272728,   6.66666651,           0.
  18122,    26.363636,   6.66666651,           0.
  18123,    25.454546,   6.66666651,           0.
  18124,    24.545454,   6.66666651,           0.
  18125,    23.636364,   6.66666651,           0.
  18126,    22.727272,   6.66666651,           0.
  18127,    21.818182,   6.66666651,           0.
  18128,     20.90909,   6.66666651,           0.
  18129,     29.09091,   5.83333349,           0.
  18130,    28.181818,   5.83333349,           0.
  18131,    27.272728,   5.83333349,           0.
  18132,    26.363636,   5.83333349,           0.
  18133,    25.454546,   5.83333349,           0.
  18134,    24.545454,   5.83333349,           0.
  18135,    23.636364,   5.83333349,           0.
  18136,    22.727272,   5.83333349,           0.
  18137,    21.818182,   5.83333349,           0.
  18138,     20.90909,   5.83333349,           0.
  18139,     29.09091,           5.,           0.
  18140,    28.181818,           5.,           0.
  18141,    27.272728,           5.,           0.
  18142,    26.363636,           5.,           0.
  18143,    25.454546,           5.,           0.
  18144,    24.545454,           5.,           0.
  18145,    23.636364,           5.,           0.
  18146,    22.727272,           5.,           0.
  18147,    21.818182,           5.,           0.
  18148,     20.90909,           5.,           0.
  18149,     29.09091,   4.16666651,           0.
  18150,    28.181818,   4.16666651,           0.
  18151,    27.272728,   4.16666651,           0.
  18152,    26.363636,   4.16666651,           0.
  18153,    25.454546,   4.16666651,           0.
  18154,    24.545454,   4.16666651,           0.
  18155,    23.636364,   4.16666651,           0.
  18156,    22.727272,   4.16666651,           0.
  18157,    21.818182,   4.16666651,           0.
  18158,     20.90909,   4.16666651,           0.
  18159,     29.09091,   3.33333325,           0.
  18160,    28.181818,   3.33333325,           0.
  18161,    27.272728,   3.33333325,           0.
  18162,    26.363636,   3.33333325,           0.
  18163,    25.454546,   3.33333325,           0.
  18164,    24.545454,   3.33333325,           0.
  18165,    23.636364,   3.33333325,           0.
  18166,    22.727272,   3.33333325,           0.
  18167,    21.818182,   3.33333325,           0.
  18168,     20.90909,   3.33333325,           0.
  18169,     29.09091,          2.5,           0.
  18170,    28.181818,          2.5,           0.
  18171,    27.272728,          2.5,           0.
  18172,    26.363636,          2.5,           0.
  18173,    25.454546,          2.5,           0.
  18174,    24.545454,          2.5,           0.
  18175,    23.636364,          2.5,           0.
  18176,    22.727272,          2.5,           0.
  18177,    21.818182,          2.5,           0.
  18178,     20.90909,          2.5,           0.
  18179,     29.09091,   1.66666663,           0.
  18180,    28.181818,   1.66666663,           0.
  18181,    27.272728,   1.66666663,           0.
  18182,    26.363636,   1.66666663,           0.
  18183,    25.454546,   1.66666663,           0.
  18184,    24.545454,   1.66666663,           0.
  18185,    23.636364,   1.66666663,           0.
  18186,    22.727272,   1.66666663,           0.
  18187,    21.818182,   1.66666663,           0.
  18188,     20.90909,   1.66666663,           0.
  18189,     29.09091,  0.833333313,           0.
  18190,    28.181818,  0.833333313,           0.
  18191,    27.272728,  0.833333313,           0.
  18192,    26.363636,  0.833333313,           0.
  18193,    25.454546,  0.833333313,           0.
  18194,    24.545454,  0.833333313,           0.
  18195,    23.636364,  0.833333313,           0.
  18196,    22.727272,  0.833333313,           0.
  18197,    21.818182,  0.833333313,           0.
  18198,     20.90909,  0.833333313,           0.
  18199,     29.09091,   9.16666698,          10.
  18200,    28.181818,   9.16666698,          10.
  18201,    27.272728,   9.16666698,          10.
  18202,    26.363636,   9.16666698,          10.
  18203,    25.454546,   9.16666698,          10.
  18204,    24.545454,   9.16666698,          10.
  18205,    23.636364,   9.16666698,          10.
  18206,    22.727272,   9.16666698,          10.
  18207,    21.818182,   9.16666698,          10.
  18208,     20.90909,   9.16666698,          10.
  18209,     29.09091,   8.33333302,          10.
  18210,    28.181818,   8.33333302,          10.
  18211,    27.272728,   8.33333302,          10.
  18212,    26.363636,   8.33333302,          10.
  18213,    25.454546,   8.33333302,          10.
  18214,    24.545454,   8.33333302,          10.
  18215,    23.636364,   8.33333302,          10.
  18216,    22.727272,   8.33333302,          10.
  18217,    21.818182,   8.33333302,          10.
  18218,     20.90909,   8.33333302,          10.
  18219,     29.09091,          7.5,          10.
  18220,    28.181818,          7.5,          10.
  18221,    27.272728,          7.5,          10.
  18222,    26.363636,          7.5,          10.
  18223,    25.454546,          7.5,          10.
  18224,    24.545454,          7.5,          10.
  18225,    23.636364,          7.5,          10.
  18226,    22.727272,          7.5,          10.
  18227,    21.818182,          7.5,          10.
  18228,     20.90909,          7.5,          10.
  18229,     29.09091,   6.66666651,          10.
  18230,    28.181818,   6.66666651,          10.
  18231,    27.272728,   6.66666651,          10.
  18232,    26.363636,   6.66666651,          10.
  18233,    25.454546,   6.66666651,          10.
  18234,    24.545454,   6.66666651,          10.
  18235,    23.636364,   6.66666651,          10.
  18236,    22.727272,   6.66666651,          10.
  18237,    21.818182,   6.66666651,          10.
  18238,     20.90909,   6.66666651,          10.
  18239,     29.09091,   5.83333349,          10.
  18240,    28.181818,   5.83333349,          10.
  18241,    27.272728,   5.83333349,          10.
  18242,    26.363636,   5.83333349,          10.
  18243,    25.454546,   5.83333349,          10.
  18244,    24.545454,   5.83333349,          10.
  18245,    23.636364,   5.83333349,          10.
  18246,    22.727272,   5.83333349,          10.
  18247,    21.818182,   5.83333349,          10.
  18248,     20.90909,   5.83333349,          10.
  18249,     29.09091,           5.,          10.
  18250,    28.181818,           5.,          10.
  18251,    27.272728,           5.,          10.
  18252,    26.363636,           5.,          10.
  18253,    25.454546,           5.,          10.
  18254,    24.545454,           5.,          10.
  18255,    23.636364,           5.,          10.
  18256,    22.727272,           5.,          10.
  18257,    21.818182,           5.,          10.
  18258,     20.90909,           5.,          10.
  18259,     29.09091,   4.16666651,          10.
  18260,    28.181818,   4.16666651,          10.
  18261,    27.272728,   4.16666651,          10.
  18262,    26.363636,   4.16666651,          10.
  18263,    25.454546,   4.16666651,          10.
  18264,    24.545454,   4.16666651,          10.
  18265,    23.636364,   4.16666651,          10.
  18266,    22.727272,   4.16666651,          10.
  18267,    21.818182,   4.16666651,          10.
  18268,     20.90909,   4.16666651,          10.
  18269,     29.09091,   3.33333325,          10.
  18270,    28.181818,   3.33333325,          10.
  18271,    27.272728,   3.33333325,          10.
  18272,    26.363636,   3.33333325,          10.
  18273,    25.454546,   3.33333325,          10.
  18274,    24.545454,   3.33333325,          10.
  18275,    23.636364,   3.33333325,          10.
  18276,    22.727272,   3.33333325,          10.
  18277,    21.818182,   3.33333325,          10.
  18278,     20.90909,   3.33333325,          10.
  18279,     29.09091,          2.5,          10.
  18280,    28.181818,          2.5,          10.
  18281,    27.272728,          2.5,          10.
  18282,    26.363636,          2.5,          10.
  18283,    25.454546,          2.5,          10.
  18284,    24.545454,          2.5,          10.
  18285,    23.636364,          2.5,          10.
  18286,    22.727272,          2.5,          10.
  18287,    21.818182,          2.5,          10.
  18288,     20.90909,          2.5,          10.
  18289,     29.09091,   1.66666663,          10.
  18290,    28.181818,   1.66666663,          10.
  18291,    27.272728,   1.66666663,          10.
  18292,    26.363636,   1.66666663,          10.
  18293,    25.454546,   1.66666663,          10.
  18294,    24.545454,   1.66666663,          10.
  18295,    23.636364,   1.66666663,          10.
  18296,    22.727272,   1.66666663,          10.
  18297,    21.818182,   1.66666663,          10.
  18298,     20.90909,   1.66666663,          10.
  18299,     29.09091,  0.833333313,          10.
  18300,    28.181818,  0.833333313,          10.
  18301,    27.272728,  0.833333313,          10.
  18302,    26.363636,  0.833333313,          10.
  18303,    25.454546,  0.833333313,          10.
  18304,    24.545454,  0.833333313,          10.
  18305,    23.636364,  0.833333313,          10.
  18306,    22.727272,  0.833333313,          10.
  18307,    21.818182,  0.833333313,          10.
  18308,     20.90909,  0.833333313,          10.
  18309,   21.7384701,   14.3461742,   9.53731346
  18310,   21.7269402,   14.3173494,   9.07462692
  18311,   21.7154102,   14.2885237,   8.61194038
  18312,   21.7038803,   14.2596989,   8.14925385
  18313,   21.6923485,   14.2308731,   7.68656683
  18314,   21.6808186,   14.2020483,   7.22388029
  18315,   21.6692886,   14.1732225,   6.76119328
  18316,   21.6577587,   14.1443977,   6.29850674
  18317,   21.6462288,    14.115572,    5.8358202
  18318,   21.6346989,   14.0867462,   5.37313366
  18319,   21.4780121,   13.6950293,   9.51302719
  18320,   21.4560242,   13.6400595,   9.02605343
  18321,   21.4340363,   13.5850887,   8.53908062
  18322,   21.4120483,   13.5301189,   8.05210686
  18323,   21.3900585,   13.4751482,   7.56513405
  18324,   21.3680706,   13.4201784,   7.07816076
  18325,   21.3460827,   13.3652077,   6.59118748
  18326,   21.3240948,   13.3102379,   6.10421467
  18327,   21.3021069,   13.2552671,   5.61724138
  18328,   21.2801189,   13.2002974,    5.1302681
  18329,   21.2197247,   13.0493116,   9.47304153
  18330,   21.1894493,   12.9736223,   8.94608307
  18331,    21.159174,    12.897934,   8.41912365
  18332,   21.1288986,   12.8222446,   7.89216518
  18333,   21.0986233,   12.7465563,   7.36520672
  18334,   21.0683479,   12.6708679,   6.83824778
  18335,   21.0380707,   12.5951786,   6.31128931
  18336,   21.0077953,   12.5194902,   5.78433037
  18337,     20.97752,   12.4438009,    5.2573719
  18338,   20.9472446,   12.3681126,   4.73041344
  18339,   20.9647465,   12.4118662,   9.41821671
  18340,    20.929493,   12.3237314,   8.83643246
  18341,   20.8942394,   12.2355976,   8.25464916
  18342,   20.8589859,   12.1474638,   7.67286587
  18343,   20.8237324,    12.059329,    7.0910821
  18344,   20.7884789,   11.9711952,    6.5092988
  18345,   20.7532253,   11.8830614,   5.92751503
  18346,   20.7179718,   11.7949276,   5.34573174
  18347,   20.6827164,   11.7067928,   4.76394796
  18348,   20.6474628,    11.618659,   4.18216419
  18349,   20.7142429,   11.7856054,   9.34998417
  18350,    20.678484,   11.6962109,   8.69996929
  18351,   20.6427269,   11.6068163,   8.04995346
  18352,   20.6069679,   11.5174208,   7.39993811
  18353,   20.5712109,   11.4280262,   6.74992228
  18354,   20.5354519,   11.3386316,   6.09990692
  18355,   20.4996948,   11.2492371,   5.44989157
  18356,   20.4639378,   11.1598425,   4.79987574
  18357,   20.4281788,   11.0704479,   4.14986038
  18358,   20.3924217,   10.9810534,   3.49984503
  18359,   20.4693432,    11.173358,   9.27052689
  18360,   20.4386864,   11.0967159,   8.54105377
  18361,   20.4080296,   11.0200739,   7.81158113
  18362,   20.3773727,   10.9434319,   7.08210802
  18363,   20.3467159,   10.8667898,   6.35263491
  18364,   20.3160591,   10.7901478,   5.62316179
  18365,   20.2854023,   10.7135057,   4.89368916
  18366,   20.2547455,   10.6368637,   4.16421604
  18367,   20.2240887,   10.5602217,   3.43474293
  18368,   20.1934319,   10.4835796,   2.70527005
  18369,   20.2310333,   10.5775852,   9.18288708
  18370,   20.2120686,   10.5301704,   8.36577415
  18371,   20.1931019,   10.4827547,   7.54866171
  18372,   20.1741352,   10.4353399,   6.73154879
  18373,   20.1551704,   10.3879251,   5.91443586
  18374,   20.1362038,   10.3405104,   5.09732294
  18375,    20.117239,   10.2930956,   4.28021002
  18376,   20.0982723,   10.2456808,   3.46309733
  18377,   20.0793056,   10.1982651,   2.64598465
  18378,   20.0603409,   10.1508503,   1.82887173
  18379,   28.2615299,   14.3461752,   9.53731346
  18380,   28.2730598,   14.3173494,   9.07462692
  18381,   28.2845898,   14.2885246,   8.61194038
  18382,   28.2961197,   14.2596989,   8.14925385
  18383,   28.3076496,   14.2308741,   7.68656683
  18384,   28.3191795,   14.2020493,   7.22388029
  18385,   28.3307114,   14.1732235,   6.76119375
  18386,   28.3422413,   14.1443987,   6.29850721
  18387,   28.3537712,   14.1155729,    5.8358202
  18388,   28.3653011,   14.0867481,   5.37313366
  18389,   28.5219879,   13.6950302,   9.51302719
  18390,   28.5439758,   13.6400595,   9.02605343
  18391,   28.5659637,   13.5850897,   8.53908062
  18392,   28.5879517,   13.5301199,   8.05210781
  18393,   28.6099396,   13.4751492,   7.56513453
  18394,   28.6319275,   13.4201794,   7.07816124
  18395,   28.6539154,   13.3652096,   6.59118795
  18396,   28.6759052,   13.3102388,   6.10421515
  18397,   28.6978931,   13.2552691,   5.61724186
  18398,   28.7198811,   13.2002983,   5.13026857
  18399,   28.7802753,   13.0493116,   9.47304153
  18400,   28.8105507,   12.9736223,   8.94608307
  18401,    28.840826,    12.897934,    8.4191246
  18402,   28.8711014,   12.8222456,   7.89216566
  18403,   28.9013767,   12.7465563,   7.36520672
  18404,   28.9316521,   12.6708679,   6.83824825
  18405,   28.9619274,   12.5951796,   6.31128979
  18406,   28.9922047,   12.5194902,   5.78433084
  18407,     29.02248,   12.4438019,   5.25737238
  18408,   29.0527554,   12.3681135,   4.73041391
  18409,   29.0352535,   12.4118662,   9.41821671
  18410,    29.070507,   12.3237324,   8.83643341
  18411,   29.1057606,   12.2355976,   8.25464916
  18412,   29.1410141,   12.1474638,   7.67286587
  18413,   29.1762676,     12.05933,   7.09108257
  18414,   29.2115211,   11.9711962,    6.5092988
  18415,   29.2467747,   11.8830614,   5.92751551
  18416,   29.2820282,   11.7949276,   5.34573221
  18417,   29.3172817,   11.7067938,   4.76394844
  18418,   29.3525352,     11.61866,   4.18216515
  18419,   29.2857571,   11.7856054,   9.34998417
  18420,    29.321516,   11.6962109,   8.69996929
  18421,   29.3572731,   11.6068163,   8.04995346
  18422,   29.3930321,   11.5174208,   7.39993811
  18423,   29.4287891,   11.4280262,   6.74992228
  18424,   29.4645481,   11.3386316,   6.09990692
  18425,   29.5003052,   11.2492371,   5.44989109
  18426,   29.5360622,   11.1598425,   4.79987574
  18427,   29.5718212,   11.0704479,   4.14986038
  18428,   29.6075783,   10.9810524,   3.49984479
  18429,   29.5306568,    11.173358,   9.27052689
  18430,   29.5613136,   11.0967159,   8.54105377
  18431,   29.5919704,   11.0200739,   7.81158066
  18432,   29.6226273,   10.9434319,   7.08210754
  18433,   29.6532841,   10.8667889,   6.35263443
  18434,   29.6839409,   10.7901468,   5.62316132
  18435,   29.7145977,   10.7135048,    4.8936882
  18436,   29.7452545,   10.6368628,   4.16421509
  18437,   29.7759113,   10.5602207,   3.43474174
  18438,   29.8065681,   10.4835787,   2.70526862
  18439,   29.7689667,   10.5775852,   9.18288708
  18440,   29.7879314,   10.5301704,   8.36577415
  18441,   29.8068981,   10.4827547,   7.54866076
  18442,   29.8258648,   10.4353399,   6.73154783
  18443,   29.8448296,   10.3879251,   5.91443491
  18444,   29.8637962,   10.3405104,   5.09732199
  18445,   29.8827629,   10.2930946,   4.28020906
  18446,   29.9017277,   10.2456799,    3.4630959
  18447,   29.9206944,   10.1982651,   2.64598274
  18448,   29.9396591,   10.1508503,   1.82886982
  18449,     22.34091,       14.375,          10.
  18450,    22.136364,        13.75,          10.
  18451,    21.931818,       13.125,          10.
  18452,    21.727272,         12.5,          10.
  18453,    21.522728,       11.875,          10.
  18454,    21.318182,        11.25,          10.
  18455,    21.113636,       10.625,          10.
  18456,    22.931818,       14.375,          10.
  18457,    22.772728,        13.75,          10.
  18458,    22.613636,       13.125,          10.
  18459,    22.454546,         12.5,          10.
  18460,    22.295454,       11.875,          10.
  18461,    22.136364,        11.25,          10.
  18462,    21.977272,       10.625,          10.
  18463,    23.522728,       14.375,          10.
  18464,     23.40909,        13.75,          10.
  18465,    23.295454,       13.125,          10.
  18466,    23.181818,         12.5,          10.
  18467,    23.068182,       11.875,          10.
  18468,    22.954546,        11.25,          10.
  18469,     22.84091,       10.625,          10.
  18470,    24.113636,       14.375,          10.
  18471,    24.045454,        13.75,          10.
  18472,    23.977272,       13.125,          10.
  18473,     23.90909,         12.5,          10.
  18474,     23.84091,       11.875,          10.
  18475,    23.772728,        11.25,          10.
  18476,    23.704546,       10.625,          10.
  18477,    24.704546,       14.375,          10.
  18478,    24.681818,        13.75,          10.
  18479,     24.65909,       13.125,          10.
  18480,    24.636364,         12.5,          10.
  18481,    24.613636,       11.875,          10.
  18482,     24.59091,        11.25,          10.
  18483,    24.568182,       10.625,          10.
  18484,    25.295454,       14.375,          10.
  18485,    25.318182,        13.75,          10.
  18486,     25.34091,       13.125,          10.
  18487,    25.363636,         12.5,          10.
  18488,    25.386364,       11.875,          10.
  18489,     25.40909,        11.25,          10.
  18490,    25.431818,       10.625,          10.
  18491,    25.886364,       14.375,          10.
  18492,    25.954546,        13.75,          10.
  18493,    26.022728,       13.125,          10.
  18494,     26.09091,         12.5,          10.
  18495,     26.15909,       11.875,          10.
  18496,    26.227272,        11.25,          10.
  18497,    26.295454,       10.625,          10.
  18498,    26.477272,       14.375,          10.
  18499,     26.59091,        13.75,          10.
  18500,    26.704546,       13.125,          10.
  18501,    26.818182,         12.5,          10.
  18502,    26.931818,       11.875,          10.
  18503,    27.045454,        11.25,          10.
  18504,     27.15909,       10.625,          10.
  18505,    27.068182,       14.375,          10.
  18506,    27.227272,        13.75,          10.
  18507,    27.386364,       13.125,          10.
  18508,    27.545454,         12.5,          10.
  18509,    27.704546,       11.875,          10.
  18510,    27.863636,        11.25,          10.
  18511,    28.022728,       10.625,          10.
  18512,     27.65909,       14.375,          10.
  18513,    27.863636,        13.75,          10.
  18514,    28.068182,       13.125,          10.
  18515,    28.272728,         12.5,          10.
  18516,    28.477272,       11.875,          10.
  18517,    28.681818,        11.25,          10.
  18518,    28.886364,       10.625,          10.
  18519,   22.2371387,   14.0579214,   4.91044664
  18520,   21.9384708,   13.1453266,   4.64329481
  18521,    21.659338,   12.2924242,   4.20345497
  18522,   21.4099903,   11.5305252,   3.60038114
  18523,   21.2009068,   10.8916578,    2.8498292
  18524,   21.0422707,   10.4069366,   1.97579682
  18525,   20.9429417,   10.1034355,   1.01175869
  18526,   22.8511066,   14.0579214,   4.91044664
  18527,   22.6188107,   13.1453276,   4.64329529
  18528,   22.4017086,   12.2924242,   4.20345497
  18529,   22.2077694,   11.5305252,   3.60038114
  18530,   22.0451488,   10.8916578,    2.8498292
  18531,   21.9217663,   10.4069366,   1.97579658
  18532,    21.844511,   10.1034355,   1.01175857
  18533,   23.4650764,   14.0579214,   4.91044664
  18534,   23.2991505,   13.1453276,   4.64329529
  18535,   23.1440773,   12.2924242,   4.20345497
  18536,   23.0055504,   11.5305252,   3.60038114
  18537,   22.8893929,   10.8916578,    2.8498292
  18538,   22.8012619,   10.4069366,   1.97579646
  18539,   22.7460785,   10.1034355,   1.01175833
  18540,   24.0790462,   14.0579224,   4.91044712
  18541,   23.9794903,   13.1453276,   4.64329529
  18542,    23.886446,   12.2924242,   4.20345497
  18543,   23.8033295,   11.5305252,   3.60038114
  18544,   23.7336349,   10.8916578,    2.8498292
  18545,   23.6807575,   10.4069366,   1.97579634
  18546,   23.6476479,   10.1034355,   1.01175809
  18547,   24.6930141,   14.0579224,   4.91044712
  18548,   24.6598301,   13.1453276,   4.64329529
  18549,   24.6288147,   12.2924242,   4.20345497
  18550,   24.6011105,   11.5305252,   3.60038114
  18551,    24.577879,   10.8916578,    2.8498292
  18552,   24.5602531,   10.4069366,   1.97579622
  18553,   24.5492153,   10.1034355,   1.01175797
  18554,   25.3069839,   14.0579224,   4.91044712
  18555,   25.3401699,   13.1453276,   4.64329529
  18556,   25.3711853,   12.2924242,   4.20345497
  18557,   25.3988895,   11.5305252,   3.60038114
  18558,    25.422121,   10.8916578,    2.8498292
  18559,   25.4397488,   10.4069366,    1.9757961
  18560,   25.4507847,   10.1034355,   1.01175773
  18561,   25.9209538,   14.0579224,   4.91044712
  18562,   26.0205097,   13.1453276,   4.64329529
  18563,    26.113554,   12.2924242,   4.20345497
  18564,   26.1966705,   11.5305252,   3.60038137
  18565,   26.2663651,   10.8916578,    2.8498292
  18566,   26.3192425,   10.4069366,    1.9757961
  18567,   26.3523521,   10.1034355,   1.01175761
  18568,   26.5349236,   14.0579224,   4.91044712
  18569,   26.7008495,   13.1453285,   4.64329576
  18570,   26.8559227,   12.2924242,   4.20345497
  18571,   26.9944496,   11.5305252,   3.60038137
  18572,   27.1106071,   10.8916578,    2.8498292
  18573,   27.1987381,   10.4069366,   1.97579598
  18574,   27.2539215,   10.1034355,   1.01175749
  18575,   27.1488914,   14.0579224,   4.91044712
  18576,   27.3811893,   13.1453285,   4.64329576
  18577,   27.5982914,   12.2924242,   4.20345497
  18578,   27.7922306,   11.5305252,   3.60038137
  18579,   27.9548512,   10.8916578,    2.8498292
  18580,   28.0782337,   10.4069366,   1.97579587
  18581,    28.155489,   10.1034355,   1.01175725
  18582,   27.7628613,   14.0579224,   4.91044712
  18583,   28.0615292,   13.1453285,   4.64329576
  18584,   28.3406601,   12.2924242,   4.20345497
  18585,   28.5900097,   11.5305252,   3.60038137
  18586,   28.7990932,   10.8916578,    2.8498292
  18587,   28.9577293,   10.4069366,   1.97579575
  18588,   29.0570583,   10.1034355,   1.01175714
  18589,     20.90909,   9.16666698,         -10.
  18590,    21.818182,   9.16666698,         -10.
  18591,    22.727272,   9.16666698,         -10.
  18592,    23.636364,   9.16666698,         -10.
  18593,    24.545454,   9.16666698,         -10.
  18594,    25.454546,   9.16666698,         -10.
  18595,    26.363636,   9.16666698,         -10.
  18596,    27.272728,   9.16666698,         -10.
  18597,    28.181818,   9.16666698,         -10.
  18598,     29.09091,   9.16666698,         -10.
  18599,     20.90909,   8.33333302,         -10.
  18600,    21.818182,   8.33333302,         -10.
  18601,    22.727272,   8.33333302,         -10.
  18602,    23.636364,   8.33333302,         -10.
  18603,    24.545454,   8.33333302,         -10.
  18604,    25.454546,   8.33333302,         -10.
  18605,    26.363636,   8.33333302,         -10.
  18606,    27.272728,   8.33333302,         -10.
  18607,    28.181818,   8.33333302,         -10.
  18608,     29.09091,   8.33333302,         -10.
  18609,     20.90909,          7.5,         -10.
  18610,    21.818182,          7.5,         -10.
  18611,    22.727272,          7.5,         -10.
  18612,    23.636364,          7.5,         -10.
  18613,    24.545454,          7.5,         -10.
  18614,    25.454546,          7.5,         -10.
  18615,    26.363636,          7.5,         -10.
  18616,    27.272728,          7.5,         -10.
  18617,    28.181818,          7.5,         -10.
  18618,     29.09091,          7.5,         -10.
  18619,     20.90909,   6.66666651,         -10.
  18620,    21.818182,   6.66666651,         -10.
  18621,    22.727272,   6.66666651,         -10.
  18622,    23.636364,   6.66666651,         -10.
  18623,    24.545454,   6.66666651,         -10.
  18624,    25.454546,   6.66666651,         -10.
  18625,    26.363636,   6.66666651,         -10.
  18626,    27.272728,   6.66666651,         -10.
  18627,    28.181818,   6.66666651,         -10.
  18628,     29.09091,   6.66666651,         -10.
  18629,     20.90909,   5.83333349,         -10.
  18630,    21.818182,   5.83333349,         -10.
  18631,    22.727272,   5.83333349,         -10.
  18632,    23.636364,   5.83333349,         -10.
  18633,    24.545454,   5.83333349,         -10.
  18634,    25.454546,   5.83333349,         -10.
  18635,    26.363636,   5.83333349,         -10.
  18636,    27.272728,   5.83333349,         -10.
  18637,    28.181818,   5.83333349,         -10.
  18638,     29.09091,   5.83333349,         -10.
  18639,     20.90909,           5.,         -10.
  18640,    21.818182,           5.,         -10.
  18641,    22.727272,           5.,         -10.
  18642,    23.636364,           5.,         -10.
  18643,    24.545454,           5.,         -10.
  18644,    25.454546,           5.,         -10.
  18645,    26.363636,           5.,         -10.
  18646,    27.272728,           5.,         -10.
  18647,    28.181818,           5.,         -10.
  18648,     29.09091,           5.,         -10.
  18649,     20.90909,   4.16666651,         -10.
  18650,    21.818182,   4.16666651,         -10.
  18651,    22.727272,   4.16666651,         -10.
  18652,    23.636364,   4.16666651,         -10.
  18653,    24.545454,   4.16666651,         -10.
  18654,    25.454546,   4.16666651,         -10.
  18655,    26.363636,   4.16666651,         -10.
  18656,    27.272728,   4.16666651,         -10.
  18657,    28.181818,   4.16666651,         -10.
  18658,     29.09091,   4.16666651,         -10.
  18659,     20.90909,   3.33333325,         -10.
  18660,    21.818182,   3.33333325,         -10.
  18661,    22.727272,   3.33333325,         -10.
  18662,    23.636364,   3.33333325,         -10.
  18663,    24.545454,   3.33333325,         -10.
  18664,    25.454546,   3.33333325,         -10.
  18665,    26.363636,   3.33333325,         -10.
  18666,    27.272728,   3.33333325,         -10.
  18667,    28.181818,   3.33333325,         -10.
  18668,     29.09091,   3.33333325,         -10.
  18669,     20.90909,          2.5,         -10.
  18670,    21.818182,          2.5,         -10.
  18671,    22.727272,          2.5,         -10.
  18672,    23.636364,          2.5,         -10.
  18673,    24.545454,          2.5,         -10.
  18674,    25.454546,          2.5,         -10.
  18675,    26.363636,          2.5,         -10.
  18676,    27.272728,          2.5,         -10.
  18677,    28.181818,          2.5,         -10.
  18678,     29.09091,          2.5,         -10.
  18679,     20.90909,   1.66666663,         -10.
  18680,    21.818182,   1.66666663,         -10.
  18681,    22.727272,   1.66666663,         -10.
  18682,    23.636364,   1.66666663,         -10.
  18683,    24.545454,   1.66666663,         -10.
  18684,    25.454546,   1.66666663,         -10.
  18685,    26.363636,   1.66666663,         -10.
  18686,    27.272728,   1.66666663,         -10.
  18687,    28.181818,   1.66666663,         -10.
  18688,     29.09091,   1.66666663,         -10.
  18689,     20.90909,  0.833333313,         -10.
  18690,    21.818182,  0.833333313,         -10.
  18691,    22.727272,  0.833333313,         -10.
  18692,    23.636364,  0.833333313,         -10.
  18693,    24.545454,  0.833333313,         -10.
  18694,    25.454546,  0.833333313,         -10.
  18695,    26.363636,  0.833333313,         -10.
  18696,    27.272728,  0.833333313,         -10.
  18697,    28.181818,  0.833333313,         -10.
  18698,     29.09091,  0.833333313,         -10.
  18699,          20.,   9.16666698,    -9.090909
  18700,          20.,   8.33333302,    -9.090909
  18701,          20.,          7.5,    -9.090909
  18702,          20.,   6.66666651,    -9.090909
  18703,          20.,   5.83333349,    -9.090909
  18704,          20.,           5.,    -9.090909
  18705,          20.,   4.16666651,    -9.090909
  18706,          20.,   3.33333325,    -9.090909
  18707,          20.,          2.5,    -9.090909
  18708,          20.,   1.66666663,    -9.090909
  18709,          20.,  0.833333313,    -9.090909
  18710,          20.,   9.16666698,  -8.18181801
  18711,          20.,   8.33333302,  -8.18181801
  18712,          20.,          7.5,  -8.18181801
  18713,          20.,   6.66666651,  -8.18181801
  18714,          20.,   5.83333349,  -8.18181801
  18715,          20.,           5.,  -8.18181801
  18716,          20.,   4.16666651,  -8.18181801
  18717,          20.,   3.33333325,  -8.18181801
  18718,          20.,          2.5,  -8.18181801
  18719,          20.,   1.66666663,  -8.18181801
  18720,          20.,  0.833333313,  -8.18181801
  18721,          20.,   9.16666698,  -7.27272749
  18722,          20.,   8.33333302,  -7.27272749
  18723,          20.,          7.5,  -7.27272749
  18724,          20.,   6.66666651,  -7.27272749
  18725,          20.,   5.83333349,  -7.27272749
  18726,          20.,           5.,  -7.27272749
  18727,          20.,   4.16666651,  -7.27272749
  18728,          20.,   3.33333325,  -7.27272749
  18729,          20.,          2.5,  -7.27272749
  18730,          20.,   1.66666663,  -7.27272749
  18731,          20.,  0.833333313,  -7.27272749
  18732,          20.,   9.16666698,  -6.36363649
  18733,          20.,   8.33333302,  -6.36363649
  18734,          20.,          7.5,  -6.36363649
  18735,          20.,   6.66666651,  -6.36363649
  18736,          20.,   5.83333349,  -6.36363649
  18737,          20.,           5.,  -6.36363649
  18738,          20.,   4.16666651,  -6.36363649
  18739,          20.,   3.33333325,  -6.36363649
  18740,          20.,          2.5,  -6.36363649
  18741,          20.,   1.66666663,  -6.36363649
  18742,          20.,  0.833333313,  -6.36363649
  18743,          20.,   9.16666698,   -5.4545455
  18744,          20.,   8.33333302,   -5.4545455
  18745,          20.,          7.5,   -5.4545455
  18746,          20.,   6.66666651,   -5.4545455
  18747,          20.,   5.83333349,   -5.4545455
  18748,          20.,           5.,   -5.4545455
  18749,          20.,   4.16666651,   -5.4545455
  18750,          20.,   3.33333325,   -5.4545455
  18751,          20.,          2.5,   -5.4545455
  18752,          20.,   1.66666663,   -5.4545455
  18753,          20.,  0.833333313,   -5.4545455
  18754,          20.,   9.16666698,   -4.5454545
  18755,          20.,   8.33333302,   -4.5454545
  18756,          20.,          7.5,   -4.5454545
  18757,          20.,   6.66666651,   -4.5454545
  18758,          20.,   5.83333349,   -4.5454545
  18759,          20.,           5.,   -4.5454545
  18760,          20.,   4.16666651,   -4.5454545
  18761,          20.,   3.33333325,   -4.5454545
  18762,          20.,          2.5,   -4.5454545
  18763,          20.,   1.66666663,   -4.5454545
  18764,          20.,  0.833333313,   -4.5454545
  18765,          20.,   9.16666698,  -3.63636374
  18766,          20.,   8.33333302,  -3.63636374
  18767,          20.,          7.5,  -3.63636374
  18768,          20.,   6.66666651,  -3.63636374
  18769,          20.,   5.83333349,  -3.63636374
  18770,          20.,           5.,  -3.63636374
  18771,          20.,   4.16666651,  -3.63636374
  18772,          20.,   3.33333325,  -3.63636374
  18773,          20.,          2.5,  -3.63636374
  18774,          20.,   1.66666663,  -3.63636374
  18775,          20.,  0.833333313,  -3.63636374
  18776,          20.,   9.16666698,  -2.72727275
  18777,          20.,   8.33333302,  -2.72727275
  18778,          20.,          7.5,  -2.72727275
  18779,          20.,   6.66666651,  -2.72727275
  18780,          20.,   5.83333349,  -2.72727275
  18781,          20.,           5.,  -2.72727275
  18782,          20.,   4.16666651,  -2.72727275
  18783,          20.,   3.33333325,  -2.72727275
  18784,          20.,          2.5,  -2.72727275
  18785,          20.,   1.66666663,  -2.72727275
  18786,          20.,  0.833333313,  -2.72727275
  18787,          20.,   9.16666698,  -1.81818187
  18788,          20.,   8.33333302,  -1.81818187
  18789,          20.,          7.5,  -1.81818187
  18790,          20.,   6.66666651,  -1.81818187
  18791,          20.,   5.83333349,  -1.81818187
  18792,          20.,           5.,  -1.81818187
  18793,          20.,   4.16666651,  -1.81818187
  18794,          20.,   3.33333325,  -1.81818187
  18795,          20.,          2.5,  -1.81818187
  18796,          20.,   1.66666663,  -1.81818187
  18797,          20.,  0.833333313,  -1.81818187
  18798,          20.,   9.16666698, -0.909090936
  18799,          20.,   8.33333302, -0.909090936
  18800,          20.,          7.5, -0.909090936
  18801,          20.,   6.66666651, -0.909090936
  18802,          20.,   5.83333349, -0.909090936
  18803,          20.,           5., -0.909090936
  18804,          20.,   4.16666651, -0.909090936
  18805,          20.,   3.33333325, -0.909090936
  18806,          20.,          2.5, -0.909090936
  18807,          20.,   1.66666663, -0.909090936
  18808,          20.,  0.833333313, -0.909090936
  18809,          30.,   9.16666698,    -9.090909
  18810,          30.,   8.33333302,    -9.090909
  18811,          30.,          7.5,    -9.090909
  18812,          30.,   6.66666651,    -9.090909
  18813,          30.,   5.83333349,    -9.090909
  18814,          30.,           5.,    -9.090909
  18815,          30.,   4.16666651,    -9.090909
  18816,          30.,   3.33333325,    -9.090909
  18817,          30.,          2.5,    -9.090909
  18818,          30.,   1.66666663,    -9.090909
  18819,          30.,  0.833333313,    -9.090909
  18820,          30.,   9.16666698,  -8.18181801
  18821,          30.,   8.33333302,  -8.18181801
  18822,          30.,          7.5,  -8.18181801
  18823,          30.,   6.66666651,  -8.18181801
  18824,          30.,   5.83333349,  -8.18181801
  18825,          30.,           5.,  -8.18181801
  18826,          30.,   4.16666651,  -8.18181801
  18827,          30.,   3.33333325,  -8.18181801
  18828,          30.,          2.5,  -8.18181801
  18829,          30.,   1.66666663,  -8.18181801
  18830,          30.,  0.833333313,  -8.18181801
  18831,          30.,   9.16666698,  -7.27272749
  18832,          30.,   8.33333302,  -7.27272749
  18833,          30.,          7.5,  -7.27272749
  18834,          30.,   6.66666651,  -7.27272749
  18835,          30.,   5.83333349,  -7.27272749
  18836,          30.,           5.,  -7.27272749
  18837,          30.,   4.16666651,  -7.27272749
  18838,          30.,   3.33333325,  -7.27272749
  18839,          30.,          2.5,  -7.27272749
  18840,          30.,   1.66666663,  -7.27272749
  18841,          30.,  0.833333313,  -7.27272749
  18842,          30.,   9.16666698,  -6.36363649
  18843,          30.,   8.33333302,  -6.36363649
  18844,          30.,          7.5,  -6.36363649
  18845,          30.,   6.66666651,  -6.36363649
  18846,          30.,   5.83333349,  -6.36363649
  18847,          30.,           5.,  -6.36363649
  18848,          30.,   4.16666651,  -6.36363649
  18849,          30.,   3.33333325,  -6.36363649
  18850,          30.,          2.5,  -6.36363649
  18851,          30.,   1.66666663,  -6.36363649
  18852,          30.,  0.833333313,  -6.36363649
  18853,          30.,   9.16666698,   -5.4545455
  18854,          30.,   8.33333302,   -5.4545455
  18855,          30.,          7.5,   -5.4545455
  18856,          30.,   6.66666651,   -5.4545455
  18857,          30.,   5.83333349,   -5.4545455
  18858,          30.,           5.,   -5.4545455
  18859,          30.,   4.16666651,   -5.4545455
  18860,          30.,   3.33333325,   -5.4545455
  18861,          30.,          2.5,   -5.4545455
  18862,          30.,   1.66666663,   -5.4545455
  18863,          30.,  0.833333313,   -5.4545455
  18864,          30.,   9.16666698,   -4.5454545
  18865,          30.,   8.33333302,   -4.5454545
  18866,          30.,          7.5,   -4.5454545
  18867,          30.,   6.66666651,   -4.5454545
  18868,          30.,   5.83333349,   -4.5454545
  18869,          30.,           5.,   -4.5454545
  18870,          30.,   4.16666651,   -4.5454545
  18871,          30.,   3.33333325,   -4.5454545
  18872,          30.,          2.5,   -4.5454545
  18873,          30.,   1.66666663,   -4.5454545
  18874,          30.,  0.833333313,   -4.5454545
  18875,          30.,   9.16666698,  -3.63636374
  18876,          30.,   8.33333302,  -3.63636374
  18877,          30.,          7.5,  -3.63636374
  18878,          30.,   6.66666651,  -3.63636374
  18879,          30.,   5.83333349,  -3.63636374
  18880,          30.,           5.,  -3.63636374
  18881,          30.,   4.16666651,  -3.63636374
  18882,          30.,   3.33333325,  -3.63636374
  18883,          30.,          2.5,  -3.63636374
  18884,          30.,   1.66666663,  -3.63636374
  18885,          30.,  0.833333313,  -3.63636374
  18886,          30.,   9.16666698,  -2.72727275
  18887,          30.,   8.33333302,  -2.72727275
  18888,          30.,          7.5,  -2.72727275
  18889,          30.,   6.66666651,  -2.72727275
  18890,          30.,   5.83333349,  -2.72727275
  18891,          30.,           5.,  -2.72727275
  18892,          30.,   4.16666651,  -2.72727275
  18893,          30.,   3.33333325,  -2.72727275
  18894,          30.,          2.5,  -2.72727275
  18895,          30.,   1.66666663,  -2.72727275
  18896,          30.,  0.833333313,  -2.72727275
  18897,          30.,   9.16666698,  -1.81818187
  18898,          30.,   8.33333302,  -1.81818187
  18899,          30.,          7.5,  -1.81818187
  18900,          30.,   6.66666651,  -1.81818187
  18901,          30.,   5.83333349,  -1.81818187
  18902,          30.,           5.,  -1.81818187
  18903,          30.,   4.16666651,  -1.81818187
  18904,          30.,   3.33333325,  -1.81818187
  18905,          30.,          2.5,  -1.81818187
  18906,          30.,   1.66666663,  -1.81818187
  18907,          30.,  0.833333313,  -1.81818187
  18908,          30.,   9.16666698, -0.909090936
  18909,          30.,   8.33333302, -0.909090936
  18910,          30.,          7.5, -0.909090936
  18911,          30.,   6.66666651, -0.909090936
  18912,          30.,   5.83333349, -0.909090936
  18913,          30.,           5., -0.909090936
  18914,          30.,   4.16666651, -0.909090936
  18915,          30.,   3.33333325, -0.909090936
  18916,          30.,          2.5, -0.909090936
  18917,          30.,   1.66666663, -0.909090936
  18918,          30.,  0.833333313, -0.909090936
  18919,     20.90909,           0.,    -9.090909
  18920,    21.818182,           0.,    -9.090909
  18921,    22.727272,           0.,    -9.090909
  18922,    23.636364,           0.,    -9.090909
  18923,    24.545454,           0.,    -9.090909
  18924,    25.454546,           0.,    -9.090909
  18925,    26.363636,           0.,    -9.090909
  18926,    27.272728,           0.,    -9.090909
  18927,    28.181818,           0.,    -9.090909
  18928,     29.09091,           0.,    -9.090909
  18929,     20.90909,           0.,  -8.18181801
  18930,    21.818182,           0.,  -8.18181801
  18931,    22.727272,           0.,  -8.18181801
  18932,    23.636364,           0.,  -8.18181801
  18933,    24.545454,           0.,  -8.18181801
  18934,    25.454546,           0.,  -8.18181801
  18935,    26.363636,           0.,  -8.18181801
  18936,    27.272728,           0.,  -8.18181801
  18937,    28.181818,           0.,  -8.18181801
  18938,     29.09091,           0.,  -8.18181801
  18939,     20.90909,           0.,  -7.27272749
  18940,    21.818182,           0.,  -7.27272749
  18941,    22.727272,           0.,  -7.27272749
  18942,    23.636364,           0.,  -7.27272749
  18943,    24.545454,           0.,  -7.27272749
  18944,    25.454546,           0.,  -7.27272749
  18945,    26.363636,           0.,  -7.27272749
  18946,    27.272728,           0.,  -7.27272749
  18947,    28.181818,           0.,  -7.27272749
  18948,     29.09091,           0.,  -7.27272749
  18949,     20.90909,           0.,  -6.36363649
  18950,    21.818182,           0.,  -6.36363649
  18951,    22.727272,           0.,  -6.36363649
  18952,    23.636364,           0.,  -6.36363649
  18953,    24.545454,           0.,  -6.36363649
  18954,    25.454546,           0.,  -6.36363649
  18955,    26.363636,           0.,  -6.36363649
  18956,    27.272728,           0.,  -6.36363649
  18957,    28.181818,           0.,  -6.36363649
  18958,     29.09091,           0.,  -6.36363649
  18959,     20.90909,           0.,   -5.4545455
  18960,    21.818182,           0.,   -5.4545455
  18961,    22.727272,           0.,   -5.4545455
  18962,    23.636364,           0.,   -5.4545455
  18963,    24.545454,           0.,   -5.4545455
  18964,    25.454546,           0.,   -5.4545455
  18965,    26.363636,           0.,   -5.4545455
  18966,    27.272728,           0.,   -5.4545455
  18967,    28.181818,           0.,   -5.4545455
  18968,     29.09091,           0.,   -5.4545455
  18969,     20.90909,           0.,   -4.5454545
  18970,    21.818182,           0.,   -4.5454545
  18971,    22.727272,           0.,   -4.5454545
  18972,    23.636364,           0.,   -4.5454545
  18973,    24.545454,           0.,   -4.5454545
  18974,    25.454546,           0.,   -4.5454545
  18975,    26.363636,           0.,   -4.5454545
  18976,    27.272728,           0.,   -4.5454545
  18977,    28.181818,           0.,   -4.5454545
  18978,     29.09091,           0.,   -4.5454545
  18979,     20.90909,           0.,  -3.63636374
  18980,    21.818182,           0.,  -3.63636374
  18981,    22.727272,           0.,  -3.63636374
  18982,    23.636364,           0.,  -3.63636374
  18983,    24.545454,           0.,  -3.63636374
  18984,    25.454546,           0.,  -3.63636374
  18985,    26.363636,           0.,  -3.63636374
  18986,    27.272728,           0.,  -3.63636374
  18987,    28.181818,           0.,  -3.63636374
  18988,     29.09091,           0.,  -3.63636374
  18989,     20.90909,           0.,  -2.72727275
  18990,    21.818182,           0.,  -2.72727275
  18991,    22.727272,           0.,  -2.72727275
  18992,    23.636364,           0.,  -2.72727275
  18993,    24.545454,           0.,  -2.72727275
  18994,    25.454546,           0.,  -2.72727275
  18995,    26.363636,           0.,  -2.72727275
  18996,    27.272728,           0.,  -2.72727275
  18997,    28.181818,           0.,  -2.72727275
  18998,     29.09091,           0.,  -2.72727275
  18999,     20.90909,           0.,  -1.81818187
  19000,    21.818182,           0.,  -1.81818187
  19001,    22.727272,           0.,  -1.81818187
  19002,    23.636364,           0.,  -1.81818187
  19003,    24.545454,           0.,  -1.81818187
  19004,    25.454546,           0.,  -1.81818187
  19005,    26.363636,           0.,  -1.81818187
  19006,    27.272728,           0.,  -1.81818187
  19007,    28.181818,           0.,  -1.81818187
  19008,     29.09091,           0.,  -1.81818187
  19009,     20.90909,           0., -0.909090936
  19010,    21.818182,           0., -0.909090936
  19011,    22.727272,           0., -0.909090936
  19012,    23.636364,           0., -0.909090936
  19013,    24.545454,           0., -0.909090936
  19014,    25.454546,           0., -0.909090936
  19015,    26.363636,           0., -0.909090936
  19016,    27.272728,           0., -0.909090936
  19017,    28.181818,           0., -0.909090936
  19018,     29.09091,           0., -0.909090936
  19019,    -29.09091,  0.833333313,         -10.
  19020,   -28.181818,  0.833333313,         -10.
  19021,   -27.272728,  0.833333313,         -10.
  19022,   -26.363636,  0.833333313,         -10.
  19023,   -25.454546,  0.833333313,         -10.
  19024,   -24.545454,  0.833333313,         -10.
  19025,   -23.636364,  0.833333313,         -10.
  19026,   -22.727272,  0.833333313,         -10.
  19027,   -21.818182,  0.833333313,         -10.
  19028,    -20.90909,  0.833333313,         -10.
  19029,    -29.09091,   1.66666663,         -10.
  19030,   -28.181818,   1.66666663,         -10.
  19031,   -27.272728,   1.66666663,         -10.
  19032,   -26.363636,   1.66666663,         -10.
  19033,   -25.454546,   1.66666663,         -10.
  19034,   -24.545454,   1.66666663,         -10.
  19035,   -23.636364,   1.66666663,         -10.
  19036,   -22.727272,   1.66666663,         -10.
  19037,   -21.818182,   1.66666663,         -10.
  19038,    -20.90909,   1.66666663,         -10.
  19039,    -29.09091,          2.5,         -10.
  19040,   -28.181818,          2.5,         -10.
  19041,   -27.272728,          2.5,         -10.
  19042,   -26.363636,          2.5,         -10.
  19043,   -25.454546,          2.5,         -10.
  19044,   -24.545454,          2.5,         -10.
  19045,   -23.636364,          2.5,         -10.
  19046,   -22.727272,          2.5,         -10.
  19047,   -21.818182,          2.5,         -10.
  19048,    -20.90909,          2.5,         -10.
  19049,    -29.09091,   3.33333325,         -10.
  19050,   -28.181818,   3.33333325,         -10.
  19051,   -27.272728,   3.33333325,         -10.
  19052,   -26.363636,   3.33333325,         -10.
  19053,   -25.454546,   3.33333325,         -10.
  19054,   -24.545454,   3.33333325,         -10.
  19055,   -23.636364,   3.33333325,         -10.
  19056,   -22.727272,   3.33333325,         -10.
  19057,   -21.818182,   3.33333325,         -10.
  19058,    -20.90909,   3.33333325,         -10.
  19059,    -29.09091,   4.16666651,         -10.
  19060,   -28.181818,   4.16666651,         -10.
  19061,   -27.272728,   4.16666651,         -10.
  19062,   -26.363636,   4.16666651,         -10.
  19063,   -25.454546,   4.16666651,         -10.
  19064,   -24.545454,   4.16666651,         -10.
  19065,   -23.636364,   4.16666651,         -10.
  19066,   -22.727272,   4.16666651,         -10.
  19067,   -21.818182,   4.16666651,         -10.
  19068,    -20.90909,   4.16666651,         -10.
  19069,    -29.09091,           5.,         -10.
  19070,   -28.181818,           5.,         -10.
  19071,   -27.272728,           5.,         -10.
  19072,   -26.363636,           5.,         -10.
  19073,   -25.454546,           5.,         -10.
  19074,   -24.545454,           5.,         -10.
  19075,   -23.636364,           5.,         -10.
  19076,   -22.727272,           5.,         -10.
  19077,   -21.818182,           5.,         -10.
  19078,    -20.90909,           5.,         -10.
  19079,    -29.09091,   5.83333349,         -10.
  19080,   -28.181818,   5.83333349,         -10.
  19081,   -27.272728,   5.83333349,         -10.
  19082,   -26.363636,   5.83333349,         -10.
  19083,   -25.454546,   5.83333349,         -10.
  19084,   -24.545454,   5.83333349,         -10.
  19085,   -23.636364,   5.83333349,         -10.
  19086,   -22.727272,   5.83333349,         -10.
  19087,   -21.818182,   5.83333349,         -10.
  19088,    -20.90909,   5.83333349,         -10.
  19089,    -29.09091,   6.66666651,         -10.
  19090,   -28.181818,   6.66666651,         -10.
  19091,   -27.272728,   6.66666651,         -10.
  19092,   -26.363636,   6.66666651,         -10.
  19093,   -25.454546,   6.66666651,         -10.
  19094,   -24.545454,   6.66666651,         -10.
  19095,   -23.636364,   6.66666651,         -10.
  19096,   -22.727272,   6.66666651,         -10.
  19097,   -21.818182,   6.66666651,         -10.
  19098,    -20.90909,   6.66666651,         -10.
  19099,    -29.09091,          7.5,         -10.
  19100,   -28.181818,          7.5,         -10.
  19101,   -27.272728,          7.5,         -10.
  19102,   -26.363636,          7.5,         -10.
  19103,   -25.454546,          7.5,         -10.
  19104,   -24.545454,          7.5,         -10.
  19105,   -23.636364,          7.5,         -10.
  19106,   -22.727272,          7.5,         -10.
  19107,   -21.818182,          7.5,         -10.
  19108,    -20.90909,          7.5,         -10.
  19109,    -29.09091,   8.33333302,         -10.
  19110,   -28.181818,   8.33333302,         -10.
  19111,   -27.272728,   8.33333302,         -10.
  19112,   -26.363636,   8.33333302,         -10.
  19113,   -25.454546,   8.33333302,         -10.
  19114,   -24.545454,   8.33333302,         -10.
  19115,   -23.636364,   8.33333302,         -10.
  19116,   -22.727272,   8.33333302,         -10.
  19117,   -21.818182,   8.33333302,         -10.
  19118,    -20.90909,   8.33333302,         -10.
  19119,    -29.09091,   9.16666698,         -10.
  19120,   -28.181818,   9.16666698,         -10.
  19121,   -27.272728,   9.16666698,         -10.
  19122,   -26.363636,   9.16666698,         -10.
  19123,   -25.454546,   9.16666698,         -10.
  19124,   -24.545454,   9.16666698,         -10.
  19125,   -23.636364,   9.16666698,         -10.
  19126,   -22.727272,   9.16666698,         -10.
  19127,   -21.818182,   9.16666698,         -10.
  19128,    -20.90909,   9.16666698,         -10.
  19129,         -30.,  0.833333313, -0.909090936
  19130,         -30.,   1.66666663, -0.909090936
  19131,         -30.,          2.5, -0.909090936
  19132,         -30.,   3.33333325, -0.909090936
  19133,         -30.,   4.16666651, -0.909090936
  19134,         -30.,           5., -0.909090936
  19135,         -30.,   5.83333349, -0.909090936
  19136,         -30.,   6.66666651, -0.909090936
  19137,         -30.,          7.5, -0.909090936
  19138,         -30.,   8.33333302, -0.909090936
  19139,         -30.,   9.16666698, -0.909090936
  19140,         -30.,  0.833333313,  -1.81818187
  19141,         -30.,   1.66666663,  -1.81818187
  19142,         -30.,          2.5,  -1.81818187
  19143,         -30.,   3.33333325,  -1.81818187
  19144,         -30.,   4.16666651,  -1.81818187
  19145,         -30.,           5.,  -1.81818187
  19146,         -30.,   5.83333349,  -1.81818187
  19147,         -30.,   6.66666651,  -1.81818187
  19148,         -30.,          7.5,  -1.81818187
  19149,         -30.,   8.33333302,  -1.81818187
  19150,         -30.,   9.16666698,  -1.81818187
  19151,         -30.,  0.833333313,  -2.72727275
  19152,         -30.,   1.66666663,  -2.72727275
  19153,         -30.,          2.5,  -2.72727275
  19154,         -30.,   3.33333325,  -2.72727275
  19155,         -30.,   4.16666651,  -2.72727275
  19156,         -30.,           5.,  -2.72727275
  19157,         -30.,   5.83333349,  -2.72727275
  19158,         -30.,   6.66666651,  -2.72727275
  19159,         -30.,          7.5,  -2.72727275
  19160,         -30.,   8.33333302,  -2.72727275
  19161,         -30.,   9.16666698,  -2.72727275
  19162,         -30.,  0.833333313,  -3.63636374
  19163,         -30.,   1.66666663,  -3.63636374
  19164,         -30.,          2.5,  -3.63636374
  19165,         -30.,   3.33333325,  -3.63636374
  19166,         -30.,   4.16666651,  -3.63636374
  19167,         -30.,           5.,  -3.63636374
  19168,         -30.,   5.83333349,  -3.63636374
  19169,         -30.,   6.66666651,  -3.63636374
  19170,         -30.,          7.5,  -3.63636374
  19171,         -30.,   8.33333302,  -3.63636374
  19172,         -30.,   9.16666698,  -3.63636374
  19173,         -30.,  0.833333313,   -4.5454545
  19174,         -30.,   1.66666663,   -4.5454545
  19175,         -30.,          2.5,   -4.5454545
  19176,         -30.,   3.33333325,   -4.5454545
  19177,         -30.,   4.16666651,   -4.5454545
  19178,         -30.,           5.,   -4.5454545
  19179,         -30.,   5.83333349,   -4.5454545
  19180,         -30.,   6.66666651,   -4.5454545
  19181,         -30.,          7.5,   -4.5454545
  19182,         -30.,   8.33333302,   -4.5454545
  19183,         -30.,   9.16666698,   -4.5454545
  19184,         -30.,  0.833333313,   -5.4545455
  19185,         -30.,   1.66666663,   -5.4545455
  19186,         -30.,          2.5,   -5.4545455
  19187,         -30.,   3.33333325,   -5.4545455
  19188,         -30.,   4.16666651,   -5.4545455
  19189,         -30.,           5.,   -5.4545455
  19190,         -30.,   5.83333349,   -5.4545455
  19191,         -30.,   6.66666651,   -5.4545455
  19192,         -30.,          7.5,   -5.4545455
  19193,         -30.,   8.33333302,   -5.4545455
  19194,         -30.,   9.16666698,   -5.4545455
  19195,         -30.,  0.833333313,  -6.36363649
  19196,         -30.,   1.66666663,  -6.36363649
  19197,         -30.,          2.5,  -6.36363649
  19198,         -30.,   3.33333325,  -6.36363649
  19199,         -30.,   4.16666651,  -6.36363649
  19200,         -30.,           5.,  -6.36363649
  19201,         -30.,   5.83333349,  -6.36363649
  19202,         -30.,   6.66666651,  -6.36363649
  19203,         -30.,          7.5,  -6.36363649
  19204,         -30.,   8.33333302,  -6.36363649
  19205,         -30.,   9.16666698,  -6.36363649
  19206,         -30.,  0.833333313,  -7.27272749
  19207,         -30.,   1.66666663,  -7.27272749
  19208,         -30.,          2.5,  -7.27272749
  19209,         -30.,   3.33333325,  -7.27272749
  19210,         -30.,   4.16666651,  -7.27272749
  19211,         -30.,           5.,  -7.27272749
  19212,         -30.,   5.83333349,  -7.27272749
  19213,         -30.,   6.66666651,  -7.27272749
  19214,         -30.,          7.5,  -7.27272749
  19215,         -30.,   8.33333302,  -7.27272749
  19216,         -30.,   9.16666698,  -7.27272749
  19217,         -30.,  0.833333313,  -8.18181801
  19218,         -30.,   1.66666663,  -8.18181801
  19219,         -30.,          2.5,  -8.18181801
  19220,         -30.,   3.33333325,  -8.18181801
  19221,         -30.,   4.16666651,  -8.18181801
  19222,         -30.,           5.,  -8.18181801
  19223,         -30.,   5.83333349,  -8.18181801
  19224,         -30.,   6.66666651,  -8.18181801
  19225,         -30.,          7.5,  -8.18181801
  19226,         -30.,   8.33333302,  -8.18181801
  19227,         -30.,   9.16666698,  -8.18181801
  19228,         -30.,  0.833333313,    -9.090909
  19229,         -30.,   1.66666663,    -9.090909
  19230,         -30.,          2.5,    -9.090909
  19231,         -30.,   3.33333325,    -9.090909
  19232,         -30.,   4.16666651,    -9.090909
  19233,         -30.,           5.,    -9.090909
  19234,         -30.,   5.83333349,    -9.090909
  19235,         -30.,   6.66666651,    -9.090909
  19236,         -30.,          7.5,    -9.090909
  19237,         -30.,   8.33333302,    -9.090909
  19238,         -30.,   9.16666698,    -9.090909
  19239,         -20.,  0.833333313, -0.909090936
  19240,         -20.,   1.66666663, -0.909090936
  19241,         -20.,          2.5, -0.909090936
  19242,         -20.,   3.33333325, -0.909090936
  19243,         -20.,   4.16666651, -0.909090936
  19244,         -20.,           5., -0.909090936
  19245,         -20.,   5.83333349, -0.909090936
  19246,         -20.,   6.66666651, -0.909090936
  19247,         -20.,          7.5, -0.909090936
  19248,         -20.,   8.33333302, -0.909090936
  19249,         -20.,   9.16666698, -0.909090936
  19250,         -20.,  0.833333313,  -1.81818187
  19251,         -20.,   1.66666663,  -1.81818187
  19252,         -20.,          2.5,  -1.81818187
  19253,         -20.,   3.33333325,  -1.81818187
  19254,         -20.,   4.16666651,  -1.81818187
  19255,         -20.,           5.,  -1.81818187
  19256,         -20.,   5.83333349,  -1.81818187
  19257,         -20.,   6.66666651,  -1.81818187
  19258,         -20.,          7.5,  -1.81818187
  19259,         -20.,   8.33333302,  -1.81818187
  19260,         -20.,   9.16666698,  -1.81818187
  19261,         -20.,  0.833333313,  -2.72727275
  19262,         -20.,   1.66666663,  -2.72727275
  19263,         -20.,          2.5,  -2.72727275
  19264,         -20.,   3.33333325,  -2.72727275
  19265,         -20.,   4.16666651,  -2.72727275
  19266,         -20.,           5.,  -2.72727275
  19267,         -20.,   5.83333349,  -2.72727275
  19268,         -20.,   6.66666651,  -2.72727275
  19269,         -20.,          7.5,  -2.72727275
  19270,         -20.,   8.33333302,  -2.72727275
  19271,         -20.,   9.16666698,  -2.72727275
  19272,         -20.,  0.833333313,  -3.63636374
  19273,         -20.,   1.66666663,  -3.63636374
  19274,         -20.,          2.5,  -3.63636374
  19275,         -20.,   3.33333325,  -3.63636374
  19276,         -20.,   4.16666651,  -3.63636374
  19277,         -20.,           5.,  -3.63636374
  19278,         -20.,   5.83333349,  -3.63636374
  19279,         -20.,   6.66666651,  -3.63636374
  19280,         -20.,          7.5,  -3.63636374
  19281,         -20.,   8.33333302,  -3.63636374
  19282,         -20.,   9.16666698,  -3.63636374
  19283,         -20.,  0.833333313,   -4.5454545
  19284,         -20.,   1.66666663,   -4.5454545
  19285,         -20.,          2.5,   -4.5454545
  19286,         -20.,   3.33333325,   -4.5454545
  19287,         -20.,   4.16666651,   -4.5454545
  19288,         -20.,           5.,   -4.5454545
  19289,         -20.,   5.83333349,   -4.5454545
  19290,         -20.,   6.66666651,   -4.5454545
  19291,         -20.,          7.5,   -4.5454545
  19292,         -20.,   8.33333302,   -4.5454545
  19293,         -20.,   9.16666698,   -4.5454545
  19294,         -20.,  0.833333313,   -5.4545455
  19295,         -20.,   1.66666663,   -5.4545455
  19296,         -20.,          2.5,   -5.4545455
  19297,         -20.,   3.33333325,   -5.4545455
  19298,         -20.,   4.16666651,   -5.4545455
  19299,         -20.,           5.,   -5.4545455
  19300,         -20.,   5.83333349,   -5.4545455
  19301,         -20.,   6.66666651,   -5.4545455
  19302,         -20.,          7.5,   -5.4545455
  19303,         -20.,   8.33333302,   -5.4545455
  19304,         -20.,   9.16666698,   -5.4545455
  19305,         -20.,  0.833333313,  -6.36363649
  19306,         -20.,   1.66666663,  -6.36363649
  19307,         -20.,          2.5,  -6.36363649
  19308,         -20.,   3.33333325,  -6.36363649
  19309,         -20.,   4.16666651,  -6.36363649
  19310,         -20.,           5.,  -6.36363649
  19311,         -20.,   5.83333349,  -6.36363649
  19312,         -20.,   6.66666651,  -6.36363649
  19313,         -20.,          7.5,  -6.36363649
  19314,         -20.,   8.33333302,  -6.36363649
  19315,         -20.,   9.16666698,  -6.36363649
  19316,         -20.,  0.833333313,  -7.27272749
  19317,         -20.,   1.66666663,  -7.27272749
  19318,         -20.,          2.5,  -7.27272749
  19319,         -20.,   3.33333325,  -7.27272749
  19320,         -20.,   4.16666651,  -7.27272749
  19321,         -20.,           5.,  -7.27272749
  19322,         -20.,   5.83333349,  -7.27272749
  19323,         -20.,   6.66666651,  -7.27272749
  19324,         -20.,          7.5,  -7.27272749
  19325,         -20.,   8.33333302,  -7.27272749
  19326,         -20.,   9.16666698,  -7.27272749
  19327,         -20.,  0.833333313,  -8.18181801
  19328,         -20.,   1.66666663,  -8.18181801
  19329,         -20.,          2.5,  -8.18181801
  19330,         -20.,   3.33333325,  -8.18181801
  19331,         -20.,   4.16666651,  -8.18181801
  19332,         -20.,           5.,  -8.18181801
  19333,         -20.,   5.83333349,  -8.18181801
  19334,         -20.,   6.66666651,  -8.18181801
  19335,         -20.,          7.5,  -8.18181801
  19336,         -20.,   8.33333302,  -8.18181801
  19337,         -20.,   9.16666698,  -8.18181801
  19338,         -20.,  0.833333313,    -9.090909
  19339,         -20.,   1.66666663,    -9.090909
  19340,         -20.,          2.5,    -9.090909
  19341,         -20.,   3.33333325,    -9.090909
  19342,         -20.,   4.16666651,    -9.090909
  19343,         -20.,           5.,    -9.090909
  19344,         -20.,   5.83333349,    -9.090909
  19345,         -20.,   6.66666651,    -9.090909
  19346,         -20.,          7.5,    -9.090909
  19347,         -20.,   8.33333302,    -9.090909
  19348,         -20.,   9.16666698,    -9.090909
  19349,    -29.09091,           0., -0.909090936
  19350,   -28.181818,           0., -0.909090936
  19351,   -27.272728,           0., -0.909090936
  19352,   -26.363636,           0., -0.909090936
  19353,   -25.454546,           0., -0.909090936
  19354,   -24.545454,           0., -0.909090936
  19355,   -23.636364,           0., -0.909090936
  19356,   -22.727272,           0., -0.909090936
  19357,   -21.818182,           0., -0.909090936
  19358,    -20.90909,           0., -0.909090936
  19359,    -29.09091,           0.,  -1.81818187
  19360,   -28.181818,           0.,  -1.81818187
  19361,   -27.272728,           0.,  -1.81818187
  19362,   -26.363636,           0.,  -1.81818187
  19363,   -25.454546,           0.,  -1.81818187
  19364,   -24.545454,           0.,  -1.81818187
  19365,   -23.636364,           0.,  -1.81818187
  19366,   -22.727272,           0.,  -1.81818187
  19367,   -21.818182,           0.,  -1.81818187
  19368,    -20.90909,           0.,  -1.81818187
  19369,    -29.09091,           0.,  -2.72727275
  19370,   -28.181818,           0.,  -2.72727275
  19371,   -27.272728,           0.,  -2.72727275
  19372,   -26.363636,           0.,  -2.72727275
  19373,   -25.454546,           0.,  -2.72727275
  19374,   -24.545454,           0.,  -2.72727275
  19375,   -23.636364,           0.,  -2.72727275
  19376,   -22.727272,           0.,  -2.72727275
  19377,   -21.818182,           0.,  -2.72727275
  19378,    -20.90909,           0.,  -2.72727275
  19379,    -29.09091,           0.,  -3.63636374
  19380,   -28.181818,           0.,  -3.63636374
  19381,   -27.272728,           0.,  -3.63636374
  19382,   -26.363636,           0.,  -3.63636374
  19383,   -25.454546,           0.,  -3.63636374
  19384,   -24.545454,           0.,  -3.63636374
  19385,   -23.636364,           0.,  -3.63636374
  19386,   -22.727272,           0.,  -3.63636374
  19387,   -21.818182,           0.,  -3.63636374
  19388,    -20.90909,           0.,  -3.63636374
  19389,    -29.09091,           0.,   -4.5454545
  19390,   -28.181818,           0.,   -4.5454545
  19391,   -27.272728,           0.,   -4.5454545
  19392,   -26.363636,           0.,   -4.5454545
  19393,   -25.454546,           0.,   -4.5454545
  19394,   -24.545454,           0.,   -4.5454545
  19395,   -23.636364,           0.,   -4.5454545
  19396,   -22.727272,           0.,   -4.5454545
  19397,   -21.818182,           0.,   -4.5454545
  19398,    -20.90909,           0.,   -4.5454545
  19399,    -29.09091,           0.,   -5.4545455
  19400,   -28.181818,           0.,   -5.4545455
  19401,   -27.272728,           0.,   -5.4545455
  19402,   -26.363636,           0.,   -5.4545455
  19403,   -25.454546,           0.,   -5.4545455
  19404,   -24.545454,           0.,   -5.4545455
  19405,   -23.636364,           0.,   -5.4545455
  19406,   -22.727272,           0.,   -5.4545455
  19407,   -21.818182,           0.,   -5.4545455
  19408,    -20.90909,           0.,   -5.4545455
  19409,    -29.09091,           0.,  -6.36363649
  19410,   -28.181818,           0.,  -6.36363649
  19411,   -27.272728,           0.,  -6.36363649
  19412,   -26.363636,           0.,  -6.36363649
  19413,   -25.454546,           0.,  -6.36363649
  19414,   -24.545454,           0.,  -6.36363649
  19415,   -23.636364,           0.,  -6.36363649
  19416,   -22.727272,           0.,  -6.36363649
  19417,   -21.818182,           0.,  -6.36363649
  19418,    -20.90909,           0.,  -6.36363649
  19419,    -29.09091,           0.,  -7.27272749
  19420,   -28.181818,           0.,  -7.27272749
  19421,   -27.272728,           0.,  -7.27272749
  19422,   -26.363636,           0.,  -7.27272749
  19423,   -25.454546,           0.,  -7.27272749
  19424,   -24.545454,           0.,  -7.27272749
  19425,   -23.636364,           0.,  -7.27272749
  19426,   -22.727272,           0.,  -7.27272749
  19427,   -21.818182,           0.,  -7.27272749
  19428,    -20.90909,           0.,  -7.27272749
  19429,    -29.09091,           0.,  -8.18181801
  19430,   -28.181818,           0.,  -8.18181801
  19431,   -27.272728,           0.,  -8.18181801
  19432,   -26.363636,           0.,  -8.18181801
  19433,   -25.454546,           0.,  -8.18181801
  19434,   -24.545454,           0.,  -8.18181801
  19435,   -23.636364,           0.,  -8.18181801
  19436,   -22.727272,           0.,  -8.18181801
  19437,   -21.818182,           0.,  -8.18181801
  19438,    -20.90909,           0.,  -8.18181801
  19439,    -29.09091,           0.,    -9.090909
  19440,   -28.181818,           0.,    -9.090909
  19441,   -27.272728,           0.,    -9.090909
  19442,   -26.363636,           0.,    -9.090909
  19443,   -25.454546,           0.,    -9.090909
  19444,   -24.545454,           0.,    -9.090909
  19445,   -23.636364,           0.,    -9.090909
  19446,   -22.727272,           0.,    -9.090909
  19447,   -21.818182,           0.,    -9.090909
  19448,    -20.90909,           0.,    -9.090909
  19449,    -29.09091,          10., -0.909090936
  19450,   -28.181818,          10., -0.909090936
  19451,   -27.272728,          10., -0.909090936
  19452,   -26.363636,          10., -0.909090936
  19453,   -25.454546,          10., -0.909090936
  19454,   -24.545454,          10., -0.909090936
  19455,   -23.636364,          10., -0.909090936
  19456,   -22.727272,          10., -0.909090936
  19457,   -21.818182,          10., -0.909090936
  19458,    -20.90909,          10., -0.909090936
  19459,    -29.09091,          10.,  -1.81818187
  19460,   -28.181818,          10.,  -1.81818187
  19461,   -27.272728,          10.,  -1.81818187
  19462,   -26.363636,          10.,  -1.81818187
  19463,   -25.454546,          10.,  -1.81818187
  19464,   -24.545454,          10.,  -1.81818187
  19465,   -23.636364,          10.,  -1.81818187
  19466,   -22.727272,          10.,  -1.81818187
  19467,   -21.818182,          10.,  -1.81818187
  19468,    -20.90909,          10.,  -1.81818187
  19469,    -29.09091,          10.,  -2.72727275
  19470,   -28.181818,          10.,  -2.72727275
  19471,   -27.272728,          10.,  -2.72727275
  19472,   -26.363636,          10.,  -2.72727275
  19473,   -25.454546,          10.,  -2.72727275
  19474,   -24.545454,          10.,  -2.72727275
  19475,   -23.636364,          10.,  -2.72727275
  19476,   -22.727272,          10.,  -2.72727275
  19477,   -21.818182,          10.,  -2.72727275
  19478,    -20.90909,          10.,  -2.72727275
  19479,    -29.09091,          10.,  -3.63636374
  19480,   -28.181818,          10.,  -3.63636374
  19481,   -27.272728,          10.,  -3.63636374
  19482,   -26.363636,          10.,  -3.63636374
  19483,   -25.454546,          10.,  -3.63636374
  19484,   -24.545454,          10.,  -3.63636374
  19485,   -23.636364,          10.,  -3.63636374
  19486,   -22.727272,          10.,  -3.63636374
  19487,   -21.818182,          10.,  -3.63636374
  19488,    -20.90909,          10.,  -3.63636374
  19489,    -29.09091,          10.,   -4.5454545
  19490,   -28.181818,          10.,   -4.5454545
  19491,   -27.272728,          10.,   -4.5454545
  19492,   -26.363636,          10.,   -4.5454545
  19493,   -25.454546,          10.,   -4.5454545
  19494,   -24.545454,          10.,   -4.5454545
  19495,   -23.636364,          10.,   -4.5454545
  19496,   -22.727272,          10.,   -4.5454545
  19497,   -21.818182,          10.,   -4.5454545
  19498,    -20.90909,          10.,   -4.5454545
  19499,    -29.09091,          10.,   -5.4545455
  19500,   -28.181818,          10.,   -5.4545455
  19501,   -27.272728,          10.,   -5.4545455
  19502,   -26.363636,          10.,   -5.4545455
  19503,   -25.454546,          10.,   -5.4545455
  19504,   -24.545454,          10.,   -5.4545455
  19505,   -23.636364,          10.,   -5.4545455
  19506,   -22.727272,          10.,   -5.4545455
  19507,   -21.818182,          10.,   -5.4545455
  19508,    -20.90909,          10.,   -5.4545455
  19509,    -29.09091,          10.,  -6.36363649
  19510,   -28.181818,          10.,  -6.36363649
  19511,   -27.272728,          10.,  -6.36363649
  19512,   -26.363636,          10.,  -6.36363649
  19513,   -25.454546,          10.,  -6.36363649
  19514,   -24.545454,          10.,  -6.36363649
  19515,   -23.636364,          10.,  -6.36363649
  19516,   -22.727272,          10.,  -6.36363649
  19517,   -21.818182,          10.,  -6.36363649
  19518,    -20.90909,          10.,  -6.36363649
  19519,    -29.09091,          10.,  -7.27272749
  19520,   -28.181818,          10.,  -7.27272749
  19521,   -27.272728,          10.,  -7.27272749
  19522,   -26.363636,          10.,  -7.27272749
  19523,   -25.454546,          10.,  -7.27272749
  19524,   -24.545454,          10.,  -7.27272749
  19525,   -23.636364,          10.,  -7.27272749
  19526,   -22.727272,          10.,  -7.27272749
  19527,   -21.818182,          10.,  -7.27272749
  19528,    -20.90909,          10.,  -7.27272749
  19529,    -29.09091,          10.,  -8.18181801
  19530,   -28.181818,          10.,  -8.18181801
  19531,   -27.272728,          10.,  -8.18181801
  19532,   -26.363636,          10.,  -8.18181801
  19533,   -25.454546,          10.,  -8.18181801
  19534,   -24.545454,          10.,  -8.18181801
  19535,   -23.636364,          10.,  -8.18181801
  19536,   -22.727272,          10.,  -8.18181801
  19537,   -21.818182,          10.,  -8.18181801
  19538,    -20.90909,          10.,  -8.18181801
  19539,    -29.09091,          10.,    -9.090909
  19540,   -28.181818,          10.,    -9.090909
  19541,   -27.272728,          10.,    -9.090909
  19542,   -26.363636,          10.,    -9.090909
  19543,   -25.454546,          10.,    -9.090909
  19544,   -24.545454,          10.,    -9.090909
  19545,   -23.636364,          10.,    -9.090909
  19546,   -22.727272,          10.,    -9.090909
  19547,   -21.818182,          10.,    -9.090909
  19548,    -20.90909,          10.,    -9.090909
  19549,    -27.65909,       14.375,         -10.
  19550,   -27.068182,       14.375,         -10.
  19551,   -26.477272,       14.375,         -10.
  19552,   -25.886364,       14.375,         -10.
  19553,   -25.295454,       14.375,         -10.
  19554,   -24.704546,       14.375,         -10.
  19555,   -24.113636,       14.375,         -10.
  19556,   -23.522728,       14.375,         -10.
  19557,   -22.931818,       14.375,         -10.
  19558,    -22.34091,       14.375,         -10.
  19559,   -27.863636,        13.75,         -10.
  19560,   -27.227272,        13.75,         -10.
  19561,    -26.59091,        13.75,         -10.
  19562,   -25.954546,        13.75,         -10.
  19563,   -25.318182,        13.75,         -10.
  19564,   -24.681818,        13.75,         -10.
  19565,   -24.045454,        13.75,         -10.
  19566,    -23.40909,        13.75,         -10.
  19567,   -22.772728,        13.75,         -10.
  19568,   -22.136364,        13.75,         -10.
  19569,   -28.068182,       13.125,         -10.
  19570,   -27.386364,       13.125,         -10.
  19571,   -26.704546,       13.125,         -10.
  19572,   -26.022728,       13.125,         -10.
  19573,    -25.34091,       13.125,         -10.
  19574,    -24.65909,       13.125,         -10.
  19575,   -23.977272,       13.125,         -10.
  19576,   -23.295454,       13.125,         -10.
  19577,   -22.613636,       13.125,         -10.
  19578,   -21.931818,       13.125,         -10.
  19579,   -28.272728,         12.5,         -10.
  19580,   -27.545454,         12.5,         -10.
  19581,   -26.818182,         12.5,         -10.
  19582,    -26.09091,         12.5,         -10.
  19583,   -25.363636,         12.5,         -10.
  19584,   -24.636364,         12.5,         -10.
  19585,    -23.90909,         12.5,         -10.
  19586,   -23.181818,         12.5,         -10.
  19587,   -22.454546,         12.5,         -10.
  19588,   -21.727272,         12.5,         -10.
  19589,   -28.477272,       11.875,         -10.
  19590,   -27.704546,       11.875,         -10.
  19591,   -26.931818,       11.875,         -10.
  19592,    -26.15909,       11.875,         -10.
  19593,   -25.386364,       11.875,         -10.
  19594,   -24.613636,       11.875,         -10.
  19595,    -23.84091,       11.875,         -10.
  19596,   -23.068182,       11.875,         -10.
  19597,   -22.295454,       11.875,         -10.
  19598,   -21.522728,       11.875,         -10.
  19599,   -28.681818,        11.25,         -10.
  19600,   -27.863636,        11.25,         -10.
  19601,   -27.045454,        11.25,         -10.
  19602,   -26.227272,        11.25,         -10.
  19603,    -25.40909,        11.25,         -10.
  19604,    -24.59091,        11.25,         -10.
  19605,   -23.772728,        11.25,         -10.
  19606,   -22.954546,        11.25,         -10.
  19607,   -22.136364,        11.25,         -10.
  19608,   -21.318182,        11.25,         -10.
  19609,   -28.886364,       10.625,         -10.
  19610,   -28.022728,       10.625,         -10.
  19611,    -27.15909,       10.625,         -10.
  19612,   -26.295454,       10.625,         -10.
  19613,   -25.431818,       10.625,         -10.
  19614,   -24.568182,       10.625,         -10.
  19615,   -23.704546,       10.625,         -10.
  19616,    -22.84091,       10.625,         -10.
  19617,   -21.977272,       10.625,         -10.
  19618,   -21.113636,       10.625,         -10.
  19619,  -27.7628613,   14.0579224,  -4.91044712
  19620,  -27.1488914,   14.0579224,  -4.91044712
  19621,  -26.5349236,   14.0579224,  -4.91044712
  19622,  -25.9209538,   14.0579224,  -4.91044712
  19623,  -25.3069839,   14.0579224,  -4.91044712
  19624,  -24.6930141,   14.0579224,  -4.91044712
  19625,  -24.0790462,   14.0579224,  -4.91044712
  19626,  -23.4650764,   14.0579214,  -4.91044664
  19627,  -22.8511066,   14.0579214,  -4.91044664
  19628,  -22.2371387,   14.0579214,  -4.91044664
  19629,  -28.0615292,   13.1453285,  -4.64329576
  19630,  -27.3811893,   13.1453285,  -4.64329576
  19631,  -26.7008495,   13.1453285,  -4.64329576
  19632,  -26.0205097,   13.1453276,  -4.64329529
  19633,  -25.3401699,   13.1453276,  -4.64329529
  19634,  -24.6598301,   13.1453276,  -4.64329529
  19635,  -23.9794903,   13.1453276,  -4.64329529
  19636,  -23.2991505,   13.1453276,  -4.64329529
  19637,  -22.6188107,   13.1453276,  -4.64329529
  19638,  -21.9384708,   13.1453266,  -4.64329481
  19639,  -28.3406601,   12.2924242,  -4.20345497
  19640,  -27.5982914,   12.2924242,  -4.20345497
  19641,  -26.8559227,   12.2924242,  -4.20345497
  19642,   -26.113554,   12.2924242,  -4.20345497
  19643,  -25.3711853,   12.2924242,  -4.20345497
  19644,  -24.6288147,   12.2924242,  -4.20345497
  19645,   -23.886446,   12.2924242,  -4.20345497
  19646,  -23.1440773,   12.2924242,  -4.20345497
  19647,  -22.4017086,   12.2924242,  -4.20345497
  19648,   -21.659338,   12.2924242,  -4.20345497
  19649,  -28.5900097,   11.5305252,  -3.60038137
  19650,  -27.7922306,   11.5305252,  -3.60038137
  19651,  -26.9944496,   11.5305252,  -3.60038137
  19652,  -26.1966705,   11.5305252,  -3.60038137
  19653,  -25.3988895,   11.5305252,  -3.60038114
  19654,  -24.6011105,   11.5305252,  -3.60038114
  19655,  -23.8033295,   11.5305252,  -3.60038114
  19656,  -23.0055504,   11.5305252,  -3.60038114
  19657,  -22.2077694,   11.5305252,  -3.60038114
  19658,  -21.4099903,   11.5305252,  -3.60038114
  19659,  -28.7990932,   10.8916578,   -2.8498292
  19660,  -27.9548512,   10.8916578,   -2.8498292
  19661,  -27.1106071,   10.8916578,   -2.8498292
  19662,  -26.2663651,   10.8916578,   -2.8498292
  19663,   -25.422121,   10.8916578,   -2.8498292
  19664,   -24.577879,   10.8916578,   -2.8498292
  19665,  -23.7336349,   10.8916578,   -2.8498292
  19666,  -22.8893929,   10.8916578,   -2.8498292
  19667,  -22.0451488,   10.8916578,   -2.8498292
  19668,  -21.2009068,   10.8916578,   -2.8498292
  19669,  -28.9577293,   10.4069366,  -1.97579575
  19670,  -28.0782337,   10.4069366,  -1.97579587
  19671,  -27.1987381,   10.4069366,  -1.97579598
  19672,  -26.3192425,   10.4069366,   -1.9757961
  19673,  -25.4397488,   10.4069366,   -1.9757961
  19674,  -24.5602531,   10.4069366,  -1.97579622
  19675,  -23.6807575,   10.4069366,  -1.97579634
  19676,  -22.8012619,   10.4069366,  -1.97579646
  19677,  -21.9217663,   10.4069366,  -1.97579658
  19678,  -21.0422707,   10.4069366,  -1.97579682
  19679,  -29.0570583,   10.1034355,  -1.01175714
  19680,   -28.155489,   10.1034355,  -1.01175725
  19681,  -27.2539215,   10.1034355,  -1.01175749
  19682,  -26.3523521,   10.1034355,  -1.01175761
  19683,  -25.4507847,   10.1034355,  -1.01175773
  19684,  -24.5492153,   10.1034355,  -1.01175797
  19685,  -23.6476479,   10.1034355,  -1.01175809
  19686,  -22.7460785,   10.1034355,  -1.01175833
  19687,   -21.844511,   10.1034355,  -1.01175857
  19688,  -20.9429417,   10.1034355,  -1.01175869
  19689,  -28.2615299,   14.3461752,  -9.53731346
  19690,  -28.5219879,   13.6950302,  -9.51302719
  19691,  -28.7802753,   13.0493116,  -9.47304153
  19692,  -29.0352535,   12.4118662,  -9.41821671
  19693,  -29.2857571,   11.7856054,  -9.34998417
  19694,  -29.5306568,    11.173358,  -9.27052689
  19695,  -29.7689667,   10.5775852,  -9.18288708
  19696,  -28.2730598,   14.3173494,  -9.07462692
  19697,  -28.5439758,   13.6400595,  -9.02605343
  19698,  -28.8105507,   12.9736223,  -8.94608307
  19699,   -29.070507,   12.3237324,  -8.83643341
  19700,   -29.321516,   11.6962109,  -8.69996929
  19701,  -29.5613136,   11.0967159,  -8.54105377
  19702,  -29.7879314,   10.5301704,  -8.36577415
  19703,  -28.2845898,   14.2885246,  -8.61194038
  19704,  -28.5659637,   13.5850897,  -8.53908062
  19705,   -28.840826,    12.897934,   -8.4191246
  19706,  -29.1057606,   12.2355976,  -8.25464916
  19707,  -29.3572731,   11.6068163,  -8.04995346
  19708,  -29.5919704,   11.0200739,  -7.81158066
  19709,  -29.8068981,   10.4827547,  -7.54866076
  19710,  -28.2961197,   14.2596989,  -8.14925385
  19711,  -28.5879517,   13.5301199,  -8.05210781
  19712,  -28.8711014,   12.8222456,  -7.89216566
  19713,  -29.1410141,   12.1474638,  -7.67286587
  19714,  -29.3930321,   11.5174208,  -7.39993811
  19715,  -29.6226273,   10.9434319,  -7.08210754
  19716,  -29.8258648,   10.4353399,  -6.73154783
  19717,  -28.3076496,   14.2308741,  -7.68656683
  19718,  -28.6099396,   13.4751492,  -7.56513453
  19719,  -28.9013767,   12.7465563,  -7.36520672
  19720,  -29.1762676,     12.05933,  -7.09108257
  19721,  -29.4287891,   11.4280262,  -6.74992228
  19722,  -29.6532841,   10.8667889,  -6.35263443
  19723,  -29.8448296,   10.3879251,  -5.91443491
  19724,  -28.3191795,   14.2020493,  -7.22388029
  19725,  -28.6319275,   13.4201794,  -7.07816124
  19726,  -28.9316521,   12.6708679,  -6.83824825
  19727,  -29.2115211,   11.9711962,   -6.5092988
  19728,  -29.4645481,   11.3386316,  -6.09990692
  19729,  -29.6839409,   10.7901468,  -5.62316132
  19730,  -29.8637962,   10.3405104,  -5.09732199
  19731,  -28.3307114,   14.1732235,  -6.76119375
  19732,  -28.6539154,   13.3652096,  -6.59118795
  19733,  -28.9619274,   12.5951796,  -6.31128979
  19734,  -29.2467747,   11.8830614,  -5.92751551
  19735,  -29.5003052,   11.2492371,  -5.44989109
  19736,  -29.7145977,   10.7135048,   -4.8936882
  19737,  -29.8827629,   10.2930946,  -4.28020906
  19738,  -28.3422413,   14.1443987,  -6.29850721
  19739,  -28.6759052,   13.3102388,  -6.10421515
  19740,  -28.9922047,   12.5194902,  -5.78433084
  19741,  -29.2820282,   11.7949276,  -5.34573221
  19742,  -29.5360622,   11.1598425,  -4.79987574
  19743,  -29.7452545,   10.6368628,  -4.16421509
  19744,  -29.9017277,   10.2456799,   -3.4630959
  19745,  -28.3537712,   14.1155729,   -5.8358202
  19746,  -28.6978931,   13.2552691,  -5.61724186
  19747,    -29.02248,   12.4438019,  -5.25737238
  19748,  -29.3172817,   11.7067938,  -4.76394844
  19749,  -29.5718212,   11.0704479,  -4.14986038
  19750,  -29.7759113,   10.5602207,  -3.43474174
  19751,  -29.9206944,   10.1982651,  -2.64598274
  19752,  -28.3653011,   14.0867481,  -5.37313366
  19753,  -28.7198811,   13.2002983,  -5.13026857
  19754,  -29.0527554,   12.3681135,  -4.73041391
  19755,  -29.3525352,     11.61866,  -4.18216515
  19756,  -29.6075783,   10.9810524,  -3.49984479
  19757,  -29.8065681,   10.4835787,  -2.70526862
  19758,  -29.9396591,   10.1508503,  -1.82886982
  19759,  -21.7384701,   14.3461742,  -9.53731346
  19760,  -21.4780121,   13.6950293,  -9.51302719
  19761,  -21.2197247,   13.0493116,  -9.47304153
  19762,  -20.9647465,   12.4118662,  -9.41821671
  19763,  -20.7142429,   11.7856054,  -9.34998417
  19764,  -20.4693432,    11.173358,  -9.27052689
  19765,  -20.2310333,   10.5775852,  -9.18288708
  19766,  -21.7269402,   14.3173494,  -9.07462692
  19767,  -21.4560242,   13.6400595,  -9.02605343
  19768,  -21.1894493,   12.9736223,  -8.94608307
  19769,   -20.929493,   12.3237314,  -8.83643246
  19770,   -20.678484,   11.6962109,  -8.69996929
  19771,  -20.4386864,   11.0967159,  -8.54105377
  19772,  -20.2120686,   10.5301704,  -8.36577415
  19773,  -21.7154102,   14.2885237,  -8.61194038
  19774,  -21.4340363,   13.5850887,  -8.53908062
  19775,   -21.159174,    12.897934,  -8.41912365
  19776,  -20.8942394,   12.2355976,  -8.25464916
  19777,  -20.6427269,   11.6068163,  -8.04995346
  19778,  -20.4080296,   11.0200739,  -7.81158113
  19779,  -20.1931019,   10.4827547,  -7.54866171
  19780,  -21.7038803,   14.2596989,  -8.14925385
  19781,  -21.4120483,   13.5301189,  -8.05210686
  19782,  -21.1288986,   12.8222446,  -7.89216518
  19783,  -20.8589859,   12.1474638,  -7.67286587
  19784,  -20.6069679,   11.5174208,  -7.39993811
  19785,  -20.3773727,   10.9434319,  -7.08210802
  19786,  -20.1741352,   10.4353399,  -6.73154879
  19787,  -21.6923485,   14.2308731,  -7.68656683
  19788,  -21.3900585,   13.4751482,  -7.56513405
  19789,  -21.0986233,   12.7465563,  -7.36520672
  19790,  -20.8237324,    12.059329,   -7.0910821
  19791,  -20.5712109,   11.4280262,  -6.74992228
  19792,  -20.3467159,   10.8667898,  -6.35263491
  19793,  -20.1551704,   10.3879251,  -5.91443586
  19794,  -21.6808186,   14.2020483,  -7.22388029
  19795,  -21.3680706,   13.4201784,  -7.07816076
  19796,  -21.0683479,   12.6708679,  -6.83824778
  19797,  -20.7884789,   11.9711952,   -6.5092988
  19798,  -20.5354519,   11.3386316,  -6.09990692
  19799,  -20.3160591,   10.7901478,  -5.62316179
  19800,  -20.1362038,   10.3405104,  -5.09732294
  19801,  -21.6692886,   14.1732225,  -6.76119328
  19802,  -21.3460827,   13.3652077,  -6.59118748
  19803,  -21.0380707,   12.5951786,  -6.31128931
  19804,  -20.7532253,   11.8830614,  -5.92751503
  19805,  -20.4996948,   11.2492371,  -5.44989157
  19806,  -20.2854023,   10.7135057,  -4.89368916
  19807,   -20.117239,   10.2930956,  -4.28021002
  19808,  -21.6577587,   14.1443977,  -6.29850674
  19809,  -21.3240948,   13.3102379,  -6.10421467
  19810,  -21.0077953,   12.5194902,  -5.78433037
  19811,  -20.7179718,   11.7949276,  -5.34573174
  19812,  -20.4639378,   11.1598425,  -4.79987574
  19813,  -20.2547455,   10.6368637,  -4.16421604
  19814,  -20.0982723,   10.2456808,  -3.46309733
  19815,  -21.6462288,    14.115572,   -5.8358202
  19816,  -21.3021069,   13.2552671,  -5.61724138
  19817,    -20.97752,   12.4438009,   -5.2573719
  19818,  -20.6827164,   11.7067928,  -4.76394796
  19819,  -20.4281788,   11.0704479,  -4.14986038
  19820,  -20.2240887,   10.5602217,  -3.43474293
  19821,  -20.0793056,   10.1982651,  -2.64598465
  19822,  -21.6346989,   14.0867462,  -5.37313366
  19823,  -21.2801189,   13.2002974,   -5.1302681
  19824,  -20.9472446,   12.3681126,  -4.73041344
  19825,  -20.6474628,    11.618659,  -4.18216419
  19826,  -20.3924217,   10.9810534,  -3.49984503
  19827,  -20.1934319,   10.4835796,  -2.70527005
  19828,  -20.0603409,   10.1508503,  -1.82887173
  19829,   20.9208965,   20.7211208, -0.909090936
  19830,    21.841795,   20.7211208, -0.909090936
  19831,   22.7626915,   20.7211208, -0.909090936
  19832,   23.6835899,   20.7211208, -0.909090936
  19833,   24.6044865,   20.7211208, -0.909090936
  19834,    25.525383,   20.7211208, -0.909090936
  19835,   26.4203072,   20.7211208, -0.909090936
  19836,   27.3152313,   20.7211208, -0.909090936
  19837,   28.2101536,   20.7211208, -0.909090936
  19838,   29.1050758,   20.7211208, -0.909090936
  19839,    20.932703,   21.4422417, -0.909090936
  19840,   21.8654079,   21.4422417, -0.909090936
  19841,    22.798111,   21.4422417, -0.909090936
  19842,    23.730814,   21.4422417, -0.909090936
  19843,   24.6635189,   21.4422417, -0.909090936
  19844,   25.5962219,   21.4422417, -0.909090936
  19845,   26.4769783,   21.4422417, -0.909090936
  19846,   27.3577328,   21.4422417, -0.909090936
  19847,   28.2384892,   21.4422417, -0.909090936
  19848,   29.1192436,   21.4422417, -0.909090936
  19849,   20.9445095,   22.1633625, -0.909090936
  19850,   21.8890209,   22.1633625, -0.909090936
  19851,   22.8335304,   22.1633625, -0.909090936
  19852,   23.7780399,   22.1633625, -0.909090936
  19853,   24.7225494,   22.1633625, -0.909090936
  19854,   25.6670609,   22.1633625, -0.909090936
  19855,   26.5336475,   22.1633625, -0.909090936
  19856,   27.4002361,   22.1633625, -0.909090936
  19857,   28.2668228,   22.1633625, -0.909090936
  19858,   29.1334133,   22.1633625, -0.909090936
  19859,    20.956316,   22.8844833, -0.909090936
  19860,    21.912632,   22.8844833, -0.909090936
  19861,   22.8689499,   22.8844833, -0.909090936
  19862,   23.8252659,   22.8844833, -0.909090936
  19863,   24.7815819,   22.8844833, -0.909090936
  19864,   25.7378979,   22.8844833, -0.909090936
  19865,   26.5903187,   22.8844833, -0.909090936
  19866,   27.4427395,   22.8844833, -0.909090936
  19867,   28.2951603,   22.8844833, -0.909090936
  19868,   29.1475792,   22.8844833, -0.909090936
  19869,   20.9681225,   23.6056042, -0.909090936
  19870,    21.936245,   23.6056042, -0.909090936
  19871,   22.9043674,   23.6056042, -0.909090936
  19872,   23.8724918,   23.6056042, -0.909090936
  19873,   24.8406143,   23.6056042, -0.909090936
  19874,   25.8087368,   23.6056042, -0.909090936
  19875,   26.6469898,   23.6056042, -0.909090936
  19876,   27.4852409,   23.6056042, -0.909090936
  19877,    28.323494,   23.6056042, -0.909090936
  19878,    29.161747,   23.6056042, -0.909090936
  19879,    20.979929,    24.326725, -0.909090936
  19880,   21.9598579,    24.326725, -0.909090936
  19881,   22.9397869,    24.326725, -0.909090936
  19882,   23.9197159,    24.326725, -0.909090936
  19883,   24.8996449,    24.326725, -0.909090936
  19884,   25.8795738,    24.326725, -0.909090936
  19885,    26.703661,    24.326725, -0.909090936
  19886,   27.5277462,    24.326725, -0.909090936
  19887,   28.3518295,    24.326725, -0.909090936
  19888,   29.1759148,    24.326725, -0.909090936
  19889,   20.9917355,   25.0478477, -0.909090936
  19890,   21.9834709,   25.0478477, -0.909090936
  19891,   22.9752064,   25.0478477, -0.909090936
  19892,   23.9669418,   25.0478477, -0.909090936
  19893,   24.9586773,   25.0478477, -0.909090936
  19894,   25.9504128,   25.0478477, -0.909090936
  19895,   26.7603302,   25.0478477, -0.909090936
  19896,   27.5702477,   25.0478477, -0.909090936
  19897,   28.3801651,   25.0478477, -0.909090936
  19898,   29.1900826,   25.0478477, -0.909090936
  19899,   20.9917355,   25.8468895, -0.909090936
  19900,   21.9834709,   25.8468895, -0.909090936
  19901,   22.9752064,   25.8468895, -0.909090936
  19902,   23.9669418,   25.8468895, -0.909090936
  19903,   24.9586773,   25.8468895, -0.909090936
  19904,   25.9504128,   25.8468895, -0.909090936
  19905,   26.7603302,   25.8468895, -0.909090936
  19906,   27.5702477,   25.8468895, -0.909090936
  19907,   28.3801651,   25.8468895, -0.909090936
  19908,   29.1900826,   25.8468895, -0.909090936
  19909,   20.9917355,   26.6459332, -0.909090936
  19910,   21.9834709,   26.6459332, -0.909090936
  19911,   22.9752064,   26.6459332, -0.909090936
  19912,   23.9669418,   26.6459332, -0.909090936
  19913,   24.9586773,   26.6459332, -0.909090936
  19914,   25.9504128,   26.6459332, -0.909090936
  19915,   26.7603302,   26.6459332, -0.909090936
  19916,   27.5702477,   26.6459332, -0.909090936
  19917,   28.3801651,   26.6459332, -0.909090936
  19918,   29.1900826,   26.6459332, -0.909090936
  19919,   20.9917355,   27.4449768, -0.909090936
  19920,   21.9834709,   27.4449768, -0.909090936
  19921,   22.9752064,   27.4449768, -0.909090936
  19922,   23.9669418,   27.4449768, -0.909090936
  19923,   24.9586773,   27.4449768, -0.909090936
  19924,   25.9504128,   27.4449768, -0.909090936
  19925,   26.7603302,   27.4449768, -0.909090936
  19926,   27.5702477,   27.4449768, -0.909090936
  19927,   28.3801651,   27.4449768, -0.909090936
  19928,   29.1900826,   27.4449768, -0.909090936
  19929,   20.9917355,   28.2440186, -0.909090936
  19930,   21.9834709,   28.2440186, -0.909090936
  19931,   22.9752064,   28.2440186, -0.909090936
  19932,   23.9669418,   28.2440186, -0.909090936
  19933,   24.9586773,   28.2440186, -0.909090936
  19934,   25.9504128,   28.2440186, -0.909090936
  19935,   26.7603302,   28.2440186, -0.909090936
  19936,   27.5702477,   28.2440186, -0.909090936
  19937,   28.3801651,   28.2440186, -0.909090936
  19938,   29.1900826,   28.2440186, -0.909090936
  19939,   20.9917355,   29.0430622, -0.909090936
  19940,   21.9834709,   29.0430622, -0.909090936
  19941,   22.9752064,   29.0430622, -0.909090936
  19942,   23.9669418,   29.0430622, -0.909090936
  19943,   24.9586773,   29.0430622, -0.909090936
  19944,   25.9504128,   29.0430622, -0.909090936
  19945,   26.7603302,   29.0430622, -0.909090936
  19946,   27.5702477,   29.0430622, -0.909090936
  19947,   28.3801651,   29.0430622, -0.909090936
  19948,   29.1900826,   29.0430622, -0.909090936
  19949,   20.9917355,   29.8421059, -0.909090936
  19950,   21.9834709,   29.8421059, -0.909090936
  19951,   22.9752064,   29.8421059, -0.909090936
  19952,   23.9669418,   29.8421059, -0.909090936
  19953,   24.9586773,   29.8421059, -0.909090936
  19954,   25.9504128,   29.8421059, -0.909090936
  19955,   26.7603302,   29.8421059, -0.909090936
  19956,   27.5702477,   29.8421059, -0.909090936
  19957,   28.3801651,   29.8421059, -0.909090936
  19958,   29.1900826,   29.8421059, -0.909090936
  19959,   20.9917355,   30.6411476, -0.909090936
  19960,   21.9834709,   30.6411476, -0.909090936
  19961,   22.9752064,   30.6411476, -0.909090936
  19962,   23.9669418,   30.6411476, -0.909090936
  19963,   24.9586773,   30.6411476, -0.909090936
  19964,   25.9504128,   30.6411476, -0.909090936
  19965,   26.7603302,   30.6411476, -0.909090936
  19966,   27.5702477,   30.6411476, -0.909090936
  19967,   28.3801651,   30.6411476, -0.909090936
  19968,   29.1900826,   30.6411476, -0.909090936
  19969,   20.9917355,   31.4401913, -0.909090936
  19970,   21.9834709,   31.4401913, -0.909090936
  19971,   22.9752064,   31.4401913, -0.909090936
  19972,   23.9669418,   31.4401913, -0.909090936
  19973,   24.9586773,   31.4401913, -0.909090936
  19974,   25.9504128,   31.4401913, -0.909090936
  19975,   26.7603302,   31.4401913, -0.909090936
  19976,   27.5702477,   31.4401913, -0.909090936
  19977,   28.3801651,   31.4401913, -0.909090936
  19978,   29.1900826,   31.4401913, -0.909090936
  19979,   20.9917355,   32.2392349, -0.909090936
  19980,   21.9834709,   32.2392349, -0.909090936
  19981,   22.9752064,   32.2392349, -0.909090936
  19982,   23.9669418,   32.2392349, -0.909090936
  19983,   24.9586773,   32.2392349, -0.909090936
  19984,   25.9504128,   32.2392349, -0.909090936
  19985,   26.7603302,   32.2392349, -0.909090936
  19986,   27.5702477,   32.2392349, -0.909090936
  19987,   28.3801651,   32.2392349, -0.909090936
  19988,   29.1900826,   32.2392349, -0.909090936
  19989,   20.9917355,   33.0382767, -0.909090936
  19990,   21.9834709,   33.0382767, -0.909090936
  19991,   22.9752064,   33.0382767, -0.909090936
  19992,   23.9669418,   33.0382767, -0.909090936
  19993,   24.9586773,   33.0382767, -0.909090936
  19994,   25.9504128,   33.0382767, -0.909090936
