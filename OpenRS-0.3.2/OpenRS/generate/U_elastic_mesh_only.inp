  27995,   25.5014095,   56.6872559,  -6.36363649
  27996,   26.3807697,   56.9178505,  -6.36363649
  27997,    27.260128,   57.1484489,  -6.36363649
  27998,   28.1394863,   57.3790436,  -6.36363649
  27999,    20.225256,    55.303688,  -7.27272749
  28000,   21.1046143,   55.5342827,  -7.27272749
  28001,   21.9839745,   55.7648773,  -7.27272749
  28002,   22.8633327,    55.995472,  -7.27272749
  28003,   23.7426929,   56.2260666,  -7.27272749
  28004,   24.6220512,   56.4566612,  -7.27272749
  28005,   25.5014095,   56.6872559,  -7.27272749
  28006,   26.3807697,   56.9178505,  -7.27272749
  28007,    27.260128,   57.1484489,  -7.27272749
  28008,   28.1394863,   57.3790436,  -7.27272749
  28009,    20.225256,    55.303688,  -8.18181801
  28010,   21.1046143,   55.5342827,  -8.18181801
  28011,   21.9839745,   55.7648773,  -8.18181801
  28012,   22.8633327,    55.995472,  -8.18181801
  28013,   23.7426929,   56.2260666,  -8.18181801
  28014,   24.6220512,   56.4566612,  -8.18181801
  28015,   25.5014095,   56.6872559,  -8.18181801
  28016,   26.3807697,   56.9178505,  -8.18181801
  28017,    27.260128,   57.1484489,  -8.18181801
  28018,   28.1394863,   57.3790436,  -8.18181801
  28019,    20.225256,    55.303688,    -9.090909
  28020,   21.1046143,   55.5342827,    -9.090909
  28021,   21.9839745,   55.7648773,    -9.090909
  28022,   22.8633327,    55.995472,    -9.090909
  28023,   23.7426929,   56.2260666,    -9.090909
  28024,   24.6220512,   56.4566612,    -9.090909
  28025,   25.5014095,   56.6872559,    -9.090909
  28026,   26.3807697,   56.9178505,    -9.090909
  28027,    27.260128,   57.1484489,    -9.090909
  28028,   28.1394863,   57.3790436,    -9.090909
  28029,   20.0448742,   55.9492149, -0.909090936
  28030,   20.9163895,   56.2078743, -0.909090936
  28031,   21.7879066,   56.4665375, -0.909090936
  28032,   22.6594219,   56.7251968, -0.909090936
  28033,   23.5309391,     56.98386, -0.909090936
  28034,   24.4024544,   57.2425194, -0.909090936
  28035,   25.2739716,   57.5011826, -0.909090936
  28036,   26.1454868,   57.7598419, -0.909090936
  28037,    27.017004,   58.0185051, -0.909090936
  28038,   27.8885193,   58.2771645, -0.909090936
  28039,   20.0448742,   55.9492149,  -1.81818187
  28040,   20.9163895,   56.2078743,  -1.81818187
  28041,   21.7879066,   56.4665375,  -1.81818187
  28042,   22.6594219,   56.7251968,  -1.81818187
  28043,   23.5309391,     56.98386,  -1.81818187
  28044,   24.4024544,   57.2425194,  -1.81818187
  28045,   25.2739716,   57.5011826,  -1.81818187
  28046,   26.1454868,   57.7598419,  -1.81818187
  28047,    27.017004,   58.0185051,  -1.81818187
  28048,   27.8885193,   58.2771645,  -1.81818187
  28049,   20.0448742,   55.9492149,  -2.72727275
  28050,   20.9163895,   56.2078743,  -2.72727275
  28051,   21.7879066,   56.4665375,  -2.72727275
  28052,   22.6594219,   56.7251968,  -2.72727275
  28053,   23.5309391,     56.98386,  -2.72727275
  28054,   24.4024544,   57.2425194,  -2.72727275
  28055,   25.2739716,   57.5011826,  -2.72727275
  28056,   26.1454868,   57.7598419,  -2.72727275
  28057,    27.017004,   58.0185051,  -2.72727275
  28058,   27.8885193,   58.2771645,  -2.72727275
  28059,   20.0448742,   55.9492149,  -3.63636374
  28060,   20.9163895,   56.2078743,  -3.63636374
  28061,   21.7879066,   56.4665375,  -3.63636374
  28062,   22.6594219,   56.7251968,  -3.63636374
  28063,   23.5309391,     56.98386,  -3.63636374
  28064,   24.4024544,   57.2425194,  -3.63636374
  28065,   25.2739716,   57.5011826,  -3.63636374
  28066,   26.1454868,   57.7598419,  -3.63636374
  28067,    27.017004,   58.0185051,  -3.63636374
  28068,   27.8885193,   58.2771645,  -3.63636374
  28069,   20.0448742,   55.9492149,   -4.5454545
  28070,   20.9163895,   56.2078743,   -4.5454545
  28071,   21.7879066,   56.4665375,   -4.5454545
  28072,   22.6594219,   56.7251968,   -4.5454545
  28073,   23.5309391,     56.98386,   -4.5454545
  28074,   24.4024544,   57.2425194,   -4.5454545
  28075,   25.2739716,   57.5011826,   -4.5454545
  28076,   26.1454868,   57.7598419,   -4.5454545
  28077,    27.017004,   58.0185051,   -4.5454545
  28078,   27.8885193,   58.2771645,   -4.5454545
  28079,   20.0448742,   55.9492149,   -5.4545455
  28080,   20.9163895,   56.2078743,   -5.4545455
  28081,   21.7879066,   56.4665375,   -5.4545455
  28082,   22.6594219,   56.7251968,   -5.4545455
  28083,   23.5309391,     56.98386,   -5.4545455
  28084,   24.4024544,   57.2425194,   -5.4545455
  28085,   25.2739716,   57.5011826,   -5.4545455
  28086,   26.1454868,   57.7598419,   -5.4545455
  28087,    27.017004,   58.0185051,   -5.4545455
  28088,   27.8885193,   58.2771645,   -5.4545455
  28089,   20.0448742,   55.9492149,  -6.36363649
  28090,   20.9163895,   56.2078743,  -6.36363649
  28091,   21.7879066,   56.4665375,  -6.36363649
  28092,   22.6594219,   56.7251968,  -6.36363649
  28093,   23.5309391,     56.98386,  -6.36363649
  28094,   24.4024544,   57.2425194,  -6.36363649
  28095,   25.2739716,   57.5011826,  -6.36363649
  28096,   26.1454868,   57.7598419,  -6.36363649
  28097,    27.017004,   58.0185051,  -6.36363649
  28098,   27.8885193,   58.2771645,  -6.36363649
  28099,   20.0448742,   55.9492149,  -7.27272749
  28100,   20.9163895,   56.2078743,  -7.27272749
  28101,   21.7879066,   56.4665375,  -7.27272749
  28102,   22.6594219,   56.7251968,  -7.27272749
  28103,   23.5309391,     56.98386,  -7.27272749
  28104,   24.4024544,   57.2425194,  -7.27272749
  28105,   25.2739716,   57.5011826,  -7.27272749
  28106,   26.1454868,   57.7598419,  -7.27272749
  28107,    27.017004,   58.0185051,  -7.27272749
  28108,   27.8885193,   58.2771645,  -7.27272749
  28109,   20.0448742,   55.9492149,  -8.18181801
  28110,   20.9163895,   56.2078743,  -8.18181801
  28111,   21.7879066,   56.4665375,  -8.18181801
  28112,   22.6594219,   56.7251968,  -8.18181801
  28113,   23.5309391,     56.98386,  -8.18181801
  28114,   24.4024544,   57.2425194,  -8.18181801
  28115,   25.2739716,   57.5011826,  -8.18181801
  28116,   26.1454868,   57.7598419,  -8.18181801
  28117,    27.017004,   58.0185051,  -8.18181801
  28118,   27.8885193,   58.2771645,  -8.18181801
  28119,   20.0448742,   55.9492149,    -9.090909
  28120,   20.9163895,   56.2078743,    -9.090909
  28121,   21.7879066,   56.4665375,    -9.090909
  28122,   22.6594219,   56.7251968,    -9.090909
  28123,   23.5309391,     56.98386,    -9.090909
  28124,   24.4024544,   57.2425194,    -9.090909
  28125,   25.2739716,   57.5011826,    -9.090909
  28126,   26.1454868,   57.7598419,    -9.090909
  28127,    27.017004,   58.0185051,    -9.090909
  28128,   27.8885193,   58.2771645,    -9.090909
  28129,   19.8438931,   56.5886269, -0.909090936
  28130,   20.7066708,   56.8750877, -0.909090936
  28131,   21.5694485,   57.1615486, -0.909090936
  28132,   22.4322262,   57.4480133, -0.909090936
  28133,   23.2950039,   57.7344742, -0.909090936
  28134,   24.1577835,   58.0209351, -0.909090936
  28135,   25.0205612,   58.3073997, -0.909090936
  28136,   25.8833389,   58.5938606, -0.909090936
  28137,   26.7461166,   58.8803215, -0.909090936
  28138,   27.6088943,   59.1667862, -0.909090936
  28139,   19.8438931,   56.5886269,  -1.81818187
  28140,   20.7066708,   56.8750877,  -1.81818187
  28141,   21.5694485,   57.1615486,  -1.81818187
  28142,   22.4322262,   57.4480133,  -1.81818187
  28143,   23.2950039,   57.7344742,  -1.81818187
  28144,   24.1577835,   58.0209351,  -1.81818187
  28145,   25.0205612,   58.3073997,  -1.81818187
  28146,   25.8833389,   58.5938606,  -1.81818187
  28147,   26.7461166,   58.8803215,  -1.81818187
  28148,   27.6088943,   59.1667862,  -1.81818187
  28149,   19.8438931,   56.5886269,  -2.72727275
  28150,   20.7066708,   56.8750877,  -2.72727275
  28151,   21.5694485,   57.1615486,  -2.72727275
  28152,   22.4322262,   57.4480133,  -2.72727275
  28153,   23.2950039,   57.7344742,  -2.72727275
  28154,   24.1577835,   58.0209351,  -2.72727275
  28155,   25.0205612,   58.3073997,  -2.72727275
  28156,   25.8833389,   58.5938606,  -2.72727275
  28157,   26.7461166,   58.8803215,  -2.72727275
  28158,   27.6088943,   59.1667862,  -2.72727275
  28159,   19.8438931,   56.5886269,  -3.63636374
  28160,   20.7066708,   56.8750877,  -3.63636374
  28161,   21.5694485,   57.1615486,  -3.63636374
  28162,   22.4322262,   57.4480133,  -3.63636374
  28163,   23.2950039,   57.7344742,  -3.63636374
  28164,   24.1577835,   58.0209351,  -3.63636374
  28165,   25.0205612,   58.3073997,  -3.63636374
  28166,   25.8833389,   58.5938606,  -3.63636374
  28167,   26.7461166,   58.8803215,  -3.63636374
  28168,   27.6088943,   59.1667862,  -3.63636374
  28169,   19.8438931,   56.5886269,   -4.5454545
  28170,   20.7066708,   56.8750877,   -4.5454545
  28171,   21.5694485,   57.1615486,   -4.5454545
  28172,   22.4322262,   57.4480133,   -4.5454545
  28173,   23.2950039,   57.7344742,   -4.5454545
  28174,   24.1577835,   58.0209351,   -4.5454545
  28175,   25.0205612,   58.3073997,   -4.5454545
  28176,   25.8833389,   58.5938606,   -4.5454545
  28177,   26.7461166,   58.8803215,   -4.5454545
  28178,   27.6088943,   59.1667862,   -4.5454545
  28179,   19.8438931,   56.5886269,   -5.4545455
  28180,   20.7066708,   56.8750877,   -5.4545455
  28181,   21.5694485,   57.1615486,   -5.4545455
  28182,   22.4322262,   57.4480133,   -5.4545455
  28183,   23.2950039,   57.7344742,   -5.4545455
  28184,   24.1577835,   58.0209351,   -5.4545455
  28185,   25.0205612,   58.3073997,   -5.4545455
  28186,   25.8833389,   58.5938606,   -5.4545455
  28187,   26.7461166,   58.8803215,   -5.4545455
  28188,   27.6088943,   59.1667862,   -5.4545455
  28189,   19.8438931,   56.5886269,  -6.36363649
  28190,   20.7066708,   56.8750877,  -6.36363649
  28191,   21.5694485,   57.1615486,  -6.36363649
  28192,   22.4322262,   57.4480133,  -6.36363649
  28193,   23.2950039,   57.7344742,  -6.36363649
  28194,   24.1577835,   58.0209351,  -6.36363649
  28195,   25.0205612,   58.3073997,  -6.36363649
  28196,   25.8833389,   58.5938606,  -6.36363649
  28197,   26.7461166,   58.8803215,  -6.36363649
  28198,   27.6088943,   59.1667862,  -6.36363649
  28199,   19.8438931,   56.5886269,  -7.27272749
  28200,   20.7066708,   56.8750877,  -7.27272749
  28201,   21.5694485,   57.1615486,  -7.27272749
  28202,   22.4322262,   57.4480133,  -7.27272749
  28203,   23.2950039,   57.7344742,  -7.27272749
  28204,   24.1577835,   58.0209351,  -7.27272749
  28205,   25.0205612,   58.3073997,  -7.27272749
  28206,   25.8833389,   58.5938606,  -7.27272749
  28207,   26.7461166,   58.8803215,  -7.27272749
  28208,   27.6088943,   59.1667862,  -7.27272749
  28209,   19.8438931,   56.5886269,  -8.18181801
  28210,   20.7066708,   56.8750877,  -8.18181801
  28211,   21.5694485,   57.1615486,  -8.18181801
  28212,   22.4322262,   57.4480133,  -8.18181801
  28213,   23.2950039,   57.7344742,  -8.18181801
  28214,   24.1577835,   58.0209351,  -8.18181801
  28215,   25.0205612,   58.3073997,  -8.18181801
  28216,   25.8833389,   58.5938606,  -8.18181801
  28217,   26.7461166,   58.8803215,  -8.18181801
  28218,   27.6088943,   59.1667862,  -8.18181801
  28219,   19.8438931,   56.5886269,    -9.090909
  28220,   20.7066708,   56.8750877,    -9.090909
  28221,   21.5694485,   57.1615486,    -9.090909
  28222,   22.4322262,   57.4480133,    -9.090909
  28223,   23.2950039,   57.7344742,    -9.090909
  28224,   24.1577835,   58.0209351,    -9.090909
  28225,   25.0205612,   58.3073997,    -9.090909
  28226,   25.8833389,   58.5938606,    -9.090909
  28227,   26.7461166,   58.8803215,    -9.090909
  28228,   27.6088943,   59.1667862,    -9.090909
  28229,   19.6225204,   57.2212677, -0.909090936
  28230,   20.4756737,   57.5352364, -0.909090936
  28231,    21.328825,    57.849205, -0.909090936
  28232,   22.1819782,   58.1631737, -0.909090936
  28233,   23.0351315,   58.4771423, -0.909090936
  28234,   23.8882866,    58.791111, -0.909090936
  28235,   24.7414398,   59.1050797, -0.909090936
  28236,    25.594593,   59.4190483, -0.909090936
  28237,   26.4477463,    59.733017, -0.909090936
  28238,   27.3008995,   60.0469818, -0.909090936
  28239,   19.6225204,   57.2212677,  -1.81818187
  28240,   20.4756737,   57.5352364,  -1.81818187
  28241,    21.328825,    57.849205,  -1.81818187
  28242,   22.1819782,   58.1631737,  -1.81818187
  28243,   23.0351315,   58.4771423,  -1.81818187
  28244,   23.8882866,    58.791111,  -1.81818187
  28245,   24.7414398,   59.1050797,  -1.81818187
  28246,    25.594593,   59.4190483,  -1.81818187
  28247,   26.4477463,    59.733017,  -1.81818187
  28248,   27.3008995,   60.0469818,  -1.81818187
  28249,   19.6225204,   57.2212677,  -2.72727275
  28250,   20.4756737,   57.5352364,  -2.72727275
  28251,    21.328825,    57.849205,  -2.72727275
  28252,   22.1819782,   58.1631737,  -2.72727275
  28253,   23.0351315,   58.4771423,  -2.72727275
  28254,   23.8882866,    58.791111,  -2.72727275
  28255,   24.7414398,   59.1050797,  -2.72727275
  28256,    25.594593,   59.4190483,  -2.72727275
  28257,   26.4477463,    59.733017,  -2.72727275
  28258,   27.3008995,   60.0469818,  -2.72727275
  28259,   19.6225204,   57.2212677,  -3.63636374
  28260,   20.4756737,   57.5352364,  -3.63636374
  28261,    21.328825,    57.849205,  -3.63636374
  28262,   22.1819782,   58.1631737,  -3.63636374
  28263,   23.0351315,   58.4771423,  -3.63636374
  28264,   23.8882866,    58.791111,  -3.63636374
  28265,   24.7414398,   59.1050797,  -3.63636374
  28266,    25.594593,   59.4190483,  -3.63636374
  28267,   26.4477463,    59.733017,  -3.63636374
  28268,   27.3008995,   60.0469818,  -3.63636374
  28269,   19.6225204,   57.2212677,   -4.5454545
  28270,   20.4756737,   57.5352364,   -4.5454545
  28271,    21.328825,    57.849205,   -4.5454545
  28272,   22.1819782,   58.1631737,   -4.5454545
  28273,   23.0351315,   58.4771423,   -4.5454545
  28274,   23.8882866,    58.791111,   -4.5454545
  28275,   24.7414398,   59.1050797,   -4.5454545
  28276,    25.594593,   59.4190483,   -4.5454545
  28277,   26.4477463,    59.733017,   -4.5454545
  28278,   27.3008995,   60.0469818,   -4.5454545
  28279,   19.6225204,   57.2212677,   -5.4545455
  28280,   20.4756737,   57.5352364,   -5.4545455
  28281,    21.328825,    57.849205,   -5.4545455
  28282,   22.1819782,   58.1631737,   -5.4545455
  28283,   23.0351315,   58.4771423,   -5.4545455
  28284,   23.8882866,    58.791111,   -5.4545455
  28285,   24.7414398,   59.1050797,   -5.4545455
  28286,    25.594593,   59.4190483,   -5.4545455
  28287,   26.4477463,    59.733017,   -5.4545455
  28288,   27.3008995,   60.0469818,   -5.4545455
  28289,   19.6225204,   57.2212677,  -6.36363649
  28290,   20.4756737,   57.5352364,  -6.36363649
  28291,    21.328825,    57.849205,  -6.36363649
  28292,   22.1819782,   58.1631737,  -6.36363649
  28293,   23.0351315,   58.4771423,  -6.36363649
  28294,   23.8882866,    58.791111,  -6.36363649
  28295,   24.7414398,   59.1050797,  -6.36363649
  28296,    25.594593,   59.4190483,  -6.36363649
  28297,   26.4477463,    59.733017,  -6.36363649
  28298,   27.3008995,   60.0469818,  -6.36363649
  28299,   19.6225204,   57.2212677,  -7.27272749
  28300,   20.4756737,   57.5352364,  -7.27272749
  28301,    21.328825,    57.849205,  -7.27272749
  28302,   22.1819782,   58.1631737,  -7.27272749
  28303,   23.0351315,   58.4771423,  -7.27272749
  28304,   23.8882866,    58.791111,  -7.27272749
  28305,   24.7414398,   59.1050797,  -7.27272749
  28306,    25.594593,   59.4190483,  -7.27272749
  28307,   26.4477463,    59.733017,  -7.27272749
  28308,   27.3008995,   60.0469818,  -7.27272749
  28309,   19.6225204,   57.2212677,  -8.18181801
  28310,   20.4756737,   57.5352364,  -8.18181801
  28311,    21.328825,    57.849205,  -8.18181801
  28312,   22.1819782,   58.1631737,  -8.18181801
  28313,   23.0351315,   58.4771423,  -8.18181801
  28314,   23.8882866,    58.791111,  -8.18181801
  28315,   24.7414398,   59.1050797,  -8.18181801
  28316,    25.594593,   59.4190483,  -8.18181801
  28317,   26.4477463,    59.733017,  -8.18181801
  28318,   27.3008995,   60.0469818,  -8.18181801
  28319,   19.6225204,   57.2212677,    -9.090909
  28320,   20.4756737,   57.5352364,    -9.090909
  28321,    21.328825,    57.849205,    -9.090909
  28322,   22.1819782,   58.1631737,    -9.090909
  28323,   23.0351315,   58.4771423,    -9.090909
  28324,   23.8882866,    58.791111,    -9.090909
  28325,   24.7414398,   59.1050797,    -9.090909
  28326,    25.594593,   59.4190483,    -9.090909
  28327,   26.4477463,    59.733017,    -9.090909
  28328,   27.3008995,   60.0469818,    -9.090909
  28329,   19.3809872,   57.8464928, -0.909090936
  28330,   20.2236385,    58.187645, -0.909090936
  28331,   21.0662899,   58.5287971, -0.909090936
  28332,   21.9089413,   58.8699455, -0.909090936
  28333,   22.7515926,   59.2110977, -0.909090936
  28334,    23.594244,   59.5522499, -0.909090936
  28335,   24.4368973,   59.8934021, -0.909090936
  28336,   25.2795486,   60.2345543, -0.909090936
  28337,      26.1222,   60.5757065, -0.909090936
  28338,   26.9648514,   60.9168587, -0.909090936
  28339,   19.3809872,   57.8464928,  -1.81818187
  28340,   20.2236385,    58.187645,  -1.81818187
  28341,   21.0662899,   58.5287971,  -1.81818187
  28342,   21.9089413,   58.8699455,  -1.81818187
  28343,   22.7515926,   59.2110977,  -1.81818187
  28344,    23.594244,   59.5522499,  -1.81818187
  28345,   24.4368973,   59.8934021,  -1.81818187
  28346,   25.2795486,   60.2345543,  -1.81818187
  28347,      26.1222,   60.5757065,  -1.81818187
  28348,   26.9648514,   60.9168587,  -1.81818187
  28349,   19.3809872,   57.8464928,  -2.72727275
  28350,   20.2236385,    58.187645,  -2.72727275
  28351,   21.0662899,   58.5287971,  -2.72727275
  28352,   21.9089413,   58.8699455,  -2.72727275
  28353,   22.7515926,   59.2110977,  -2.72727275
  28354,    23.594244,   59.5522499,  -2.72727275
  28355,   24.4368973,   59.8934021,  -2.72727275
  28356,   25.2795486,   60.2345543,  -2.72727275
  28357,      26.1222,   60.5757065,  -2.72727275
  28358,   26.9648514,   60.9168587,  -2.72727275
  28359,   19.3809872,   57.8464928,  -3.63636374
  28360,   20.2236385,    58.187645,  -3.63636374
  28361,   21.0662899,   58.5287971,  -3.63636374
  28362,   21.9089413,   58.8699455,  -3.63636374
  28363,   22.7515926,   59.2110977,  -3.63636374
  28364,    23.594244,   59.5522499,  -3.63636374
  28365,   24.4368973,   59.8934021,  -3.63636374
  28366,   25.2795486,   60.2345543,  -3.63636374
  28367,      26.1222,   60.5757065,  -3.63636374
  28368,   26.9648514,   60.9168587,  -3.63636374
  28369,   19.3809872,   57.8464928,   -4.5454545
  28370,   20.2236385,    58.187645,   -4.5454545
  28371,   21.0662899,   58.5287971,   -4.5454545
  28372,   21.9089413,   58.8699455,   -4.5454545
  28373,   22.7515926,   59.2110977,   -4.5454545
  28374,    23.594244,   59.5522499,   -4.5454545
  28375,   24.4368973,   59.8934021,   -4.5454545
  28376,   25.2795486,   60.2345543,   -4.5454545
  28377,      26.1222,   60.5757065,   -4.5454545
  28378,   26.9648514,   60.9168587,   -4.5454545
  28379,   19.3809872,   57.8464928,   -5.4545455
  28380,   20.2236385,    58.187645,   -5.4545455
  28381,   21.0662899,   58.5287971,   -5.4545455
  28382,   21.9089413,   58.8699455,   -5.4545455
  28383,   22.7515926,   59.2110977,   -5.4545455
  28384,    23.594244,   59.5522499,   -5.4545455
  28385,   24.4368973,   59.8934021,   -5.4545455
  28386,   25.2795486,   60.2345543,   -5.4545455
  28387,      26.1222,   60.5757065,   -5.4545455
  28388,   26.9648514,   60.9168587,   -5.4545455
  28389,   19.3809872,   57.8464928,  -6.36363649
  28390,   20.2236385,    58.187645,  -6.36363649
  28391,   21.0662899,   58.5287971,  -6.36363649
  28392,   21.9089413,   58.8699455,  -6.36363649
  28393,   22.7515926,   59.2110977,  -6.36363649
  28394,    23.594244,   59.5522499,  -6.36363649
  28395,   24.4368973,   59.8934021,  -6.36363649
  28396,   25.2795486,   60.2345543,  -6.36363649
  28397,      26.1222,   60.5757065,  -6.36363649
  28398,   26.9648514,   60.9168587,  -6.36363649
  28399,   19.3809872,   57.8464928,  -7.27272749
  28400,   20.2236385,    58.187645,  -7.27272749
  28401,   21.0662899,   58.5287971,  -7.27272749
  28402,   21.9089413,   58.8699455,  -7.27272749
  28403,   22.7515926,   59.2110977,  -7.27272749
  28404,    23.594244,   59.5522499,  -7.27272749
  28405,   24.4368973,   59.8934021,  -7.27272749
  28406,   25.2795486,   60.2345543,  -7.27272749
  28407,      26.1222,   60.5757065,  -7.27272749
  28408,   26.9648514,   60.9168587,  -7.27272749
  28409,   19.3809872,   57.8464928,  -8.18181801
  28410,   20.2236385,    58.187645,  -8.18181801
  28411,   21.0662899,   58.5287971,  -8.18181801
  28412,   21.9089413,   58.8699455,  -8.18181801
  28413,   22.7515926,   59.2110977,  -8.18181801
  28414,    23.594244,   59.5522499,  -8.18181801
  28415,   24.4368973,   59.8934021,  -8.18181801
  28416,   25.2795486,   60.2345543,  -8.18181801
  28417,      26.1222,   60.5757065,  -8.18181801
  28418,   26.9648514,   60.9168587,  -8.18181801
  28419,   19.3809872,   57.8464928,    -9.090909
  28420,   20.2236385,    58.187645,    -9.090909
  28421,   21.0662899,   58.5287971,    -9.090909
  28422,   21.9089413,   58.8699455,    -9.090909
  28423,   22.7515926,   59.2110977,    -9.090909
  28424,    23.594244,   59.5522499,    -9.090909
  28425,   24.4368973,   59.8934021,    -9.090909
  28426,   25.2795486,   60.2345543,    -9.090909
  28427,      26.1222,   60.5757065,    -9.090909
  28428,   26.9648514,   60.9168587,    -9.090909
  28429,   19.1195393,   58.4636536, -0.909090936
  28430,   19.9508228,   58.8316383, -0.909090936
  28431,   20.7821064,   59.1996231, -0.909090936
  28432,   21.6133919,   59.5676079, -0.909090936
  28433,   22.4446754,   59.9355927, -0.909090936
  28434,   23.2759571,   60.3035774, -0.909090936
  28435,   24.1072426,   60.6715622, -0.909090936
  28436,   24.9385262,    61.039547, -0.909090936
  28437,   25.7698097,   61.4075317, -0.909090936
  28438,   26.6010952,   61.7755165, -0.909090936
  28439,   19.1195393,   58.4636536,  -1.81818187
  28440,   19.9508228,   58.8316383,  -1.81818187
  28441,   20.7821064,   59.1996231,  -1.81818187
  28442,   21.6133919,   59.5676079,  -1.81818187
  28443,   22.4446754,   59.9355927,  -1.81818187
  28444,   23.2759571,   60.3035774,  -1.81818187
  28445,   24.1072426,   60.6715622,  -1.81818187
  28446,   24.9385262,    61.039547,  -1.81818187
  28447,   25.7698097,   61.4075317,  -1.81818187
  28448,   26.6010952,   61.7755165,  -1.81818187
  28449,   19.1195393,   58.4636536,  -2.72727275
  28450,   19.9508228,   58.8316383,  -2.72727275
  28451,   20.7821064,   59.1996231,  -2.72727275
  28452,   21.6133919,   59.5676079,  -2.72727275
  28453,   22.4446754,   59.9355927,  -2.72727275
  28454,   23.2759571,   60.3035774,  -2.72727275
  28455,   24.1072426,   60.6715622,  -2.72727275
  28456,   24.9385262,    61.039547,  -2.72727275
  28457,   25.7698097,   61.4075317,  -2.72727275
  28458,   26.6010952,   61.7755165,  -2.72727275
  28459,   19.1195393,   58.4636536,  -3.63636374
  28460,   19.9508228,   58.8316383,  -3.63636374
  28461,   20.7821064,   59.1996231,  -3.63636374
  28462,   21.6133919,   59.5676079,  -3.63636374
  28463,   22.4446754,   59.9355927,  -3.63636374
  28464,   23.2759571,   60.3035774,  -3.63636374
  28465,   24.1072426,   60.6715622,  -3.63636374
  28466,   24.9385262,    61.039547,  -3.63636374
  28467,   25.7698097,   61.4075317,  -3.63636374
  28468,   26.6010952,   61.7755165,  -3.63636374
  28469,   19.1195393,   58.4636536,   -4.5454545
  28470,   19.9508228,   58.8316383,   -4.5454545
  28471,   20.7821064,   59.1996231,   -4.5454545
  28472,   21.6133919,   59.5676079,   -4.5454545
  28473,   22.4446754,   59.9355927,   -4.5454545
  28474,   23.2759571,   60.3035774,   -4.5454545
  28475,   24.1072426,   60.6715622,   -4.5454545
  28476,   24.9385262,    61.039547,   -4.5454545
  28477,   25.7698097,   61.4075317,   -4.5454545
  28478,   26.6010952,   61.7755165,   -4.5454545
  28479,   19.1195393,   58.4636536,   -5.4545455
  28480,   19.9508228,   58.8316383,   -5.4545455
  28481,   20.7821064,   59.1996231,   -5.4545455
  28482,   21.6133919,   59.5676079,   -5.4545455
  28483,   22.4446754,   59.9355927,   -5.4545455
  28484,   23.2759571,   60.3035774,   -5.4545455
  28485,   24.1072426,   60.6715622,   -5.4545455
  28486,   24.9385262,    61.039547,   -5.4545455
  28487,   25.7698097,   61.4075317,   -5.4545455
  28488,   26.6010952,   61.7755165,   -5.4545455
  28489,   19.1195393,   58.4636536,  -6.36363649
  28490,   19.9508228,   58.8316383,  -6.36363649
  28491,   20.7821064,   59.1996231,  -6.36363649
  28492,   21.6133919,   59.5676079,  -6.36363649
  28493,   22.4446754,   59.9355927,  -6.36363649
  28494,   23.2759571,   60.3035774,  -6.36363649
  28495,   24.1072426,   60.6715622,  -6.36363649
  28496,   24.9385262,    61.039547,  -6.36363649
  28497,   25.7698097,   61.4075317,  -6.36363649
  28498,   26.6010952,   61.7755165,  -6.36363649
  28499,   19.1195393,   58.4636536,  -7.27272749
  28500,   19.9508228,   58.8316383,  -7.27272749
  28501,   20.7821064,   59.1996231,  -7.27272749
  28502,   21.6133919,   59.5676079,  -7.27272749
  28503,   22.4446754,   59.9355927,  -7.27272749
  28504,   23.2759571,   60.3035774,  -7.27272749
  28505,   24.1072426,   60.6715622,  -7.27272749
  28506,   24.9385262,    61.039547,  -7.27272749
  28507,   25.7698097,   61.4075317,  -7.27272749
  28508,   26.6010952,   61.7755165,  -7.27272749
  28509,   19.1195393,   58.4636536,  -8.18181801
  28510,   19.9508228,   58.8316383,  -8.18181801
  28511,   20.7821064,   59.1996231,  -8.18181801
  28512,   21.6133919,   59.5676079,  -8.18181801
  28513,   22.4446754,   59.9355927,  -8.18181801
  28514,   23.2759571,   60.3035774,  -8.18181801
  28515,   24.1072426,   60.6715622,  -8.18181801
  28516,   24.9385262,    61.039547,  -8.18181801
  28517,   25.7698097,   61.4075317,  -8.18181801
  28518,   26.6010952,   61.7755165,  -8.18181801
  28519,   19.1195393,   58.4636536,    -9.090909
  28520,   19.9508228,   58.8316383,    -9.090909
  28521,   20.7821064,   59.1996231,    -9.090909
  28522,   21.6133919,   59.5676079,    -9.090909
  28523,   22.4446754,   59.9355927,    -9.090909
  28524,   23.2759571,   60.3035774,    -9.090909
  28525,   24.1072426,   60.6715622,    -9.090909
  28526,   24.9385262,    61.039547,    -9.090909
  28527,   25.7698097,   61.4075317,    -9.090909
  28528,   26.6010952,   61.7755165,    -9.090909
  28529,   18.8384418,    59.072113, -0.909090936
  28530,    19.657505,   59.4665527, -0.909090936
  28531,   20.4765663,   59.8609924, -0.909090936
  28532,   21.2956295,   60.2554321, -0.909090936
  28533,   22.1146927,   60.6498718, -0.909090936
  28534,   22.9337521,   61.0443115, -0.909090936
  28535,   23.7528152,   61.4387512, -0.909090936
  28536,   24.5718784,   61.8331947, -0.909090936
  28537,   25.3909416,   62.2276344, -0.909090936
  28538,   26.2100029,   62.6220741, -0.909090936
  28539,   18.8384418,    59.072113,  -1.81818187
  28540,    19.657505,   59.4665527,  -1.81818187
  28541,   20.4765663,   59.8609924,  -1.81818187
  28542,   21.2956295,   60.2554321,  -1.81818187
  28543,   22.1146927,   60.6498718,  -1.81818187
  28544,   22.9337521,   61.0443115,  -1.81818187
  28545,   23.7528152,   61.4387512,  -1.81818187
  28546,   24.5718784,   61.8331947,  -1.81818187
  28547,   25.3909416,   62.2276344,  -1.81818187
  28548,   26.2100029,   62.6220741,  -1.81818187
  28549,   18.8384418,    59.072113,  -2.72727275
  28550,    19.657505,   59.4665527,  -2.72727275
  28551,   20.4765663,   59.8609924,  -2.72727275
  28552,   21.2956295,   60.2554321,  -2.72727275
  28553,   22.1146927,   60.6498718,  -2.72727275
  28554,   22.9337521,   61.0443115,  -2.72727275
  28555,   23.7528152,   61.4387512,  -2.72727275
  28556,   24.5718784,   61.8331947,  -2.72727275
  28557,   25.3909416,   62.2276344,  -2.72727275
  28558,   26.2100029,   62.6220741,  -2.72727275
  28559,   18.8384418,    59.072113,  -3.63636374
  28560,    19.657505,   59.4665527,  -3.63636374
  28561,   20.4765663,   59.8609924,  -3.63636374
  28562,   21.2956295,   60.2554321,  -3.63636374
  28563,   22.1146927,   60.6498718,  -3.63636374
  28564,   22.9337521,   61.0443115,  -3.63636374
  28565,   23.7528152,   61.4387512,  -3.63636374
  28566,   24.5718784,   61.8331947,  -3.63636374
  28567,   25.3909416,   62.2276344,  -3.63636374
  28568,   26.2100029,   62.6220741,  -3.63636374
  28569,   18.8384418,    59.072113,   -4.5454545
  28570,    19.657505,   59.4665527,   -4.5454545
  28571,   20.4765663,   59.8609924,   -4.5454545
  28572,   21.2956295,   60.2554321,   -4.5454545
  28573,   22.1146927,   60.6498718,   -4.5454545
  28574,   22.9337521,   61.0443115,   -4.5454545
  28575,   23.7528152,   61.4387512,   -4.5454545
  28576,   24.5718784,   61.8331947,   -4.5454545
  28577,   25.3909416,   62.2276344,   -4.5454545
  28578,   26.2100029,   62.6220741,   -4.5454545
  28579,   18.8384418,    59.072113,   -5.4545455
  28580,    19.657505,   59.4665527,   -5.4545455
  28581,   20.4765663,   59.8609924,   -5.4545455
  28582,   21.2956295,   60.2554321,   -5.4545455
  28583,   22.1146927,   60.6498718,   -5.4545455
  28584,   22.9337521,   61.0443115,   -5.4545455
  28585,   23.7528152,   61.4387512,   -5.4545455
  28586,   24.5718784,   61.8331947,   -5.4545455
  28587,   25.3909416,   62.2276344,   -5.4545455
  28588,   26.2100029,   62.6220741,   -5.4545455
  28589,   18.8384418,    59.072113,  -6.36363649
  28590,    19.657505,   59.4665527,  -6.36363649
  28591,   20.4765663,   59.8609924,  -6.36363649
  28592,   21.2956295,   60.2554321,  -6.36363649
  28593,   22.1146927,   60.6498718,  -6.36363649
  28594,   22.9337521,   61.0443115,  -6.36363649
  28595,   23.7528152,   61.4387512,  -6.36363649
  28596,   24.5718784,   61.8331947,  -6.36363649
  28597,   25.3909416,   62.2276344,  -6.36363649
  28598,   26.2100029,   62.6220741,  -6.36363649
  28599,   18.8384418,    59.072113,  -7.27272749
  28600,    19.657505,   59.4665527,  -7.27272749
  28601,   20.4765663,   59.8609924,  -7.27272749
  28602,   21.2956295,   60.2554321,  -7.27272749
  28603,   22.1146927,   60.6498718,  -7.27272749
  28604,   22.9337521,   61.0443115,  -7.27272749
  28605,   23.7528152,   61.4387512,  -7.27272749
  28606,   24.5718784,   61.8331947,  -7.27272749
  28607,   25.3909416,   62.2276344,  -7.27272749
  28608,   26.2100029,   62.6220741,  -7.27272749
  28609,   18.8384418,    59.072113,  -8.18181801
  28610,    19.657505,   59.4665527,  -8.18181801
  28611,   20.4765663,   59.8609924,  -8.18181801
  28612,   21.2956295,   60.2554321,  -8.18181801
  28613,   22.1146927,   60.6498718,  -8.18181801
  28614,   22.9337521,   61.0443115,  -8.18181801
  28615,   23.7528152,   61.4387512,  -8.18181801
  28616,   24.5718784,   61.8331947,  -8.18181801
  28617,   25.3909416,   62.2276344,  -8.18181801
  28618,   26.2100029,   62.6220741,  -8.18181801
  28619,   18.8384418,    59.072113,    -9.090909
  28620,    19.657505,   59.4665527,    -9.090909
  28621,   20.4765663,   59.8609924,    -9.090909
  28622,   21.2956295,   60.2554321,    -9.090909
  28623,   22.1146927,   60.6498718,    -9.090909
  28624,   22.9337521,   61.0443115,    -9.090909
  28625,   23.7528152,   61.4387512,    -9.090909
  28626,   24.5718784,   61.8331947,    -9.090909
  28627,   25.3909416,   62.2276344,    -9.090909
  28628,   26.2100029,   62.6220741,    -9.090909
  28629,   18.5379829,    59.671257, -0.909090936
  28630,   19.3439827,   60.0917435, -0.909090936
  28631,   20.1499825,   60.5122337, -0.909090936
  28632,   20.9559822,    60.932724, -0.909090936
  28633,    21.761982,   61.3532143, -0.909090936
  28634,   22.5679817,   61.7737007, -0.909090936
  28635,   23.3739815,    62.194191, -0.909090936
  28636,   24.1799812,   62.6146812, -0.909090936
  28637,    24.985981,   63.0351715, -0.909090936
  28638,   25.7919807,    63.455658, -0.909090936
  28639,   18.5379829,    59.671257,  -1.81818187
  28640,   19.3439827,   60.0917435,  -1.81818187
  28641,   20.1499825,   60.5122337,  -1.81818187
  28642,   20.9559822,    60.932724,  -1.81818187
  28643,    21.761982,   61.3532143,  -1.81818187
  28644,   22.5679817,   61.7737007,  -1.81818187
  28645,   23.3739815,    62.194191,  -1.81818187
  28646,   24.1799812,   62.6146812,  -1.81818187
  28647,    24.985981,   63.0351715,  -1.81818187
  28648,   25.7919807,    63.455658,  -1.81818187
  28649,   18.5379829,    59.671257,  -2.72727275
  28650,   19.3439827,   60.0917435,  -2.72727275
  28651,   20.1499825,   60.5122337,  -2.72727275
  28652,   20.9559822,    60.932724,  -2.72727275
  28653,    21.761982,   61.3532143,  -2.72727275
  28654,   22.5679817,   61.7737007,  -2.72727275
  28655,   23.3739815,    62.194191,  -2.72727275
  28656,   24.1799812,   62.6146812,  -2.72727275
  28657,    24.985981,   63.0351715,  -2.72727275
  28658,   25.7919807,    63.455658,  -2.72727275
  28659,   18.5379829,    59.671257,  -3.63636374
  28660,   19.3439827,   60.0917435,  -3.63636374
  28661,   20.1499825,   60.5122337,  -3.63636374
  28662,   20.9559822,    60.932724,  -3.63636374
  28663,    21.761982,   61.3532143,  -3.63636374
  28664,   22.5679817,   61.7737007,  -3.63636374
  28665,   23.3739815,    62.194191,  -3.63636374
  28666,   24.1799812,   62.6146812,  -3.63636374
  28667,    24.985981,   63.0351715,  -3.63636374
  28668,   25.7919807,    63.455658,  -3.63636374
  28669,   18.5379829,    59.671257,   -4.5454545
  28670,   19.3439827,   60.0917435,   -4.5454545
  28671,   20.1499825,   60.5122337,   -4.5454545
  28672,   20.9559822,    60.932724,   -4.5454545
  28673,    21.761982,   61.3532143,   -4.5454545
  28674,   22.5679817,   61.7737007,   -4.5454545
  28675,   23.3739815,    62.194191,   -4.5454545
  28676,   24.1799812,   62.6146812,   -4.5454545
  28677,    24.985981,   63.0351715,   -4.5454545
  28678,   25.7919807,    63.455658,   -4.5454545
  28679,   18.5379829,    59.671257,   -5.4545455
  28680,   19.3439827,   60.0917435,   -5.4545455
  28681,   20.1499825,   60.5122337,   -5.4545455
  28682,   20.9559822,    60.932724,   -5.4545455
  28683,    21.761982,   61.3532143,   -5.4545455
  28684,   22.5679817,   61.7737007,   -5.4545455
  28685,   23.3739815,    62.194191,   -5.4545455
  28686,   24.1799812,   62.6146812,   -5.4545455
  28687,    24.985981,   63.0351715,   -5.4545455
  28688,   25.7919807,    63.455658,   -5.4545455
  28689,   18.5379829,    59.671257,  -6.36363649
  28690,   19.3439827,   60.0917435,  -6.36363649
  28691,   20.1499825,   60.5122337,  -6.36363649
  28692,   20.9559822,    60.932724,  -6.36363649
  28693,    21.761982,   61.3532143,  -6.36363649
  28694,   22.5679817,   61.7737007,  -6.36363649
  28695,   23.3739815,    62.194191,  -6.36363649
  28696,   24.1799812,   62.6146812,  -6.36363649
  28697,    24.985981,   63.0351715,  -6.36363649
  28698,   25.7919807,    63.455658,  -6.36363649
  28699,   18.5379829,    59.671257,  -7.27272749
  28700,   19.3439827,   60.0917435,  -7.27272749
  28701,   20.1499825,   60.5122337,  -7.27272749
  28702,   20.9559822,    60.932724,  -7.27272749
  28703,    21.761982,   61.3532143,  -7.27272749
  28704,   22.5679817,   61.7737007,  -7.27272749
  28705,   23.3739815,    62.194191,  -7.27272749
  28706,   24.1799812,   62.6146812,  -7.27272749
  28707,    24.985981,   63.0351715,  -7.27272749
  28708,   25.7919807,    63.455658,  -7.27272749
  28709,   18.5379829,    59.671257,  -8.18181801
  28710,   19.3439827,   60.0917435,  -8.18181801
  28711,   20.1499825,   60.5122337,  -8.18181801
  28712,   20.9559822,    60.932724,  -8.18181801
  28713,    21.761982,   61.3532143,  -8.18181801
  28714,   22.5679817,   61.7737007,  -8.18181801
  28715,   23.3739815,    62.194191,  -8.18181801
  28716,   24.1799812,   62.6146812,  -8.18181801
  28717,    24.985981,   63.0351715,  -8.18181801
  28718,   25.7919807,    63.455658,  -8.18181801
  28719,   18.5379829,    59.671257,    -9.090909
  28720,   19.3439827,   60.0917435,    -9.090909
  28721,   20.1499825,   60.5122337,    -9.090909
  28722,   20.9559822,    60.932724,    -9.090909
  28723,    21.761982,   61.3532143,    -9.090909
  28724,   22.5679817,   61.7737007,    -9.090909
  28725,   23.3739815,    62.194191,    -9.090909
  28726,   24.1799812,   62.6146812,    -9.090909
  28727,    24.985981,   63.0351715,    -9.090909
  28728,   25.7919807,    63.455658,    -9.090909
  28729,   18.2184811,   60.2604561, -0.909090936
  28730,   19.0105896,   60.7065659, -0.909090936
  28731,   19.8026981,   61.1526718, -0.909090936
  28732,   20.5948067,   61.5987778, -0.909090936
  28733,   21.3869133,   62.0448837, -0.909090936
  28734,   22.1790218,   62.4909935, -0.909090936
  28735,   22.9711304,   62.9370995, -0.909090936
  28736,    23.763237,   63.3832054, -0.909090936
  28737,   24.5553455,   63.8293114, -0.909090936
  28738,   25.3474541,   64.2754211, -0.909090936
  28739,   18.2184811,   60.2604561,  -1.81818187
  28740,   19.0105896,   60.7065659,  -1.81818187
  28741,   19.8026981,   61.1526718,  -1.81818187
  28742,   20.5948067,   61.5987778,  -1.81818187
  28743,   21.3869133,   62.0448837,  -1.81818187
  28744,   22.1790218,   62.4909935,  -1.81818187
  28745,   22.9711304,   62.9370995,  -1.81818187
  28746,    23.763237,   63.3832054,  -1.81818187
  28747,   24.5553455,   63.8293114,  -1.81818187
  28748,   25.3474541,   64.2754211,  -1.81818187
  28749,   18.2184811,   60.2604561,  -2.72727275
  28750,   19.0105896,   60.7065659,  -2.72727275
  28751,   19.8026981,   61.1526718,  -2.72727275
  28752,   20.5948067,   61.5987778,  -2.72727275
  28753,   21.3869133,   62.0448837,  -2.72727275
  28754,   22.1790218,   62.4909935,  -2.72727275
  28755,   22.9711304,   62.9370995,  -2.72727275
  28756,    23.763237,   63.3832054,  -2.72727275
  28757,   24.5553455,   63.8293114,  -2.72727275
  28758,   25.3474541,   64.2754211,  -2.72727275
  28759,   18.2184811,   60.2604561,  -3.63636374
  28760,   19.0105896,   60.7065659,  -3.63636374
  28761,   19.8026981,   61.1526718,  -3.63636374
  28762,   20.5948067,   61.5987778,  -3.63636374
  28763,   21.3869133,   62.0448837,  -3.63636374
  28764,   22.1790218,   62.4909935,  -3.63636374
  28765,   22.9711304,   62.9370995,  -3.63636374
  28766,    23.763237,   63.3832054,  -3.63636374
  28767,   24.5553455,   63.8293114,  -3.63636374
  28768,   25.3474541,   64.2754211,  -3.63636374
  28769,   18.2184811,   60.2604561,   -4.5454545
  28770,   19.0105896,   60.7065659,   -4.5454545
  28771,   19.8026981,   61.1526718,   -4.5454545
  28772,   20.5948067,   61.5987778,   -4.5454545
  28773,   21.3869133,   62.0448837,   -4.5454545
  28774,   22.1790218,   62.4909935,   -4.5454545
  28775,   22.9711304,   62.9370995,   -4.5454545
  28776,    23.763237,   63.3832054,   -4.5454545
  28777,   24.5553455,   63.8293114,   -4.5454545
  28778,   25.3474541,   64.2754211,   -4.5454545
  28779,   18.2184811,   60.2604561,   -5.4545455
  28780,   19.0105896,   60.7065659,   -5.4545455
  28781,   19.8026981,   61.1526718,   -5.4545455
  28782,   20.5948067,   61.5987778,   -5.4545455
  28783,   21.3869133,   62.0448837,   -5.4545455
  28784,   22.1790218,   62.4909935,   -5.4545455
  28785,   22.9711304,   62.9370995,   -5.4545455
  28786,    23.763237,   63.3832054,   -5.4545455
  28787,   24.5553455,   63.8293114,   -5.4545455
  28788,   25.3474541,   64.2754211,   -5.4545455
  28789,   18.2184811,   60.2604561,  -6.36363649
  28790,   19.0105896,   60.7065659,  -6.36363649
  28791,   19.8026981,   61.1526718,  -6.36363649
  28792,   20.5948067,   61.5987778,  -6.36363649
  28793,   21.3869133,   62.0448837,  -6.36363649
  28794,   22.1790218,   62.4909935,  -6.36363649
  28795,   22.9711304,   62.9370995,  -6.36363649
  28796,    23.763237,   63.3832054,  -6.36363649
  28797,   24.5553455,   63.8293114,  -6.36363649
  28798,   25.3474541,   64.2754211,  -6.36363649
  28799,   18.2184811,   60.2604561,  -7.27272749
  28800,   19.0105896,   60.7065659,  -7.27272749
  28801,   19.8026981,   61.1526718,  -7.27272749
  28802,   20.5948067,   61.5987778,  -7.27272749
  28803,   21.3869133,   62.0448837,  -7.27272749
  28804,   22.1790218,   62.4909935,  -7.27272749
  28805,   22.9711304,   62.9370995,  -7.27272749
  28806,    23.763237,   63.3832054,  -7.27272749
  28807,   24.5553455,   63.8293114,  -7.27272749
  28808,   25.3474541,   64.2754211,  -7.27272749
  28809,   18.2184811,   60.2604561,  -8.18181801
  28810,   19.0105896,   60.7065659,  -8.18181801
  28811,   19.8026981,   61.1526718,  -8.18181801
  28812,   20.5948067,   61.5987778,  -8.18181801
  28813,   21.3869133,   62.0448837,  -8.18181801
  28814,   22.1790218,   62.4909935,  -8.18181801
  28815,   22.9711304,   62.9370995,  -8.18181801
  28816,    23.763237,   63.3832054,  -8.18181801
  28817,   24.5553455,   63.8293114,  -8.18181801
  28818,   25.3474541,   64.2754211,  -8.18181801
  28819,   18.2184811,   60.2604561,    -9.090909
  28820,   19.0105896,   60.7065659,    -9.090909
  28821,   19.8026981,   61.1526718,    -9.090909
  28822,   20.5948067,   61.5987778,    -9.090909
  28823,   21.3869133,   62.0448837,    -9.090909
  28824,   22.1790218,   62.4909935,    -9.090909
  28825,   22.9711304,   62.9370995,    -9.090909
  28826,    23.763237,   63.3832054,    -9.090909
  28827,   24.5553455,   63.8293114,    -9.090909
  28828,   25.3474541,   64.2754211,    -9.090909
  28829,   17.8802586,    60.839119, -0.909090936
  28830,   18.6576595,   61.3103828, -0.909090936
  28831,   19.4350624,   61.7816505, -0.909090936
  28832,   20.2124653,   62.2529144, -0.909090936
  28833,   20.9898682,   62.7241821, -0.909090936
  28834,   21.7672691,    63.195446, -0.909090936
  28835,   22.5446701,   63.6667137, -0.909090936
  28836,    23.322073,   64.1379776, -0.909090936
  28837,   24.0994759,   64.6092453, -0.909090936
  28838,   24.8768787,    65.080513, -0.909090936
  28839,   17.8802586,    60.839119,  -1.81818187
  28840,   18.6576595,   61.3103828,  -1.81818187
  28841,   19.4350624,   61.7816505,  -1.81818187
  28842,   20.2124653,   62.2529144,  -1.81818187
  28843,   20.9898682,   62.7241821,  -1.81818187
  28844,   21.7672691,    63.195446,  -1.81818187
  28845,   22.5446701,   63.6667137,  -1.81818187
  28846,    23.322073,   64.1379776,  -1.81818187
  28847,   24.0994759,   64.6092453,  -1.81818187
  28848,   24.8768787,    65.080513,  -1.81818187
  28849,   17.8802586,    60.839119,  -2.72727275
  28850,   18.6576595,   61.3103828,  -2.72727275
  28851,   19.4350624,   61.7816505,  -2.72727275
  28852,   20.2124653,   62.2529144,  -2.72727275
  28853,   20.9898682,   62.7241821,  -2.72727275
  28854,   21.7672691,    63.195446,  -2.72727275
  28855,   22.5446701,   63.6667137,  -2.72727275
  28856,    23.322073,   64.1379776,  -2.72727275
  28857,   24.0994759,   64.6092453,  -2.72727275
  28858,   24.8768787,    65.080513,  -2.72727275
  28859,   17.8802586,    60.839119,  -3.63636374
  28860,   18.6576595,   61.3103828,  -3.63636374
  28861,   19.4350624,   61.7816505,  -3.63636374
  28862,   20.2124653,   62.2529144,  -3.63636374
  28863,   20.9898682,   62.7241821,  -3.63636374
  28864,   21.7672691,    63.195446,  -3.63636374
  28865,   22.5446701,   63.6667137,  -3.63636374
  28866,    23.322073,   64.1379776,  -3.63636374
  28867,   24.0994759,   64.6092453,  -3.63636374
  28868,   24.8768787,    65.080513,  -3.63636374
  28869,   17.8802586,    60.839119,   -4.5454545
  28870,   18.6576595,   61.3103828,   -4.5454545
  28871,   19.4350624,   61.7816505,   -4.5454545
  28872,   20.2124653,   62.2529144,   -4.5454545
  28873,   20.9898682,   62.7241821,   -4.5454545
  28874,   21.7672691,    63.195446,   -4.5454545
  28875,   22.5446701,   63.6667137,   -4.5454545
  28876,    23.322073,   64.1379776,   -4.5454545
  28877,   24.0994759,   64.6092453,   -4.5454545
  28878,   24.8768787,    65.080513,   -4.5454545
  28879,   17.8802586,    60.839119,   -5.4545455
  28880,   18.6576595,   61.3103828,   -5.4545455
  28881,   19.4350624,   61.7816505,   -5.4545455
  28882,   20.2124653,   62.2529144,   -5.4545455
  28883,   20.9898682,   62.7241821,   -5.4545455
  28884,   21.7672691,    63.195446,   -5.4545455
  28885,   22.5446701,   63.6667137,   -5.4545455
  28886,    23.322073,   64.1379776,   -5.4545455
  28887,   24.0994759,   64.6092453,   -5.4545455
  28888,   24.8768787,    65.080513,   -5.4545455
  28889,   17.8802586,    60.839119,  -6.36363649
  28890,   18.6576595,   61.3103828,  -6.36363649
  28891,   19.4350624,   61.7816505,  -6.36363649
  28892,   20.2124653,   62.2529144,  -6.36363649
  28893,   20.9898682,   62.7241821,  -6.36363649
  28894,   21.7672691,    63.195446,  -6.36363649
  28895,   22.5446701,   63.6667137,  -6.36363649
  28896,    23.322073,   64.1379776,  -6.36363649
  28897,   24.0994759,   64.6092453,  -6.36363649
  28898,   24.8768787,    65.080513,  -6.36363649
  28899,   17.8802586,    60.839119,  -7.27272749
  28900,   18.6576595,   61.3103828,  -7.27272749
  28901,   19.4350624,   61.7816505,  -7.27272749
  28902,   20.2124653,   62.2529144,  -7.27272749
  28903,   20.9898682,   62.7241821,  -7.27272749
  28904,   21.7672691,    63.195446,  -7.27272749
  28905,   22.5446701,   63.6667137,  -7.27272749
  28906,    23.322073,   64.1379776,  -7.27272749
  28907,   24.0994759,   64.6092453,  -7.27272749
  28908,   24.8768787,    65.080513,  -7.27272749
  28909,   17.8802586,    60.839119,  -8.18181801
  28910,   18.6576595,   61.3103828,  -8.18181801
  28911,   19.4350624,   61.7816505,  -8.18181801
  28912,   20.2124653,   62.2529144,  -8.18181801
  28913,   20.9898682,   62.7241821,  -8.18181801
  28914,   21.7672691,    63.195446,  -8.18181801
  28915,   22.5446701,   63.6667137,  -8.18181801
  28916,    23.322073,   64.1379776,  -8.18181801
  28917,   24.0994759,   64.6092453,  -8.18181801
  28918,   24.8768787,    65.080513,  -8.18181801
  28919,   17.8802586,    60.839119,    -9.090909
  28920,   18.6576595,   61.3103828,    -9.090909
  28921,   19.4350624,   61.7816505,    -9.090909
  28922,   20.2124653,   62.2529144,    -9.090909
  28923,   20.9898682,   62.7241821,    -9.090909
  28924,   21.7672691,    63.195446,    -9.090909
  28925,   22.5446701,   63.6667137,    -9.090909
  28926,    23.322073,   64.1379776,    -9.090909
  28927,   24.0994759,   64.6092453,    -9.090909
  28928,   24.8768787,    65.080513,    -9.090909
  28929,   17.5236607,   61.4066391, -0.909090936
  28930,   18.2855587,   61.9025803, -0.909090936
  28931,   19.0474567,   62.3985214, -0.909090936
  28932,   19.8093548,   62.8944626, -0.909090936
  28933,   20.5712528,   63.3904037, -0.909090936
  28934,    21.333149,   63.8863411, -0.909090936
  28935,   22.0950489,   64.3822861, -0.909090936
  28936,   22.8569469,   64.8782272, -0.909090936
  28937,    23.618845,   65.3741684, -0.909090936
  28938,    24.380743,   65.8701096, -0.909090936
  28939,   17.5236607,   61.4066391,  -1.81818187
  28940,   18.2855587,   61.9025803,  -1.81818187
  28941,   19.0474567,   62.3985214,  -1.81818187
  28942,   19.8093548,   62.8944626,  -1.81818187
  28943,   20.5712528,   63.3904037,  -1.81818187
  28944,    21.333149,   63.8863411,  -1.81818187
  28945,   22.0950489,   64.3822861,  -1.81818187
  28946,   22.8569469,   64.8782272,  -1.81818187
  28947,    23.618845,   65.3741684,  -1.81818187
  28948,    24.380743,   65.8701096,  -1.81818187
  28949,   17.5236607,   61.4066391,  -2.72727275
  28950,   18.2855587,   61.9025803,  -2.72727275
  28951,   19.0474567,   62.3985214,  -2.72727275
  28952,   19.8093548,   62.8944626,  -2.72727275
  28953,   20.5712528,   63.3904037,  -2.72727275
  28954,    21.333149,   63.8863411,  -2.72727275
  28955,   22.0950489,   64.3822861,  -2.72727275
  28956,   22.8569469,   64.8782272,  -2.72727275
  28957,    23.618845,   65.3741684,  -2.72727275
  28958,    24.380743,   65.8701096,  -2.72727275
  28959,   17.5236607,   61.4066391,  -3.63636374
  28960,   18.2855587,   61.9025803,  -3.63636374
  28961,   19.0474567,   62.3985214,  -3.63636374
  28962,   19.8093548,   62.8944626,  -3.63636374
  28963,   20.5712528,   63.3904037,  -3.63636374
  28964,    21.333149,   63.8863411,  -3.63636374
  28965,   22.0950489,   64.3822861,  -3.63636374
  28966,   22.8569469,   64.8782272,  -3.63636374
  28967,    23.618845,   65.3741684,  -3.63636374
  28968,    24.380743,   65.8701096,  -3.63636374
  28969,   17.5236607,   61.4066391,   -4.5454545
  28970,   18.2855587,   61.9025803,   -4.5454545
  28971,   19.0474567,   62.3985214,   -4.5454545
  28972,   19.8093548,   62.8944626,   -4.5454545
  28973,   20.5712528,   63.3904037,   -4.5454545
  28974,    21.333149,   63.8863411,   -4.5454545
  28975,   22.0950489,   64.3822861,   -4.5454545
  28976,   22.8569469,   64.8782272,   -4.5454545
  28977,    23.618845,   65.3741684,   -4.5454545
  28978,    24.380743,   65.8701096,   -4.5454545
  28979,   17.5236607,   61.4066391,   -5.4545455
  28980,   18.2855587,   61.9025803,   -5.4545455
  28981,   19.0474567,   62.3985214,   -5.4545455
  28982,   19.8093548,   62.8944626,   -5.4545455
  28983,   20.5712528,   63.3904037,   -5.4545455
  28984,    21.333149,   63.8863411,   -5.4545455
  28985,   22.0950489,   64.3822861,   -5.4545455
  28986,   22.8569469,   64.8782272,   -5.4545455
  28987,    23.618845,   65.3741684,   -5.4545455
  28988,    24.380743,   65.8701096,   -5.4545455
  28989,   17.5236607,   61.4066391,  -6.36363649
  28990,   18.2855587,   61.9025803,  -6.36363649
  28991,   19.0474567,   62.3985214,  -6.36363649
  28992,   19.8093548,   62.8944626,  -6.36363649
  28993,   20.5712528,   63.3904037,  -6.36363649
  28994,    21.333149,   63.8863411,  -6.36363649
  28995,   22.0950489,   64.3822861,  -6.36363649
  28996,   22.8569469,   64.8782272,  -6.36363649
  28997,    23.618845,   65.3741684,  -6.36363649
  28998,    24.380743,   65.8701096,  -6.36363649
  28999,   17.5236607,   61.4066391,  -7.27272749
  29000,   18.2855587,   61.9025803,  -7.27272749
  29001,   19.0474567,   62.3985214,  -7.27272749
  29002,   19.8093548,   62.8944626,  -7.27272749
  29003,   20.5712528,   63.3904037,  -7.27272749
  29004,    21.333149,   63.8863411,  -7.27272749
  29005,   22.0950489,   64.3822861,  -7.27272749
  29006,   22.8569469,   64.8782272,  -7.27272749
  29007,    23.618845,   65.3741684,  -7.27272749
  29008,    24.380743,   65.8701096,  -7.27272749
  29009,   17.5236607,   61.4066391,  -8.18181801
  29010,   18.2855587,   61.9025803,  -8.18181801
  29011,   19.0474567,   62.3985214,  -8.18181801
  29012,   19.8093548,   62.8944626,  -8.18181801
  29013,   20.5712528,   63.3904037,  -8.18181801
  29014,    21.333149,   63.8863411,  -8.18181801
  29015,   22.0950489,   64.3822861,  -8.18181801
  29016,   22.8569469,   64.8782272,  -8.18181801
  29017,    23.618845,   65.3741684,  -8.18181801
  29018,    24.380743,   65.8701096,  -8.18181801
  29019,   17.5236607,   61.4066391,    -9.090909
  29020,   18.2855587,   61.9025803,    -9.090909
  29021,   19.0474567,   62.3985214,    -9.090909
  29022,   19.8093548,   62.8944626,    -9.090909
  29023,   20.5712528,   63.3904037,    -9.090909
  29024,    21.333149,   63.8863411,    -9.090909
  29025,   22.0950489,   64.3822861,    -9.090909
  29026,   22.8569469,   64.8782272,    -9.090909
  29027,    23.618845,   65.3741684,    -9.090909
  29028,    24.380743,   65.8701096,    -9.090909
  29029,   17.1490555,   61.9624405, -0.909090936
  29030,   17.8946667,   62.4825439, -0.909090936
  29031,   18.6402779,   63.0026512, -0.909090936
  29032,   19.3858891,   63.5227585, -0.909090936
  29033,   20.1315002,   64.0428619, -0.909090936
  29034,   20.8771133,    64.562973, -0.909090936
  29035,   21.6227245,   65.0830765, -0.909090936
  29036,   22.3683357,   65.6031799, -0.909090936
  29037,   23.1139469,    66.123291, -0.909090936
  29038,   23.8595581,   66.6433945, -0.909090936
  29039,   17.1490555,   61.9624405,  -1.81818187
  29040,   17.8946667,   62.4825439,  -1.81818187
  29041,   18.6402779,   63.0026512,  -1.81818187
  29042,   19.3858891,   63.5227585,  -1.81818187
  29043,   20.1315002,   64.0428619,  -1.81818187
  29044,   20.8771133,    64.562973,  -1.81818187
  29045,   21.6227245,   65.0830765,  -1.81818187
  29046,   22.3683357,   65.6031799,  -1.81818187
  29047,   23.1139469,    66.123291,  -1.81818187
  29048,   23.8595581,   66.6433945,  -1.81818187
  29049,   17.1490555,   61.9624405,  -2.72727275
  29050,   17.8946667,   62.4825439,  -2.72727275
  29051,   18.6402779,   63.0026512,  -2.72727275
  29052,   19.3858891,   63.5227585,  -2.72727275
  29053,   20.1315002,   64.0428619,  -2.72727275
  29054,   20.8771133,    64.562973,  -2.72727275
  29055,   21.6227245,   65.0830765,  -2.72727275
  29056,   22.3683357,   65.6031799,  -2.72727275
  29057,   23.1139469,    66.123291,  -2.72727275
  29058,   23.8595581,   66.6433945,  -2.72727275
  29059,   17.1490555,   61.9624405,  -3.63636374
  29060,   17.8946667,   62.4825439,  -3.63636374
  29061,   18.6402779,   63.0026512,  -3.63636374
  29062,   19.3858891,   63.5227585,  -3.63636374
  29063,   20.1315002,   64.0428619,  -3.63636374
  29064,   20.8771133,    64.562973,  -3.63636374
  29065,   21.6227245,   65.0830765,  -3.63636374
  29066,   22.3683357,   65.6031799,  -3.63636374
  29067,   23.1139469,    66.123291,  -3.63636374
  29068,   23.8595581,   66.6433945,  -3.63636374
  29069,   17.1490555,   61.9624405,   -4.5454545
  29070,   17.8946667,   62.4825439,   -4.5454545
  29071,   18.6402779,   63.0026512,   -4.5454545
  29072,   19.3858891,   63.5227585,   -4.5454545
  29073,   20.1315002,   64.0428619,   -4.5454545
  29074,   20.8771133,    64.562973,   -4.5454545
  29075,   21.6227245,   65.0830765,   -4.5454545
  29076,   22.3683357,   65.6031799,   -4.5454545
  29077,   23.1139469,    66.123291,   -4.5454545
  29078,   23.8595581,   66.6433945,   -4.5454545
  29079,   17.1490555,   61.9624405,   -5.4545455
  29080,   17.8946667,   62.4825439,   -5.4545455
  29081,   18.6402779,   63.0026512,   -5.4545455
  29082,   19.3858891,   63.5227585,   -5.4545455
  29083,   20.1315002,   64.0428619,   -5.4545455
  29084,   20.8771133,    64.562973,   -5.4545455
  29085,   21.6227245,   65.0830765,   -5.4545455
  29086,   22.3683357,   65.6031799,   -5.4545455
  29087,   23.1139469,    66.123291,   -5.4545455
  29088,   23.8595581,   66.6433945,   -5.4545455
  29089,   17.1490555,   61.9624405,  -6.36363649
  29090,   17.8946667,   62.4825439,  -6.36363649
  29091,   18.6402779,   63.0026512,  -6.36363649
  29092,   19.3858891,   63.5227585,  -6.36363649
  29093,   20.1315002,   64.0428619,  -6.36363649
  29094,   20.8771133,    64.562973,  -6.36363649
  29095,   21.6227245,   65.0830765,  -6.36363649
  29096,   22.3683357,   65.6031799,  -6.36363649
  29097,   23.1139469,    66.123291,  -6.36363649
  29098,   23.8595581,   66.6433945,  -6.36363649
  29099,   17.1490555,   61.9624405,  -7.27272749
  29100,   17.8946667,   62.4825439,  -7.27272749
  29101,   18.6402779,   63.0026512,  -7.27272749
  29102,   19.3858891,   63.5227585,  -7.27272749
  29103,   20.1315002,   64.0428619,  -7.27272749
  29104,   20.8771133,    64.562973,  -7.27272749
  29105,   21.6227245,   65.0830765,  -7.27272749
  29106,   22.3683357,   65.6031799,  -7.27272749
  29107,   23.1139469,    66.123291,  -7.27272749
  29108,   23.8595581,   66.6433945,  -7.27272749
  29109,   17.1490555,   61.9624405,  -8.18181801
  29110,   17.8946667,   62.4825439,  -8.18181801
  29111,   18.6402779,   63.0026512,  -8.18181801
  29112,   19.3858891,   63.5227585,  -8.18181801
  29113,   20.1315002,   64.0428619,  -8.18181801
  29114,   20.8771133,    64.562973,  -8.18181801
  29115,   21.6227245,   65.0830765,  -8.18181801
  29116,   22.3683357,   65.6031799,  -8.18181801
  29117,   23.1139469,    66.123291,  -8.18181801
  29118,   23.8595581,   66.6433945,  -8.18181801
  29119,   17.1490555,   61.9624405,    -9.090909
  29120,   17.8946667,   62.4825439,    -9.090909
  29121,   18.6402779,   63.0026512,    -9.090909
  29122,   19.3858891,   63.5227585,    -9.090909
  29123,   20.1315002,   64.0428619,    -9.090909
  29124,   20.8771133,    64.562973,    -9.090909
  29125,   21.6227245,   65.0830765,    -9.090909
  29126,   22.3683357,   65.6031799,    -9.090909
  29127,   23.1139469,    66.123291,    -9.090909
  29128,   23.8595581,   66.6433945,    -9.090909
  29129,   16.7568302,   62.5059471, -0.909090936
  29130,   17.4853878,   63.0496826, -0.909090936
  29131,   18.2139454,   63.5934219, -0.909090936
  29132,    18.942503,   64.1371613, -0.909090936
  29133,   19.6710625,   64.6808929, -0.909090936
  29134,    20.399622,   65.2246323, -0.909090936
  29135,   21.1281796,   65.7683716, -0.909090936
  29136,   21.8567371,   66.3121033, -0.909090936
  29137,   22.5852947,   66.8558426, -0.909090936
  29138,   23.3138523,   67.3995819, -0.909090936
  29139,   16.7568302,   62.5059471,  -1.81818187
  29140,   17.4853878,   63.0496826,  -1.81818187
  29141,   18.2139454,   63.5934219,  -1.81818187
  29142,    18.942503,   64.1371613,  -1.81818187
  29143,   19.6710625,   64.6808929,  -1.81818187
  29144,    20.399622,   65.2246323,  -1.81818187
  29145,   21.1281796,   65.7683716,  -1.81818187
  29146,   21.8567371,   66.3121033,  -1.81818187
  29147,   22.5852947,   66.8558426,  -1.81818187
  29148,   23.3138523,   67.3995819,  -1.81818187
  29149,   16.7568302,   62.5059471,  -2.72727275
  29150,   17.4853878,   63.0496826,  -2.72727275
  29151,   18.2139454,   63.5934219,  -2.72727275
  29152,    18.942503,   64.1371613,  -2.72727275
  29153,   19.6710625,   64.6808929,  -2.72727275
  29154,    20.399622,   65.2246323,  -2.72727275
  29155,   21.1281796,   65.7683716,  -2.72727275
  29156,   21.8567371,   66.3121033,  -2.72727275
  29157,   22.5852947,   66.8558426,  -2.72727275
  29158,   23.3138523,   67.3995819,  -2.72727275
  29159,   16.7568302,   62.5059471,  -3.63636374
  29160,   17.4853878,   63.0496826,  -3.63636374
  29161,   18.2139454,   63.5934219,  -3.63636374
  29162,    18.942503,   64.1371613,  -3.63636374
  29163,   19.6710625,   64.6808929,  -3.63636374
  29164,    20.399622,   65.2246323,  -3.63636374
  29165,   21.1281796,   65.7683716,  -3.63636374
  29166,   21.8567371,   66.3121033,  -3.63636374
  29167,   22.5852947,   66.8558426,  -3.63636374
  29168,   23.3138523,   67.3995819,  -3.63636374
  29169,   16.7568302,   62.5059471,   -4.5454545
  29170,   17.4853878,   63.0496826,   -4.5454545
  29171,   18.2139454,   63.5934219,   -4.5454545
  29172,    18.942503,   64.1371613,   -4.5454545
  29173,   19.6710625,   64.6808929,   -4.5454545
  29174,    20.399622,   65.2246323,   -4.5454545
  29175,   21.1281796,   65.7683716,   -4.5454545
  29176,   21.8567371,   66.3121033,   -4.5454545
  29177,   22.5852947,   66.8558426,   -4.5454545
  29178,   23.3138523,   67.3995819,   -4.5454545
  29179,   16.7568302,   62.5059471,   -5.4545455
  29180,   17.4853878,   63.0496826,   -5.4545455
  29181,   18.2139454,   63.5934219,   -5.4545455
  29182,    18.942503,   64.1371613,   -5.4545455
  29183,   19.6710625,   64.6808929,   -5.4545455
  29184,    20.399622,   65.2246323,   -5.4545455
  29185,   21.1281796,   65.7683716,   -5.4545455
  29186,   21.8567371,   66.3121033,   -5.4545455
  29187,   22.5852947,   66.8558426,   -5.4545455
  29188,   23.3138523,   67.3995819,   -5.4545455
  29189,   16.7568302,   62.5059471,  -6.36363649
  29190,   17.4853878,   63.0496826,  -6.36363649
  29191,   18.2139454,   63.5934219,  -6.36363649
  29192,    18.942503,   64.1371613,  -6.36363649
  29193,   19.6710625,   64.6808929,  -6.36363649
  29194,    20.399622,   65.2246323,  -6.36363649
  29195,   21.1281796,   65.7683716,  -6.36363649
  29196,   21.8567371,   66.3121033,  -6.36363649
  29197,   22.5852947,   66.8558426,  -6.36363649
  29198,   23.3138523,   67.3995819,  -6.36363649
  29199,   16.7568302,   62.5059471,  -7.27272749
  29200,   17.4853878,   63.0496826,  -7.27272749
  29201,   18.2139454,   63.5934219,  -7.27272749
  29202,    18.942503,   64.1371613,  -7.27272749
  29203,   19.6710625,   64.6808929,  -7.27272749
  29204,    20.399622,   65.2246323,  -7.27272749
  29205,   21.1281796,   65.7683716,  -7.27272749
  29206,   21.8567371,   66.3121033,  -7.27272749
  29207,   22.5852947,   66.8558426,  -7.27272749
  29208,   23.3138523,   67.3995819,  -7.27272749
  29209,   16.7568302,   62.5059471,  -8.18181801
  29210,   17.4853878,   63.0496826,  -8.18181801
  29211,   18.2139454,   63.5934219,  -8.18181801
  29212,    18.942503,   64.1371613,  -8.18181801
  29213,   19.6710625,   64.6808929,  -8.18181801
  29214,    20.399622,   65.2246323,  -8.18181801
  29215,   21.1281796,   65.7683716,  -8.18181801
  29216,   21.8567371,   66.3121033,  -8.18181801
  29217,   22.5852947,   66.8558426,  -8.18181801
  29218,   23.3138523,   67.3995819,  -8.18181801
  29219,   16.7568302,   62.5059471,    -9.090909
  29220,   17.4853878,   63.0496826,    -9.090909
  29221,   18.2139454,   63.5934219,    -9.090909
  29222,    18.942503,   64.1371613,    -9.090909
  29223,   19.6710625,   64.6808929,    -9.090909
  29224,    20.399622,   65.2246323,    -9.090909
  29225,   21.1281796,   65.7683716,    -9.090909
  29226,   21.8567371,   66.3121033,    -9.090909
  29227,   22.5852947,   66.8558426,    -9.090909
  29228,   23.3138523,   67.3995819,    -9.090909
  29229,   16.3473854,   63.0366058, -0.909090936
  29230,   17.0581417,   63.6034126, -0.909090936
  29231,    17.768898,   64.1702194, -0.909090936
  29232,   18.4796524,     64.73703, -0.909090936
  29233,   19.1904087,   65.3038406, -0.909090936
  29234,   19.9011631,   65.8706512, -0.909090936
  29235,   20.6119194,   66.4374619, -0.909090936
  29236,   21.3226757,   67.0042648, -0.909090936
  29237,   22.0334301,   67.5710754, -0.909090936
  29238,   22.7441864,    68.137886, -0.909090936
  29239,   16.3473854,   63.0366058,  -1.81818187
  29240,   17.0581417,   63.6034126,  -1.81818187
  29241,    17.768898,   64.1702194,  -1.81818187
  29242,   18.4796524,     64.73703,  -1.81818187
  29243,   19.1904087,   65.3038406,  -1.81818187
  29244,   19.9011631,   65.8706512,  -1.81818187
  29245,   20.6119194,   66.4374619,  -1.81818187
  29246,   21.3226757,   67.0042648,  -1.81818187
  29247,   22.0334301,   67.5710754,  -1.81818187
  29248,   22.7441864,    68.137886,  -1.81818187
  29249,   16.3473854,   63.0366058,  -2.72727275
  29250,   17.0581417,   63.6034126,  -2.72727275
  29251,    17.768898,   64.1702194,  -2.72727275
  29252,   18.4796524,     64.73703,  -2.72727275
  29253,   19.1904087,   65.3038406,  -2.72727275
  29254,   19.9011631,   65.8706512,  -2.72727275
  29255,   20.6119194,   66.4374619,  -2.72727275
  29256,   21.3226757,   67.0042648,  -2.72727275
  29257,   22.0334301,   67.5710754,  -2.72727275
  29258,   22.7441864,    68.137886,  -2.72727275
  29259,   16.3473854,   63.0366058,  -3.63636374
  29260,   17.0581417,   63.6034126,  -3.63636374
  29261,    17.768898,   64.1702194,  -3.63636374
  29262,   18.4796524,     64.73703,  -3.63636374
  29263,   19.1904087,   65.3038406,  -3.63636374
  29264,   19.9011631,   65.8706512,  -3.63636374
  29265,   20.6119194,   66.4374619,  -3.63636374
  29266,   21.3226757,   67.0042648,  -3.63636374
  29267,   22.0334301,   67.5710754,  -3.63636374
  29268,   22.7441864,    68.137886,  -3.63636374
  29269,   16.3473854,   63.0366058,   -4.5454545
  29270,   17.0581417,   63.6034126,   -4.5454545
  29271,    17.768898,   64.1702194,   -4.5454545
  29272,   18.4796524,     64.73703,   -4.5454545
  29273,   19.1904087,   65.3038406,   -4.5454545
  29274,   19.9011631,   65.8706512,   -4.5454545
  29275,   20.6119194,   66.4374619,   -4.5454545
  29276,   21.3226757,   67.0042648,   -4.5454545
  29277,   22.0334301,   67.5710754,   -4.5454545
  29278,   22.7441864,    68.137886,   -4.5454545
  29279,   16.3473854,   63.0366058,   -5.4545455
  29280,   17.0581417,   63.6034126,   -5.4545455
  29281,    17.768898,   64.1702194,   -5.4545455
  29282,   18.4796524,     64.73703,   -5.4545455
  29283,   19.1904087,   65.3038406,   -5.4545455
  29284,   19.9011631,   65.8706512,   -5.4545455
  29285,   20.6119194,   66.4374619,   -5.4545455
  29286,   21.3226757,   67.0042648,   -5.4545455
  29287,   22.0334301,   67.5710754,   -5.4545455
  29288,   22.7441864,    68.137886,   -5.4545455
  29289,   16.3473854,   63.0366058,  -6.36363649
  29290,   17.0581417,   63.6034126,  -6.36363649
  29291,    17.768898,   64.1702194,  -6.36363649
  29292,   18.4796524,     64.73703,  -6.36363649
  29293,   19.1904087,   65.3038406,  -6.36363649
  29294,   19.9011631,   65.8706512,  -6.36363649
  29295,   20.6119194,   66.4374619,  -6.36363649
  29296,   21.3226757,   67.0042648,  -6.36363649
  29297,   22.0334301,   67.5710754,  -6.36363649
  29298,   22.7441864,    68.137886,  -6.36363649
  29299,   16.3473854,   63.0366058,  -7.27272749
  29300,   17.0581417,   63.6034126,  -7.27272749
  29301,    17.768898,   64.1702194,  -7.27272749
  29302,   18.4796524,     64.73703,  -7.27272749
  29303,   19.1904087,   65.3038406,  -7.27272749
  29304,   19.9011631,   65.8706512,  -7.27272749
  29305,   20.6119194,   66.4374619,  -7.27272749
  29306,   21.3226757,   67.0042648,  -7.27272749
  29307,   22.0334301,   67.5710754,  -7.27272749
  29308,   22.7441864,    68.137886,  -7.27272749
  29309,   16.3473854,   63.0366058,  -8.18181801
  29310,   17.0581417,   63.6034126,  -8.18181801
  29311,    17.768898,   64.1702194,  -8.18181801
  29312,   18.4796524,     64.73703,  -8.18181801
  29313,   19.1904087,   65.3038406,  -8.18181801
  29314,   19.9011631,   65.8706512,  -8.18181801
  29315,   20.6119194,   66.4374619,  -8.18181801
  29316,   21.3226757,   67.0042648,  -8.18181801
  29317,   22.0334301,   67.5710754,  -8.18181801
  29318,   22.7441864,    68.137886,  -8.18181801
  29319,   16.3473854,   63.0366058,    -9.090909
  29320,   17.0581417,   63.6034126,    -9.090909
  29321,    17.768898,   64.1702194,    -9.090909
  29322,   18.4796524,     64.73703,    -9.090909
  29323,   19.1904087,   65.3038406,    -9.090909
  29324,   19.9011631,   65.8706512,    -9.090909
  29325,   20.6119194,   66.4374619,    -9.090909
  29326,   21.3226757,   67.0042648,    -9.090909
  29327,   22.0334301,   67.5710754,    -9.090909
  29328,   22.7441864,    68.137886,    -9.090909
  29329,   15.9211416,   63.5538673, -0.909090936
  29330,   16.6133671,   64.1431656, -0.909090936
  29331,   17.3055897,     64.73246, -0.909090936
  29332,   17.9978142,   65.3217621, -0.909090936
  29333,   18.6900368,   65.9110641, -0.909090936
  29334,   19.3822613,   66.5003586, -0.909090936
  29335,   20.0744839,   67.0896606, -0.909090936
  29336,   20.7667084,   67.6789551, -0.909090936
  29337,    21.458931,   68.2682571, -0.909090936
  29338,   22.1511555,   68.8575516, -0.909090936
  29339,   15.9211416,   63.5538673,  -1.81818187
  29340,   16.6133671,   64.1431656,  -1.81818187
  29341,   17.3055897,     64.73246,  -1.81818187
  29342,   17.9978142,   65.3217621,  -1.81818187
  29343,   18.6900368,   65.9110641,  -1.81818187
  29344,   19.3822613,   66.5003586,  -1.81818187
  29345,   20.0744839,   67.0896606,  -1.81818187
  29346,   20.7667084,   67.6789551,  -1.81818187
  29347,    21.458931,   68.2682571,  -1.81818187
  29348,   22.1511555,   68.8575516,  -1.81818187
  29349,   15.9211416,   63.5538673,  -2.72727275
  29350,   16.6133671,   64.1431656,  -2.72727275
  29351,   17.3055897,     64.73246,  -2.72727275
  29352,   17.9978142,   65.3217621,  -2.72727275
  29353,   18.6900368,   65.9110641,  -2.72727275
  29354,   19.3822613,   66.5003586,  -2.72727275
  29355,   20.0744839,   67.0896606,  -2.72727275
  29356,   20.7667084,   67.6789551,  -2.72727275
  29357,    21.458931,   68.2682571,  -2.72727275
  29358,   22.1511555,   68.8575516,  -2.72727275
  29359,   15.9211416,   63.5538673,  -3.63636374
  29360,   16.6133671,   64.1431656,  -3.63636374
  29361,   17.3055897,     64.73246,  -3.63636374
  29362,   17.9978142,   65.3217621,  -3.63636374
  29363,   18.6900368,   65.9110641,  -3.63636374
  29364,   19.3822613,   66.5003586,  -3.63636374
  29365,   20.0744839,   67.0896606,  -3.63636374
  29366,   20.7667084,   67.6789551,  -3.63636374
  29367,    21.458931,   68.2682571,  -3.63636374
  29368,   22.1511555,   68.8575516,  -3.63636374
  29369,   15.9211416,   63.5538673,   -4.5454545
  29370,   16.6133671,   64.1431656,   -4.5454545
  29371,   17.3055897,     64.73246,   -4.5454545
  29372,   17.9978142,   65.3217621,   -4.5454545
  29373,   18.6900368,   65.9110641,   -4.5454545
  29374,   19.3822613,   66.5003586,   -4.5454545
  29375,   20.0744839,   67.0896606,   -4.5454545
  29376,   20.7667084,   67.6789551,   -4.5454545
  29377,    21.458931,   68.2682571,   -4.5454545
  29378,   22.1511555,   68.8575516,   -4.5454545
  29379,   15.9211416,   63.5538673,   -5.4545455
  29380,   16.6133671,   64.1431656,   -5.4545455
  29381,   17.3055897,     64.73246,   -5.4545455
  29382,   17.9978142,   65.3217621,   -5.4545455
  29383,   18.6900368,   65.9110641,   -5.4545455
  29384,   19.3822613,   66.5003586,   -5.4545455
  29385,   20.0744839,   67.0896606,   -5.4545455
  29386,   20.7667084,   67.6789551,   -5.4545455
  29387,    21.458931,   68.2682571,   -5.4545455
  29388,   22.1511555,   68.8575516,   -5.4545455
  29389,   15.9211416,   63.5538673,  -6.36363649
  29390,   16.6133671,   64.1431656,  -6.36363649
  29391,   17.3055897,     64.73246,  -6.36363649
  29392,   17.9978142,   65.3217621,  -6.36363649
  29393,   18.6900368,   65.9110641,  -6.36363649
  29394,   19.3822613,   66.5003586,  -6.36363649
  29395,   20.0744839,   67.0896606,  -6.36363649
  29396,   20.7667084,   67.6789551,  -6.36363649
  29397,    21.458931,   68.2682571,  -6.36363649
  29398,   22.1511555,   68.8575516,  -6.36363649
  29399,   15.9211416,   63.5538673,  -7.27272749
  29400,   16.6133671,   64.1431656,  -7.27272749
  29401,   17.3055897,     64.73246,  -7.27272749
  29402,   17.9978142,   65.3217621,  -7.27272749
  29403,   18.6900368,   65.9110641,  -7.27272749
  29404,   19.3822613,   66.5003586,  -7.27272749
  29405,   20.0744839,   67.0896606,  -7.27272749
  29406,   20.7667084,   67.6789551,  -7.27272749
  29407,    21.458931,   68.2682571,  -7.27272749
  29408,   22.1511555,   68.8575516,  -7.27272749
  29409,   15.9211416,   63.5538673,  -8.18181801
  29410,   16.6133671,   64.1431656,  -8.18181801
  29411,   17.3055897,     64.73246,  -8.18181801
  29412,   17.9978142,   65.3217621,  -8.18181801
  29413,   18.6900368,   65.9110641,  -8.18181801
  29414,   19.3822613,   66.5003586,  -8.18181801
  29415,   20.0744839,   67.0896606,  -8.18181801
  29416,   20.7667084,   67.6789551,  -8.18181801
  29417,    21.458931,   68.2682571,  -8.18181801
  29418,   22.1511555,   68.8575516,  -8.18181801
  29419,   15.9211416,   63.5538673,    -9.090909
  29420,   16.6133671,   64.1431656,    -9.090909
  29421,   17.3055897,     64.73246,    -9.090909
  29422,   17.9978142,   65.3217621,    -9.090909
  29423,   18.6900368,   65.9110641,    -9.090909
  29424,   19.3822613,   66.5003586,    -9.090909
  29425,   20.0744839,   67.0896606,    -9.090909
  29426,   20.7667084,   67.6789551,    -9.090909
  29427,    21.458931,   68.2682571,    -9.090909
  29428,   22.1511555,   68.8575516,    -9.090909
  29429,   15.4785395,   64.0571976, -0.909090936
  29430,   16.1515198,   64.6683807, -0.909090936
  29431,   16.8244991,   65.2795639, -0.909090936
  29432,   17.4974804,   65.8907471, -0.909090936
  29433,   18.1704597,   66.5019302, -0.909090936
  29434,   18.8434372,   67.1131134, -0.909090936
  29435,   19.5164185,   67.7242966, -0.909090936
  29436,   20.1893978,   68.3354797, -0.909090936
  29437,   20.8623772,   68.9466629, -0.909090936
  29438,   21.5353584,   69.5578461, -0.909090936
  29439,   15.4785395,   64.0571976,  -1.81818187
  29440,   16.1515198,   64.6683807,  -1.81818187
  29441,   16.8244991,   65.2795639,  -1.81818187
  29442,   17.4974804,   65.8907471,  -1.81818187
  29443,   18.1704597,   66.5019302,  -1.81818187
  29444,   18.8434372,   67.1131134,  -1.81818187
  29445,   19.5164185,   67.7242966,  -1.81818187
  29446,   20.1893978,   68.3354797,  -1.81818187
  29447,   20.8623772,   68.9466629,  -1.81818187
  29448,   21.5353584,   69.5578461,  -1.81818187
  29449,   15.4785395,   64.0571976,  -2.72727275
  29450,   16.1515198,   64.6683807,  -2.72727275
  29451,   16.8244991,   65.2795639,  -2.72727275
  29452,   17.4974804,   65.8907471,  -2.72727275
  29453,   18.1704597,   66.5019302,  -2.72727275
  29454,   18.8434372,   67.1131134,  -2.72727275
  29455,   19.5164185,   67.7242966,  -2.72727275
  29456,   20.1893978,   68.3354797,  -2.72727275
  29457,   20.8623772,   68.9466629,  -2.72727275
  29458,   21.5353584,   69.5578461,  -2.72727275
  29459,   15.4785395,   64.0571976,  -3.63636374
  29460,   16.1515198,   64.6683807,  -3.63636374
  29461,   16.8244991,   65.2795639,  -3.63636374
  29462,   17.4974804,   65.8907471,  -3.63636374
  29463,   18.1704597,   66.5019302,  -3.63636374
  29464,   18.8434372,   67.1131134,  -3.63636374
  29465,   19.5164185,   67.7242966,  -3.63636374
  29466,   20.1893978,   68.3354797,  -3.63636374
  29467,   20.8623772,   68.9466629,  -3.63636374
  29468,   21.5353584,   69.5578461,  -3.63636374
  29469,   15.4785395,   64.0571976,   -4.5454545
  29470,   16.1515198,   64.6683807,   -4.5454545
  29471,   16.8244991,   65.2795639,   -4.5454545
  29472,   17.4974804,   65.8907471,   -4.5454545
  29473,   18.1704597,   66.5019302,   -4.5454545
  29474,   18.8434372,   67.1131134,   -4.5454545
  29475,   19.5164185,   67.7242966,   -4.5454545
  29476,   20.1893978,   68.3354797,   -4.5454545
  29477,   20.8623772,   68.9466629,   -4.5454545
  29478,   21.5353584,   69.5578461,   -4.5454545
  29479,   15.4785395,   64.0571976,   -5.4545455
  29480,   16.1515198,   64.6683807,   -5.4545455
  29481,   16.8244991,   65.2795639,   -5.4545455
  29482,   17.4974804,   65.8907471,   -5.4545455
  29483,   18.1704597,   66.5019302,   -5.4545455
  29484,   18.8434372,   67.1131134,   -5.4545455
  29485,   19.5164185,   67.7242966,   -5.4545455
  29486,   20.1893978,   68.3354797,   -5.4545455
  29487,   20.8623772,   68.9466629,   -5.4545455
  29488,   21.5353584,   69.5578461,   -5.4545455
  29489,   15.4785395,   64.0571976,  -6.36363649
  29490,   16.1515198,   64.6683807,  -6.36363649
  29491,   16.8244991,   65.2795639,  -6.36363649
  29492,   17.4974804,   65.8907471,  -6.36363649
  29493,   18.1704597,   66.5019302,  -6.36363649
  29494,   18.8434372,   67.1131134,  -6.36363649
  29495,   19.5164185,   67.7242966,  -6.36363649
  29496,   20.1893978,   68.3354797,  -6.36363649
  29497,   20.8623772,   68.9466629,  -6.36363649
  29498,   21.5353584,   69.5578461,  -6.36363649
  29499,   15.4785395,   64.0571976,  -7.27272749
  29500,   16.1515198,   64.6683807,  -7.27272749
  29501,   16.8244991,   65.2795639,  -7.27272749
  29502,   17.4974804,   65.8907471,  -7.27272749
  29503,   18.1704597,   66.5019302,  -7.27272749
  29504,   18.8434372,   67.1131134,  -7.27272749
  29505,   19.5164185,   67.7242966,  -7.27272749
  29506,   20.1893978,   68.3354797,  -7.27272749
  29507,   20.8623772,   68.9466629,  -7.27272749
  29508,   21.5353584,   69.5578461,  -7.27272749
  29509,   15.4785395,   64.0571976,  -8.18181801
  29510,   16.1515198,   64.6683807,  -8.18181801
  29511,   16.8244991,   65.2795639,  -8.18181801
  29512,   17.4974804,   65.8907471,  -8.18181801
  29513,   18.1704597,   66.5019302,  -8.18181801
  29514,   18.8434372,   67.1131134,  -8.18181801
  29515,   19.5164185,   67.7242966,  -8.18181801
  29516,   20.1893978,   68.3354797,  -8.18181801
  29517,   20.8623772,   68.9466629,  -8.18181801
  29518,   21.5353584,   69.5578461,  -8.18181801
  29519,   15.4785395,   64.0571976,    -9.090909
  29520,   16.1515198,   64.6683807,    -9.090909
  29521,   16.8244991,   65.2795639,    -9.090909
  29522,   17.4974804,   65.8907471,    -9.090909
  29523,   18.1704597,   66.5019302,    -9.090909
  29524,   18.8434372,   67.1131134,    -9.090909
  29525,   19.5164185,   67.7242966,    -9.090909
  29526,   20.1893978,   68.3354797,    -9.090909
  29527,   20.8623772,   68.9466629,    -9.090909
  29528,   21.5353584,   69.5578461,    -9.090909
  29529,   15.0200319,   64.5460892, -0.909090936
  29530,   15.6730766,   65.1785278, -0.909090936
  29531,   16.3261223,   65.8109665, -0.909090936
  29532,    16.979166,   66.4434052, -0.909090936
  29533,   17.6322117,   67.0758438, -0.909090936
  29534,   18.2852554,   67.7082825, -0.909090936
  29535,   18.9383011,   68.3407211, -0.909090936
  29536,   19.5913467,   68.9731598, -0.909090936
  29537,   20.2443905,   69.6055984, -0.909090936
  29538,   20.8974361,   70.2380371, -0.909090936
  29539,   15.0200319,   64.5460892,  -1.81818187
  29540,   15.6730766,   65.1785278,  -1.81818187
  29541,   16.3261223,   65.8109665,  -1.81818187
  29542,    16.979166,   66.4434052,  -1.81818187
  29543,   17.6322117,   67.0758438,  -1.81818187
  29544,   18.2852554,   67.7082825,  -1.81818187
  29545,   18.9383011,   68.3407211,  -1.81818187
  29546,   19.5913467,   68.9731598,  -1.81818187
  29547,   20.2443905,   69.6055984,  -1.81818187
  29548,   20.8974361,   70.2380371,  -1.81818187
  29549,   15.0200319,   64.5460892,  -2.72727275
  29550,   15.6730766,   65.1785278,  -2.72727275
  29551,   16.3261223,   65.8109665,  -2.72727275
  29552,    16.979166,   66.4434052,  -2.72727275
  29553,   17.6322117,   67.0758438,  -2.72727275
  29554,   18.2852554,   67.7082825,  -2.72727275
  29555,   18.9383011,   68.3407211,  -2.72727275
  29556,   19.5913467,   68.9731598,  -2.72727275
  29557,   20.2443905,   69.6055984,  -2.72727275
  29558,   20.8974361,   70.2380371,  -2.72727275
  29559,   15.0200319,   64.5460892,  -3.63636374
  29560,   15.6730766,   65.1785278,  -3.63636374
  29561,   16.3261223,   65.8109665,  -3.63636374
  29562,    16.979166,   66.4434052,  -3.63636374
  29563,   17.6322117,   67.0758438,  -3.63636374
  29564,   18.2852554,   67.7082825,  -3.63636374
  29565,   18.9383011,   68.3407211,  -3.63636374
  29566,   19.5913467,   68.9731598,  -3.63636374
  29567,   20.2443905,   69.6055984,  -3.63636374
  29568,   20.8974361,   70.2380371,  -3.63636374
  29569,   15.0200319,   64.5460892,   -4.5454545
  29570,   15.6730766,   65.1785278,   -4.5454545
  29571,   16.3261223,   65.8109665,   -4.5454545
  29572,    16.979166,   66.4434052,   -4.5454545
  29573,   17.6322117,   67.0758438,   -4.5454545
  29574,   18.2852554,   67.7082825,   -4.5454545
  29575,   18.9383011,   68.3407211,   -4.5454545
  29576,   19.5913467,   68.9731598,   -4.5454545
  29577,   20.2443905,   69.6055984,   -4.5454545
  29578,   20.8974361,   70.2380371,   -4.5454545
  29579,   15.0200319,   64.5460892,   -5.4545455
  29580,   15.6730766,   65.1785278,   -5.4545455
  29581,   16.3261223,   65.8109665,   -5.4545455
  29582,    16.979166,   66.4434052,   -5.4545455
  29583,   17.6322117,   67.0758438,   -5.4545455
  29584,   18.2852554,   67.7082825,   -5.4545455
  29585,   18.9383011,   68.3407211,   -5.4545455
  29586,   19.5913467,   68.9731598,   -5.4545455
  29587,   20.2443905,   69.6055984,   -5.4545455
  29588,   20.8974361,   70.2380371,   -5.4545455
  29589,   15.0200319,   64.5460892,  -6.36363649
  29590,   15.6730766,   65.1785278,  -6.36363649
  29591,   16.3261223,   65.8109665,  -6.36363649
  29592,    16.979166,   66.4434052,  -6.36363649
  29593,   17.6322117,   67.0758438,  -6.36363649
  29594,   18.2852554,   67.7082825,  -6.36363649
  29595,   18.9383011,   68.3407211,  -6.36363649
  29596,   19.5913467,   68.9731598,  -6.36363649
  29597,   20.2443905,   69.6055984,  -6.36363649
  29598,   20.8974361,   70.2380371,  -6.36363649
  29599,   15.0200319,   64.5460892,  -7.27272749
  29600,   15.6730766,   65.1785278,  -7.27272749
  29601,   16.3261223,   65.8109665,  -7.27272749
  29602,    16.979166,   66.4434052,  -7.27272749
  29603,   17.6322117,   67.0758438,  -7.27272749
  29604,   18.2852554,   67.7082825,  -7.27272749
  29605,   18.9383011,   68.3407211,  -7.27272749
  29606,   19.5913467,   68.9731598,  -7.27272749
  29607,   20.2443905,   69.6055984,  -7.27272749
  29608,   20.8974361,   70.2380371,  -7.27272749
  29609,   15.0200319,   64.5460892,  -8.18181801
  29610,   15.6730766,   65.1785278,  -8.18181801
  29611,   16.3261223,   65.8109665,  -8.18181801
  29612,    16.979166,   66.4434052,  -8.18181801
  29613,   17.6322117,   67.0758438,  -8.18181801
  29614,   18.2852554,   67.7082825,  -8.18181801
  29615,   18.9383011,   68.3407211,  -8.18181801
  29616,   19.5913467,   68.9731598,  -8.18181801
  29617,   20.2443905,   69.6055984,  -8.18181801
  29618,   20.8974361,   70.2380371,  -8.18181801
  29619,   15.0200319,   64.5460892,    -9.090909
  29620,   15.6730766,   65.1785278,    -9.090909
  29621,   16.3261223,   65.8109665,    -9.090909
  29622,    16.979166,   66.4434052,    -9.090909
  29623,   17.6322117,   67.0758438,    -9.090909
  29624,   18.2852554,   67.7082825,    -9.090909
  29625,   18.9383011,   68.3407211,    -9.090909
  29626,   19.5913467,   68.9731598,    -9.090909
  29627,   20.2443905,   69.6055984,    -9.090909
  29628,   20.8974361,   70.2380371,    -9.090909
  29629,   14.5460892,   65.0200348, -0.909090936
  29630,   15.1785278,   65.6730804, -0.909090936
  29631,   15.8109665,   66.3261185, -0.909090936
  29632,   16.4434032,   66.9791641, -0.909090936
  29633,   17.0758419,   67.6322098, -0.909090936
  29634,   17.7082806,   68.2852554, -0.909090936
  29635,   18.3407192,   68.9383011, -0.909090936
  29636,   18.9731579,   69.5913467, -0.909090936
  29637,   19.6055965,   70.2443924, -0.909090936
  29638,   20.2380352,    70.897438, -0.909090936
  29639,   14.5460892,   65.0200348,  -1.81818187
  29640,   15.1785278,   65.6730804,  -1.81818187
  29641,   15.8109665,   66.3261185,  -1.81818187
  29642,   16.4434032,   66.9791641,  -1.81818187
  29643,   17.0758419,   67.6322098,  -1.81818187
  29644,   17.7082806,   68.2852554,  -1.81818187
  29645,   18.3407192,   68.9383011,  -1.81818187
  29646,   18.9731579,   69.5913467,  -1.81818187
  29647,   19.6055965,   70.2443924,  -1.81818187
  29648,   20.2380352,    70.897438,  -1.81818187
  29649,   14.5460892,   65.0200348,  -2.72727275
  29650,   15.1785278,   65.6730804,  -2.72727275
  29651,   15.8109665,   66.3261185,  -2.72727275
  29652,   16.4434032,   66.9791641,  -2.72727275
  29653,   17.0758419,   67.6322098,  -2.72727275
  29654,   17.7082806,   68.2852554,  -2.72727275
  29655,   18.3407192,   68.9383011,  -2.72727275
  29656,   18.9731579,   69.5913467,  -2.72727275
  29657,   19.6055965,   70.2443924,  -2.72727275
  29658,   20.2380352,    70.897438,  -2.72727275
  29659,   14.5460892,   65.0200348,  -3.63636374
  29660,   15.1785278,   65.6730804,  -3.63636374
  29661,   15.8109665,   66.3261185,  -3.63636374
  29662,   16.4434032,   66.9791641,  -3.63636374
  29663,   17.0758419,   67.6322098,  -3.63636374
  29664,   17.7082806,   68.2852554,  -3.63636374
  29665,   18.3407192,   68.9383011,  -3.63636374
  29666,   18.9731579,   69.5913467,  -3.63636374
  29667,   19.6055965,   70.2443924,  -3.63636374
  29668,   20.2380352,    70.897438,  -3.63636374
  29669,   14.5460892,   65.0200348,   -4.5454545
  29670,   15.1785278,   65.6730804,   -4.5454545
  29671,   15.8109665,   66.3261185,   -4.5454545
  29672,   16.4434032,   66.9791641,   -4.5454545
  29673,   17.0758419,   67.6322098,   -4.5454545
  29674,   17.7082806,   68.2852554,   -4.5454545
  29675,   18.3407192,   68.9383011,   -4.5454545
  29676,   18.9731579,   69.5913467,   -4.5454545
  29677,   19.6055965,   70.2443924,   -4.5454545
  29678,   20.2380352,    70.897438,   -4.5454545
  29679,   14.5460892,   65.0200348,   -5.4545455
  29680,   15.1785278,   65.6730804,   -5.4545455
  29681,   15.8109665,   66.3261185,   -5.4545455
  29682,   16.4434032,   66.9791641,   -5.4545455
  29683,   17.0758419,   67.6322098,   -5.4545455
  29684,   17.7082806,   68.2852554,   -5.4545455
  29685,   18.3407192,   68.9383011,   -5.4545455
  29686,   18.9731579,   69.5913467,   -5.4545455
  29687,   19.6055965,   70.2443924,   -5.4545455
  29688,   20.2380352,    70.897438,   -5.4545455
  29689,   14.5460892,   65.0200348,  -6.36363649
  29690,   15.1785278,   65.6730804,  -6.36363649
  29691,   15.8109665,   66.3261185,  -6.36363649
  29692,   16.4434032,   66.9791641,  -6.36363649
  29693,   17.0758419,   67.6322098,  -6.36363649
  29694,   17.7082806,   68.2852554,  -6.36363649
  29695,   18.3407192,   68.9383011,  -6.36363649
  29696,   18.9731579,   69.5913467,  -6.36363649
  29697,   19.6055965,   70.2443924,  -6.36363649
  29698,   20.2380352,    70.897438,  -6.36363649
  29699,   14.5460892,   65.0200348,  -7.27272749
  29700,   15.1785278,   65.6730804,  -7.27272749
  29701,   15.8109665,   66.3261185,  -7.27272749
  29702,   16.4434032,   66.9791641,  -7.27272749
  29703,   17.0758419,   67.6322098,  -7.27272749
  29704,   17.7082806,   68.2852554,  -7.27272749
  29705,   18.3407192,   68.9383011,  -7.27272749
  29706,   18.9731579,   69.5913467,  -7.27272749
  29707,   19.6055965,   70.2443924,  -7.27272749
  29708,   20.2380352,    70.897438,  -7.27272749
  29709,   14.5460892,   65.0200348,  -8.18181801
  29710,   15.1785278,   65.6730804,  -8.18181801
  29711,   15.8109665,   66.3261185,  -8.18181801
  29712,   16.4434032,   66.9791641,  -8.18181801
  29713,   17.0758419,   67.6322098,  -8.18181801
  29714,   17.7082806,   68.2852554,  -8.18181801
  29715,   18.3407192,   68.9383011,  -8.18181801
  29716,   18.9731579,   69.5913467,  -8.18181801
  29717,   19.6055965,   70.2443924,  -8.18181801
  29718,   20.2380352,    70.897438,  -8.18181801
  29719,   14.5460892,   65.0200348,    -9.090909
  29720,   15.1785278,   65.6730804,    -9.090909
  29721,   15.8109665,   66.3261185,    -9.090909
  29722,   16.4434032,   66.9791641,    -9.090909
  29723,   17.0758419,   67.6322098,    -9.090909
  29724,   17.7082806,   68.2852554,    -9.090909
  29725,   18.3407192,   68.9383011,    -9.090909
  29726,   18.9731579,   69.5913467,    -9.090909
  29727,   19.6055965,   70.2443924,    -9.090909
  29728,   20.2380352,    70.897438,    -9.090909
  29729,   14.0572014,   65.4785385, -0.909090936
  29730,   14.6683826,   66.1515198, -0.909090936
  29731,   15.2795658,    66.824501, -0.909090936
  29732,    15.890748,   67.4974823, -0.909090936
  29733,   16.5019302,   68.1704636, -0.909090936
  29734,   17.1131134,   68.8434372, -0.909090936
  29735,   17.7242966,   69.5164185, -0.909090936
  29736,   18.3354778,   70.1893997, -0.909090936
  29737,   18.9466591,    70.862381, -0.909090936
  29738,   19.5578423,   71.5353622, -0.909090936
  29739,   14.0572014,   65.4785385,  -1.81818187
  29740,   14.6683826,   66.1515198,  -1.81818187
  29741,   15.2795658,    66.824501,  -1.81818187
  29742,    15.890748,   67.4974823,  -1.81818187
  29743,   16.5019302,   68.1704636,  -1.81818187
  29744,   17.1131134,   68.8434372,  -1.81818187
  29745,   17.7242966,   69.5164185,  -1.81818187
  29746,   18.3354778,   70.1893997,  -1.81818187
  29747,   18.9466591,    70.862381,  -1.81818187
  29748,   19.5578423,   71.5353622,  -1.81818187
  29749,   14.0572014,   65.4785385,  -2.72727275
  29750,   14.6683826,   66.1515198,  -2.72727275
  29751,   15.2795658,    66.824501,  -2.72727275
  29752,    15.890748,   67.4974823,  -2.72727275
  29753,   16.5019302,   68.1704636,  -2.72727275
  29754,   17.1131134,   68.8434372,  -2.72727275
  29755,   17.7242966,   69.5164185,  -2.72727275
  29756,   18.3354778,   70.1893997,  -2.72727275
  29757,   18.9466591,    70.862381,  -2.72727275
  29758,   19.5578423,   71.5353622,  -2.72727275
  29759,   14.0572014,   65.4785385,  -3.63636374
  29760,   14.6683826,   66.1515198,  -3.63636374
  29761,   15.2795658,    66.824501,  -3.63636374
  29762,    15.890748,   67.4974823,  -3.63636374
  29763,   16.5019302,   68.1704636,  -3.63636374
  29764,   17.1131134,   68.8434372,  -3.63636374
  29765,   17.7242966,   69.5164185,  -3.63636374
  29766,   18.3354778,   70.1893997,  -3.63636374
  29767,   18.9466591,    70.862381,  -3.63636374
  29768,   19.5578423,   71.5353622,  -3.63636374
  29769,   14.0572014,   65.4785385,   -4.5454545
  29770,   14.6683826,   66.1515198,   -4.5454545
  29771,   15.2795658,    66.824501,   -4.5454545
  29772,    15.890748,   67.4974823,   -4.5454545
  29773,   16.5019302,   68.1704636,   -4.5454545
  29774,   17.1131134,   68.8434372,   -4.5454545
  29775,   17.7242966,   69.5164185,   -4.5454545
  29776,   18.3354778,   70.1893997,   -4.5454545
  29777,   18.9466591,    70.862381,   -4.5454545
  29778,   19.5578423,   71.5353622,   -4.5454545
  29779,   14.0572014,   65.4785385,   -5.4545455
  29780,   14.6683826,   66.1515198,   -5.4545455
  29781,   15.2795658,    66.824501,   -5.4545455
  29782,    15.890748,   67.4974823,   -5.4545455
  29783,   16.5019302,   68.1704636,   -5.4545455
  29784,   17.1131134,   68.8434372,   -5.4545455
  29785,   17.7242966,   69.5164185,   -5.4545455
  29786,   18.3354778,   70.1893997,   -5.4545455
  29787,   18.9466591,    70.862381,   -5.4545455
  29788,   19.5578423,   71.5353622,   -5.4545455
  29789,   14.0572014,   65.4785385,  -6.36363649
  29790,   14.6683826,   66.1515198,  -6.36363649
  29791,   15.2795658,    66.824501,  -6.36363649
  29792,    15.890748,   67.4974823,  -6.36363649
  29793,   16.5019302,   68.1704636,  -6.36363649
  29794,   17.1131134,   68.8434372,  -6.36363649
  29795,   17.7242966,   69.5164185,  -6.36363649
  29796,   18.3354778,   70.1893997,  -6.36363649
  29797,   18.9466591,    70.862381,  -6.36363649
  29798,   19.5578423,   71.5353622,  -6.36363649
  29799,   14.0572014,   65.4785385,  -7.27272749
  29800,   14.6683826,   66.1515198,  -7.27272749
  29801,   15.2795658,    66.824501,  -7.27272749
  29802,    15.890748,   67.4974823,  -7.27272749
  29803,   16.5019302,   68.1704636,  -7.27272749
  29804,   17.1131134,   68.8434372,  -7.27272749
  29805,   17.7242966,   69.5164185,  -7.27272749
  29806,   18.3354778,   70.1893997,  -7.27272749
  29807,   18.9466591,    70.862381,  -7.27272749
  29808,   19.5578423,   71.5353622,  -7.27272749
  29809,   14.0572014,   65.4785385,  -8.18181801
  29810,   14.6683826,   66.1515198,  -8.18181801
  29811,   15.2795658,    66.824501,  -8.18181801
  29812,    15.890748,   67.4974823,  -8.18181801
  29813,   16.5019302,   68.1704636,  -8.18181801
  29814,   17.1131134,   68.8434372,  -8.18181801
  29815,   17.7242966,   69.5164185,  -8.18181801
  29816,   18.3354778,   70.1893997,  -8.18181801
  29817,   18.9466591,    70.862381,  -8.18181801
  29818,   19.5578423,   71.5353622,  -8.18181801
  29819,   14.0572014,   65.4785385,    -9.090909
  29820,   14.6683826,   66.1515198,    -9.090909
  29821,   15.2795658,    66.824501,    -9.090909
  29822,    15.890748,   67.4974823,    -9.090909
  29823,   16.5019302,   68.1704636,    -9.090909
  29824,   17.1131134,   68.8434372,    -9.090909
  29825,   17.7242966,   69.5164185,    -9.090909
  29826,   18.3354778,   70.1893997,    -9.090909
  29827,   18.9466591,    70.862381,    -9.090909
  29828,   19.5578423,   71.5353622,    -9.090909
  29829,   13.5538654,   65.9211426, -0.909090936
  29830,   14.1431646,   66.6133652, -0.909090936
  29831,   14.7324638,   67.3055878, -0.909090936
  29832,   15.3217621,   67.9978104, -0.909090936
  29833,   15.9110603,   68.6900406, -0.909090936
  29834,   16.5003586,   69.3822632, -0.909090936
  29835,   17.0896568,   70.0744858, -0.909090936
  29836,   17.6789589,   70.7667084, -0.909090936
  29837,   18.2682571,    71.458931, -0.909090936
  29838,   18.8575554,   72.1511536, -0.909090936
  29839,   13.5538654,   65.9211426,  -1.81818187
  29840,   14.1431646,   66.6133652,  -1.81818187
  29841,   14.7324638,   67.3055878,  -1.81818187
  29842,   15.3217621,   67.9978104,  -1.81818187
  29843,   15.9110603,   68.6900406,  -1.81818187
  29844,   16.5003586,   69.3822632,  -1.81818187
  29845,   17.0896568,   70.0744858,  -1.81818187
  29846,   17.6789589,   70.7667084,  -1.81818187
  29847,   18.2682571,    71.458931,  -1.81818187
  29848,   18.8575554,   72.1511536,  -1.81818187
  29849,   13.5538654,   65.9211426,  -2.72727275
  29850,   14.1431646,   66.6133652,  -2.72727275
  29851,   14.7324638,   67.3055878,  -2.72727275
  29852,   15.3217621,   67.9978104,  -2.72727275
  29853,   15.9110603,   68.6900406,  -2.72727275
  29854,   16.5003586,   69.3822632,  -2.72727275
  29855,   17.0896568,   70.0744858,  -2.72727275
  29856,   17.6789589,   70.7667084,  -2.72727275
  29857,   18.2682571,    71.458931,  -2.72727275
  29858,   18.8575554,   72.1511536,  -2.72727275
  29859,   13.5538654,   65.9211426,  -3.63636374
  29860,   14.1431646,   66.6133652,  -3.63636374
  29861,   14.7324638,   67.3055878,  -3.63636374
  29862,   15.3217621,   67.9978104,  -3.63636374
  29863,   15.9110603,   68.6900406,  -3.63636374
  29864,   16.5003586,   69.3822632,  -3.63636374
  29865,   17.0896568,   70.0744858,  -3.63636374
  29866,   17.6789589,   70.7667084,  -3.63636374
  29867,   18.2682571,    71.458931,  -3.63636374
  29868,   18.8575554,   72.1511536,  -3.63636374
  29869,   13.5538654,   65.9211426,   -4.5454545
  29870,   14.1431646,   66.6133652,   -4.5454545
  29871,   14.7324638,   67.3055878,   -4.5454545
  29872,   15.3217621,   67.9978104,   -4.5454545
  29873,   15.9110603,   68.6900406,   -4.5454545
  29874,   16.5003586,   69.3822632,   -4.5454545
  29875,   17.0896568,   70.0744858,   -4.5454545
  29876,   17.6789589,   70.7667084,   -4.5454545
  29877,   18.2682571,    71.458931,   -4.5454545
  29878,   18.8575554,   72.1511536,   -4.5454545
  29879,   13.5538654,   65.9211426,   -5.4545455
  29880,   14.1431646,   66.6133652,   -5.4545455
  29881,   14.7324638,   67.3055878,   -5.4545455
  29882,   15.3217621,   67.9978104,   -5.4545455
  29883,   15.9110603,   68.6900406,   -5.4545455
  29884,   16.5003586,   69.3822632,   -5.4545455
  29885,   17.0896568,   70.0744858,   -5.4545455
  29886,   17.6789589,   70.7667084,   -5.4545455
  29887,   18.2682571,    71.458931,   -5.4545455
  29888,   18.8575554,   72.1511536,   -5.4545455
  29889,   13.5538654,   65.9211426,  -6.36363649
  29890,   14.1431646,   66.6133652,  -6.36363649
  29891,   14.7324638,   67.3055878,  -6.36363649
  29892,   15.3217621,   67.9978104,  -6.36363649
  29893,   15.9110603,   68.6900406,  -6.36363649
  29894,   16.5003586,   69.3822632,  -6.36363649
  29895,   17.0896568,   70.0744858,  -6.36363649
  29896,   17.6789589,   70.7667084,  -6.36363649
  29897,   18.2682571,    71.458931,  -6.36363649
  29898,   18.8575554,   72.1511536,  -6.36363649
  29899,   13.5538654,   65.9211426,  -7.27272749
  29900,   14.1431646,   66.6133652,  -7.27272749
  29901,   14.7324638,   67.3055878,  -7.27272749
  29902,   15.3217621,   67.9978104,  -7.27272749
  29903,   15.9110603,   68.6900406,  -7.27272749
  29904,   16.5003586,   69.3822632,  -7.27272749
  29905,   17.0896568,   70.0744858,  -7.27272749
  29906,   17.6789589,   70.7667084,  -7.27272749
  29907,   18.2682571,    71.458931,  -7.27272749
  29908,   18.8575554,   72.1511536,  -7.27272749
  29909,   13.5538654,   65.9211426,  -8.18181801
  29910,   14.1431646,   66.6133652,  -8.18181801
  29911,   14.7324638,   67.3055878,  -8.18181801
  29912,   15.3217621,   67.9978104,  -8.18181801
  29913,   15.9110603,   68.6900406,  -8.18181801
  29914,   16.5003586,   69.3822632,  -8.18181801
  29915,   17.0896568,   70.0744858,  -8.18181801
  29916,   17.6789589,   70.7667084,  -8.18181801
  29917,   18.2682571,    71.458931,  -8.18181801
  29918,   18.8575554,   72.1511536,  -8.18181801
  29919,   13.5538654,   65.9211426,    -9.090909
  29920,   14.1431646,   66.6133652,    -9.090909
  29921,   14.7324638,   67.3055878,    -9.090909
  29922,   15.3217621,   67.9978104,    -9.090909
  29923,   15.9110603,   68.6900406,    -9.090909
  29924,   16.5003586,   69.3822632,    -9.090909
  29925,   17.0896568,   70.0744858,    -9.090909
  29926,   17.6789589,   70.7667084,    -9.090909
  29927,   18.2682571,    71.458931,    -9.090909
  29928,   18.8575554,   72.1511536,    -9.090909
  29929,   13.0366058,   66.3473892, -0.909090936
  29930,   13.6034145,   67.0581436, -0.909090936
  29931,   14.1702242,    67.768898, -0.909090936
  29932,   14.7370329,   68.4796524, -0.909090936
  29933,   15.3038416,   69.1904068, -0.909090936
  29934,   15.8706512,   69.9011612, -0.909090936
  29935,   16.4374599,   70.6119232, -0.909090936
  29936,   17.0042686,   71.3226776, -0.909090936
  29937,   17.5710773,    72.033432, -0.909090936
  29938,    18.137888,   72.7441864, -0.909090936
  29939,   13.0366058,   66.3473892,  -1.81818187
  29940,   13.6034145,   67.0581436,  -1.81818187
  29941,   14.1702242,    67.768898,  -1.81818187
  29942,   14.7370329,   68.4796524,  -1.81818187
  29943,   15.3038416,   69.1904068,  -1.81818187
  29944,   15.8706512,   69.9011612,  -1.81818187
  29945,   16.4374599,   70.6119232,  -1.81818187
  29946,   17.0042686,   71.3226776,  -1.81818187
  29947,   17.5710773,    72.033432,  -1.81818187
  29948,    18.137888,   72.7441864,  -1.81818187
  29949,   13.0366058,   66.3473892,  -2.72727275
  29950,   13.6034145,   67.0581436,  -2.72727275
  29951,   14.1702242,    67.768898,  -2.72727275
  29952,   14.7370329,   68.4796524,  -2.72727275
  29953,   15.3038416,   69.1904068,  -2.72727275
  29954,   15.8706512,   69.9011612,  -2.72727275
  29955,   16.4374599,   70.6119232,  -2.72727275
  29956,   17.0042686,   71.3226776,  -2.72727275
  29957,   17.5710773,    72.033432,  -2.72727275
  29958,    18.137888,   72.7441864,  -2.72727275
  29959,   13.0366058,   66.3473892,  -3.63636374
  29960,   13.6034145,   67.0581436,  -3.63636374
  29961,   14.1702242,    67.768898,  -3.63636374
  29962,   14.7370329,   68.4796524,  -3.63636374
  29963,   15.3038416,   69.1904068,  -3.63636374
  29964,   15.8706512,   69.9011612,  -3.63636374
  29965,   16.4374599,   70.6119232,  -3.63636374
  29966,   17.0042686,   71.3226776,  -3.63636374
  29967,   17.5710773,    72.033432,  -3.63636374
  29968,    18.137888,   72.7441864,  -3.63636374
  29969,   13.0366058,   66.3473892,   -4.5454545
  29970,   13.6034145,   67.0581436,   -4.5454545
  29971,   14.1702242,    67.768898,   -4.5454545
  29972,   14.7370329,   68.4796524,   -4.5454545
  29973,   15.3038416,   69.1904068,   -4.5454545
  29974,   15.8706512,   69.9011612,   -4.5454545
  29975,   16.4374599,   70.6119232,   -4.5454545
  29976,   17.0042686,   71.3226776,   -4.5454545
  29977,   17.5710773,    72.033432,   -4.5454545
  29978,    18.137888,   72.7441864,   -4.5454545
  29979,   13.0366058,   66.3473892,   -5.4545455
  29980,   13.6034145,   67.0581436,   -5.4545455
  29981,   14.1702242,    67.768898,   -5.4545455
  29982,   14.7370329,   68.4796524,   -5.4545455
  29983,   15.3038416,   69.1904068,   -5.4545455
  29984,   15.8706512,   69.9011612,   -5.4545455
  29985,   16.4374599,   70.6119232,   -5.4545455
  29986,   17.0042686,   71.3226776,   -5.4545455
  29987,   17.5710773,    72.033432,   -5.4545455
  29988,    18.137888,   72.7441864,   -5.4545455
  29989,   13.0366058,   66.3473892,  -6.36363649
  29990,   13.6034145,   67.0581436,  -6.36363649
  29991,   14.1702242,    67.768898,  -6.36363649
  29992,   14.7370329,   68.4796524,  -6.36363649
  29993,   15.3038416,   69.1904068,  -6.36363649
  29994,   15.8706512,   69.9011612,  -6.36363649
