  35995,  -25.0205612,   58.3073997,  -6.36363649
  35996,  -25.8833389,   58.5938606,  -6.36363649
  35997,  -26.7461166,   58.8803215,  -6.36363649
  35998,  -27.6088943,   59.1667862,  -6.36363649
  35999,  -19.8438931,   56.5886269,  -7.27272749
  36000,  -20.7066708,   56.8750877,  -7.27272749
  36001,  -21.5694485,   57.1615486,  -7.27272749
  36002,  -22.4322262,   57.4480133,  -7.27272749
  36003,  -23.2950039,   57.7344742,  -7.27272749
  36004,  -24.1577835,   58.0209351,  -7.27272749
  36005,  -25.0205612,   58.3073997,  -7.27272749
  36006,  -25.8833389,   58.5938606,  -7.27272749
  36007,  -26.7461166,   58.8803215,  -7.27272749
  36008,  -27.6088943,   59.1667862,  -7.27272749
  36009,  -19.8438931,   56.5886269,  -8.18181801
  36010,  -20.7066708,   56.8750877,  -8.18181801
  36011,  -21.5694485,   57.1615486,  -8.18181801
  36012,  -22.4322262,   57.4480133,  -8.18181801
  36013,  -23.2950039,   57.7344742,  -8.18181801
  36014,  -24.1577835,   58.0209351,  -8.18181801
  36015,  -25.0205612,   58.3073997,  -8.18181801
  36016,  -25.8833389,   58.5938606,  -8.18181801
  36017,  -26.7461166,   58.8803215,  -8.18181801
  36018,  -27.6088943,   59.1667862,  -8.18181801
  36019,  -19.8438931,   56.5886269,    -9.090909
  36020,  -20.7066708,   56.8750877,    -9.090909
  36021,  -21.5694485,   57.1615486,    -9.090909
  36022,  -22.4322262,   57.4480133,    -9.090909
  36023,  -23.2950039,   57.7344742,    -9.090909
  36024,  -24.1577835,   58.0209351,    -9.090909
  36025,  -25.0205612,   58.3073997,    -9.090909
  36026,  -25.8833389,   58.5938606,    -9.090909
  36027,  -26.7461166,   58.8803215,    -9.090909
  36028,  -27.6088943,   59.1667862,    -9.090909
  36029,  -20.0448742,   55.9492149, -0.909090936
  36030,  -20.9163895,   56.2078743, -0.909090936
  36031,  -21.7879066,   56.4665375, -0.909090936
  36032,  -22.6594219,   56.7251968, -0.909090936
  36033,  -23.5309391,     56.98386, -0.909090936
  36034,  -24.4024544,   57.2425194, -0.909090936
  36035,  -25.2739716,   57.5011826, -0.909090936
  36036,  -26.1454868,   57.7598419, -0.909090936
  36037,   -27.017004,   58.0185051, -0.909090936
  36038,  -27.8885193,   58.2771645, -0.909090936
  36039,  -20.0448742,   55.9492149,  -1.81818187
  36040,  -20.9163895,   56.2078743,  -1.81818187
  36041,  -21.7879066,   56.4665375,  -1.81818187
  36042,  -22.6594219,   56.7251968,  -1.81818187
  36043,  -23.5309391,     56.98386,  -1.81818187
  36044,  -24.4024544,   57.2425194,  -1.81818187
  36045,  -25.2739716,   57.5011826,  -1.81818187
  36046,  -26.1454868,   57.7598419,  -1.81818187
  36047,   -27.017004,   58.0185051,  -1.81818187
  36048,  -27.8885193,   58.2771645,  -1.81818187
  36049,  -20.0448742,   55.9492149,  -2.72727275
  36050,  -20.9163895,   56.2078743,  -2.72727275
  36051,  -21.7879066,   56.4665375,  -2.72727275
  36052,  -22.6594219,   56.7251968,  -2.72727275
  36053,  -23.5309391,     56.98386,  -2.72727275
  36054,  -24.4024544,   57.2425194,  -2.72727275
  36055,  -25.2739716,   57.5011826,  -2.72727275
  36056,  -26.1454868,   57.7598419,  -2.72727275
  36057,   -27.017004,   58.0185051,  -2.72727275
  36058,  -27.8885193,   58.2771645,  -2.72727275
  36059,  -20.0448742,   55.9492149,  -3.63636374
  36060,  -20.9163895,   56.2078743,  -3.63636374
  36061,  -21.7879066,   56.4665375,  -3.63636374
  36062,  -22.6594219,   56.7251968,  -3.63636374
  36063,  -23.5309391,     56.98386,  -3.63636374
  36064,  -24.4024544,   57.2425194,  -3.63636374
  36065,  -25.2739716,   57.5011826,  -3.63636374
  36066,  -26.1454868,   57.7598419,  -3.63636374
  36067,   -27.017004,   58.0185051,  -3.63636374
  36068,  -27.8885193,   58.2771645,  -3.63636374
  36069,  -20.0448742,   55.9492149,   -4.5454545
  36070,  -20.9163895,   56.2078743,   -4.5454545
  36071,  -21.7879066,   56.4665375,   -4.5454545
  36072,  -22.6594219,   56.7251968,   -4.5454545
  36073,  -23.5309391,     56.98386,   -4.5454545
  36074,  -24.4024544,   57.2425194,   -4.5454545
  36075,  -25.2739716,   57.5011826,   -4.5454545
  36076,  -26.1454868,   57.7598419,   -4.5454545
  36077,   -27.017004,   58.0185051,   -4.5454545
  36078,  -27.8885193,   58.2771645,   -4.5454545
  36079,  -20.0448742,   55.9492149,   -5.4545455
  36080,  -20.9163895,   56.2078743,   -5.4545455
  36081,  -21.7879066,   56.4665375,   -5.4545455
  36082,  -22.6594219,   56.7251968,   -5.4545455
  36083,  -23.5309391,     56.98386,   -5.4545455
  36084,  -24.4024544,   57.2425194,   -5.4545455
  36085,  -25.2739716,   57.5011826,   -5.4545455
  36086,  -26.1454868,   57.7598419,   -5.4545455
  36087,   -27.017004,   58.0185051,   -5.4545455
  36088,  -27.8885193,   58.2771645,   -5.4545455
  36089,  -20.0448742,   55.9492149,  -6.36363649
  36090,  -20.9163895,   56.2078743,  -6.36363649
  36091,  -21.7879066,   56.4665375,  -6.36363649
  36092,  -22.6594219,   56.7251968,  -6.36363649
  36093,  -23.5309391,     56.98386,  -6.36363649
  36094,  -24.4024544,   57.2425194,  -6.36363649
  36095,  -25.2739716,   57.5011826,  -6.36363649
  36096,  -26.1454868,   57.7598419,  -6.36363649
  36097,   -27.017004,   58.0185051,  -6.36363649
  36098,  -27.8885193,   58.2771645,  -6.36363649
  36099,  -20.0448742,   55.9492149,  -7.27272749
  36100,  -20.9163895,   56.2078743,  -7.27272749
  36101,  -21.7879066,   56.4665375,  -7.27272749
  36102,  -22.6594219,   56.7251968,  -7.27272749
  36103,  -23.5309391,     56.98386,  -7.27272749
  36104,  -24.4024544,   57.2425194,  -7.27272749
  36105,  -25.2739716,   57.5011826,  -7.27272749
  36106,  -26.1454868,   57.7598419,  -7.27272749
  36107,   -27.017004,   58.0185051,  -7.27272749
  36108,  -27.8885193,   58.2771645,  -7.27272749
  36109,  -20.0448742,   55.9492149,  -8.18181801
  36110,  -20.9163895,   56.2078743,  -8.18181801
  36111,  -21.7879066,   56.4665375,  -8.18181801
  36112,  -22.6594219,   56.7251968,  -8.18181801
  36113,  -23.5309391,     56.98386,  -8.18181801
  36114,  -24.4024544,   57.2425194,  -8.18181801
  36115,  -25.2739716,   57.5011826,  -8.18181801
  36116,  -26.1454868,   57.7598419,  -8.18181801
  36117,   -27.017004,   58.0185051,  -8.18181801
  36118,  -27.8885193,   58.2771645,  -8.18181801
  36119,  -20.0448742,   55.9492149,    -9.090909
  36120,  -20.9163895,   56.2078743,    -9.090909
  36121,  -21.7879066,   56.4665375,    -9.090909
  36122,  -22.6594219,   56.7251968,    -9.090909
  36123,  -23.5309391,     56.98386,    -9.090909
  36124,  -24.4024544,   57.2425194,    -9.090909
  36125,  -25.2739716,   57.5011826,    -9.090909
  36126,  -26.1454868,   57.7598419,    -9.090909
  36127,   -27.017004,   58.0185051,    -9.090909
  36128,  -27.8885193,   58.2771645,    -9.090909
  36129,   -20.225256,    55.303688, -0.909090936
  36130,  -21.1046143,   55.5342827, -0.909090936
  36131,  -21.9839745,   55.7648773, -0.909090936
  36132,  -22.8633327,    55.995472, -0.909090936
  36133,  -23.7426929,   56.2260666, -0.909090936
  36134,  -24.6220512,   56.4566612, -0.909090936
  36135,  -25.5014095,   56.6872559, -0.909090936
  36136,  -26.3807697,   56.9178505, -0.909090936
  36137,   -27.260128,   57.1484489, -0.909090936
  36138,  -28.1394863,   57.3790436, -0.909090936
  36139,   -20.225256,    55.303688,  -1.81818187
  36140,  -21.1046143,   55.5342827,  -1.81818187
  36141,  -21.9839745,   55.7648773,  -1.81818187
  36142,  -22.8633327,    55.995472,  -1.81818187
  36143,  -23.7426929,   56.2260666,  -1.81818187
  36144,  -24.6220512,   56.4566612,  -1.81818187
  36145,  -25.5014095,   56.6872559,  -1.81818187
  36146,  -26.3807697,   56.9178505,  -1.81818187
  36147,   -27.260128,   57.1484489,  -1.81818187
  36148,  -28.1394863,   57.3790436,  -1.81818187
  36149,   -20.225256,    55.303688,  -2.72727275
  36150,  -21.1046143,   55.5342827,  -2.72727275
  36151,  -21.9839745,   55.7648773,  -2.72727275
  36152,  -22.8633327,    55.995472,  -2.72727275
  36153,  -23.7426929,   56.2260666,  -2.72727275
  36154,  -24.6220512,   56.4566612,  -2.72727275
  36155,  -25.5014095,   56.6872559,  -2.72727275
  36156,  -26.3807697,   56.9178505,  -2.72727275
  36157,   -27.260128,   57.1484489,  -2.72727275
  36158,  -28.1394863,   57.3790436,  -2.72727275
  36159,   -20.225256,    55.303688,  -3.63636374
  36160,  -21.1046143,   55.5342827,  -3.63636374
  36161,  -21.9839745,   55.7648773,  -3.63636374
  36162,  -22.8633327,    55.995472,  -3.63636374
  36163,  -23.7426929,   56.2260666,  -3.63636374
  36164,  -24.6220512,   56.4566612,  -3.63636374
  36165,  -25.5014095,   56.6872559,  -3.63636374
  36166,  -26.3807697,   56.9178505,  -3.63636374
  36167,   -27.260128,   57.1484489,  -3.63636374
  36168,  -28.1394863,   57.3790436,  -3.63636374
  36169,   -20.225256,    55.303688,   -4.5454545
  36170,  -21.1046143,   55.5342827,   -4.5454545
  36171,  -21.9839745,   55.7648773,   -4.5454545
  36172,  -22.8633327,    55.995472,   -4.5454545
  36173,  -23.7426929,   56.2260666,   -4.5454545
  36174,  -24.6220512,   56.4566612,   -4.5454545
  36175,  -25.5014095,   56.6872559,   -4.5454545
  36176,  -26.3807697,   56.9178505,   -4.5454545
  36177,   -27.260128,   57.1484489,   -4.5454545
  36178,  -28.1394863,   57.3790436,   -4.5454545
  36179,   -20.225256,    55.303688,   -5.4545455
  36180,  -21.1046143,   55.5342827,   -5.4545455
  36181,  -21.9839745,   55.7648773,   -5.4545455
  36182,  -22.8633327,    55.995472,   -5.4545455
  36183,  -23.7426929,   56.2260666,   -5.4545455
  36184,  -24.6220512,   56.4566612,   -5.4545455
  36185,  -25.5014095,   56.6872559,   -5.4545455
  36186,  -26.3807697,   56.9178505,   -5.4545455
  36187,   -27.260128,   57.1484489,   -5.4545455
  36188,  -28.1394863,   57.3790436,   -5.4545455
  36189,   -20.225256,    55.303688,  -6.36363649
  36190,  -21.1046143,   55.5342827,  -6.36363649
  36191,  -21.9839745,   55.7648773,  -6.36363649
  36192,  -22.8633327,    55.995472,  -6.36363649
  36193,  -23.7426929,   56.2260666,  -6.36363649
  36194,  -24.6220512,   56.4566612,  -6.36363649
  36195,  -25.5014095,   56.6872559,  -6.36363649
  36196,  -26.3807697,   56.9178505,  -6.36363649
  36197,   -27.260128,   57.1484489,  -6.36363649
  36198,  -28.1394863,   57.3790436,  -6.36363649
  36199,   -20.225256,    55.303688,  -7.27272749
  36200,  -21.1046143,   55.5342827,  -7.27272749
  36201,  -21.9839745,   55.7648773,  -7.27272749
  36202,  -22.8633327,    55.995472,  -7.27272749
  36203,  -23.7426929,   56.2260666,  -7.27272749
  36204,  -24.6220512,   56.4566612,  -7.27272749
  36205,  -25.5014095,   56.6872559,  -7.27272749
  36206,  -26.3807697,   56.9178505,  -7.27272749
  36207,   -27.260128,   57.1484489,  -7.27272749
  36208,  -28.1394863,   57.3790436,  -7.27272749
  36209,   -20.225256,    55.303688,  -8.18181801
  36210,  -21.1046143,   55.5342827,  -8.18181801
  36211,  -21.9839745,   55.7648773,  -8.18181801
  36212,  -22.8633327,    55.995472,  -8.18181801
  36213,  -23.7426929,   56.2260666,  -8.18181801
  36214,  -24.6220512,   56.4566612,  -8.18181801
  36215,  -25.5014095,   56.6872559,  -8.18181801
  36216,  -26.3807697,   56.9178505,  -8.18181801
  36217,   -27.260128,   57.1484489,  -8.18181801
  36218,  -28.1394863,   57.3790436,  -8.18181801
  36219,   -20.225256,    55.303688,    -9.090909
  36220,  -21.1046143,   55.5342827,    -9.090909
  36221,  -21.9839745,   55.7648773,    -9.090909
  36222,  -22.8633327,    55.995472,    -9.090909
  36223,  -23.7426929,   56.2260666,    -9.090909
  36224,  -24.6220512,   56.4566612,    -9.090909
  36225,  -25.5014095,   56.6872559,    -9.090909
  36226,  -26.3807697,   56.9178505,    -9.090909
  36227,   -27.260128,   57.1484489,    -9.090909
  36228,  -28.1394863,   57.3790436,    -9.090909
  36229,  -20.3848572,     54.65271, -0.909090936
  36230,  -21.2711544,   54.8550034, -0.909090936
  36231,  -22.1574516,   55.0572929, -0.909090936
  36232,  -23.0437508,   55.2595863, -0.909090936
  36233,   -23.930048,   55.4618759, -0.909090936
  36234,  -24.8163471,   55.6641693, -0.909090936
  36235,  -25.7026443,   55.8664627, -0.909090936
  36236,  -26.5889435,   56.0687523, -0.909090936
  36237,  -27.4752407,   56.2710457, -0.909090936
  36238,  -28.3615398,   56.4733353, -0.909090936
  36239,  -20.3848572,     54.65271,  -1.81818187
  36240,  -21.2711544,   54.8550034,  -1.81818187
  36241,  -22.1574516,   55.0572929,  -1.81818187
  36242,  -23.0437508,   55.2595863,  -1.81818187
  36243,   -23.930048,   55.4618759,  -1.81818187
  36244,  -24.8163471,   55.6641693,  -1.81818187
  36245,  -25.7026443,   55.8664627,  -1.81818187
  36246,  -26.5889435,   56.0687523,  -1.81818187
  36247,  -27.4752407,   56.2710457,  -1.81818187
  36248,  -28.3615398,   56.4733353,  -1.81818187
  36249,  -20.3848572,     54.65271,  -2.72727275
  36250,  -21.2711544,   54.8550034,  -2.72727275
  36251,  -22.1574516,   55.0572929,  -2.72727275
  36252,  -23.0437508,   55.2595863,  -2.72727275
  36253,   -23.930048,   55.4618759,  -2.72727275
  36254,  -24.8163471,   55.6641693,  -2.72727275
  36255,  -25.7026443,   55.8664627,  -2.72727275
  36256,  -26.5889435,   56.0687523,  -2.72727275
  36257,  -27.4752407,   56.2710457,  -2.72727275
  36258,  -28.3615398,   56.4733353,  -2.72727275
  36259,  -20.3848572,     54.65271,  -3.63636374
  36260,  -21.2711544,   54.8550034,  -3.63636374
  36261,  -22.1574516,   55.0572929,  -3.63636374
  36262,  -23.0437508,   55.2595863,  -3.63636374
  36263,   -23.930048,   55.4618759,  -3.63636374
  36264,  -24.8163471,   55.6641693,  -3.63636374
  36265,  -25.7026443,   55.8664627,  -3.63636374
  36266,  -26.5889435,   56.0687523,  -3.63636374
  36267,  -27.4752407,   56.2710457,  -3.63636374
  36268,  -28.3615398,   56.4733353,  -3.63636374
  36269,  -20.3848572,     54.65271,   -4.5454545
  36270,  -21.2711544,   54.8550034,   -4.5454545
  36271,  -22.1574516,   55.0572929,   -4.5454545
  36272,  -23.0437508,   55.2595863,   -4.5454545
  36273,   -23.930048,   55.4618759,   -4.5454545
  36274,  -24.8163471,   55.6641693,   -4.5454545
  36275,  -25.7026443,   55.8664627,   -4.5454545
  36276,  -26.5889435,   56.0687523,   -4.5454545
  36277,  -27.4752407,   56.2710457,   -4.5454545
  36278,  -28.3615398,   56.4733353,   -4.5454545
  36279,  -20.3848572,     54.65271,   -5.4545455
  36280,  -21.2711544,   54.8550034,   -5.4545455
  36281,  -22.1574516,   55.0572929,   -5.4545455
  36282,  -23.0437508,   55.2595863,   -5.4545455
  36283,   -23.930048,   55.4618759,   -5.4545455
  36284,  -24.8163471,   55.6641693,   -5.4545455
  36285,  -25.7026443,   55.8664627,   -5.4545455
  36286,  -26.5889435,   56.0687523,   -5.4545455
  36287,  -27.4752407,   56.2710457,   -5.4545455
  36288,  -28.3615398,   56.4733353,   -5.4545455
  36289,  -20.3848572,     54.65271,  -6.36363649
  36290,  -21.2711544,   54.8550034,  -6.36363649
  36291,  -22.1574516,   55.0572929,  -6.36363649
  36292,  -23.0437508,   55.2595863,  -6.36363649
  36293,   -23.930048,   55.4618759,  -6.36363649
  36294,  -24.8163471,   55.6641693,  -6.36363649
  36295,  -25.7026443,   55.8664627,  -6.36363649
  36296,  -26.5889435,   56.0687523,  -6.36363649
  36297,  -27.4752407,   56.2710457,  -6.36363649
  36298,  -28.3615398,   56.4733353,  -6.36363649
  36299,  -20.3848572,     54.65271,  -7.27272749
  36300,  -21.2711544,   54.8550034,  -7.27272749
  36301,  -22.1574516,   55.0572929,  -7.27272749
  36302,  -23.0437508,   55.2595863,  -7.27272749
  36303,   -23.930048,   55.4618759,  -7.27272749
  36304,  -24.8163471,   55.6641693,  -7.27272749
  36305,  -25.7026443,   55.8664627,  -7.27272749
  36306,  -26.5889435,   56.0687523,  -7.27272749
  36307,  -27.4752407,   56.2710457,  -7.27272749
  36308,  -28.3615398,   56.4733353,  -7.27272749
  36309,  -20.3848572,     54.65271,  -8.18181801
  36310,  -21.2711544,   54.8550034,  -8.18181801
  36311,  -22.1574516,   55.0572929,  -8.18181801
  36312,  -23.0437508,   55.2595863,  -8.18181801
  36313,   -23.930048,   55.4618759,  -8.18181801
  36314,  -24.8163471,   55.6641693,  -8.18181801
  36315,  -25.7026443,   55.8664627,  -8.18181801
  36316,  -26.5889435,   56.0687523,  -8.18181801
  36317,  -27.4752407,   56.2710457,  -8.18181801
  36318,  -28.3615398,   56.4733353,  -8.18181801
  36319,  -20.3848572,     54.65271,    -9.090909
  36320,  -21.2711544,   54.8550034,    -9.090909
  36321,  -22.1574516,   55.0572929,    -9.090909
  36322,  -23.0437508,   55.2595863,    -9.090909
  36323,   -23.930048,   55.4618759,    -9.090909
  36324,  -24.8163471,   55.6641693,    -9.090909
  36325,  -25.7026443,   55.8664627,    -9.090909
  36326,  -26.5889435,   56.0687523,    -9.090909
  36327,  -27.4752407,   56.2710457,    -9.090909
  36328,  -28.3615398,   56.4733353,    -9.090909
  36329,    -20.52351,   53.9969521, -0.909090936
  36330,  -21.4158363,   54.1707344, -0.909090936
  36331,  -22.3081627,   54.3445129, -0.909090936
  36332,   -23.200489,   54.5182953, -0.909090936
  36333,  -24.0928154,   54.6920738, -0.909090936
  36334,  -24.9851398,   54.8658562, -0.909090936
  36335,  -25.8774662,   55.0396347, -0.909090936
  36336,  -26.7697926,   55.2134171, -0.909090936
  36337,  -27.6621189,   55.3871994, -0.909090936
  36338,  -28.5544472,   55.5609779, -0.909090936
  36339,    -20.52351,   53.9969521,  -1.81818187
  36340,  -21.4158363,   54.1707344,  -1.81818187
  36341,  -22.3081627,   54.3445129,  -1.81818187
  36342,   -23.200489,   54.5182953,  -1.81818187
  36343,  -24.0928154,   54.6920738,  -1.81818187
  36344,  -24.9851398,   54.8658562,  -1.81818187
  36345,  -25.8774662,   55.0396347,  -1.81818187
  36346,  -26.7697926,   55.2134171,  -1.81818187
  36347,  -27.6621189,   55.3871994,  -1.81818187
  36348,  -28.5544472,   55.5609779,  -1.81818187
  36349,    -20.52351,   53.9969521,  -2.72727275
  36350,  -21.4158363,   54.1707344,  -2.72727275
  36351,  -22.3081627,   54.3445129,  -2.72727275
  36352,   -23.200489,   54.5182953,  -2.72727275
  36353,  -24.0928154,   54.6920738,  -2.72727275
  36354,  -24.9851398,   54.8658562,  -2.72727275
  36355,  -25.8774662,   55.0396347,  -2.72727275
  36356,  -26.7697926,   55.2134171,  -2.72727275
  36357,  -27.6621189,   55.3871994,  -2.72727275
  36358,  -28.5544472,   55.5609779,  -2.72727275
  36359,    -20.52351,   53.9969521,  -3.63636374
  36360,  -21.4158363,   54.1707344,  -3.63636374
  36361,  -22.3081627,   54.3445129,  -3.63636374
  36362,   -23.200489,   54.5182953,  -3.63636374
  36363,  -24.0928154,   54.6920738,  -3.63636374
  36364,  -24.9851398,   54.8658562,  -3.63636374
  36365,  -25.8774662,   55.0396347,  -3.63636374
  36366,  -26.7697926,   55.2134171,  -3.63636374
  36367,  -27.6621189,   55.3871994,  -3.63636374
  36368,  -28.5544472,   55.5609779,  -3.63636374
  36369,    -20.52351,   53.9969521,   -4.5454545
  36370,  -21.4158363,   54.1707344,   -4.5454545
  36371,  -22.3081627,   54.3445129,   -4.5454545
  36372,   -23.200489,   54.5182953,   -4.5454545
  36373,  -24.0928154,   54.6920738,   -4.5454545
  36374,  -24.9851398,   54.8658562,   -4.5454545
  36375,  -25.8774662,   55.0396347,   -4.5454545
  36376,  -26.7697926,   55.2134171,   -4.5454545
  36377,  -27.6621189,   55.3871994,   -4.5454545
  36378,  -28.5544472,   55.5609779,   -4.5454545
  36379,    -20.52351,   53.9969521,   -5.4545455
  36380,  -21.4158363,   54.1707344,   -5.4545455
  36381,  -22.3081627,   54.3445129,   -5.4545455
  36382,   -23.200489,   54.5182953,   -5.4545455
  36383,  -24.0928154,   54.6920738,   -5.4545455
  36384,  -24.9851398,   54.8658562,   -5.4545455
  36385,  -25.8774662,   55.0396347,   -5.4545455
  36386,  -26.7697926,   55.2134171,   -5.4545455
  36387,  -27.6621189,   55.3871994,   -5.4545455
  36388,  -28.5544472,   55.5609779,   -5.4545455
  36389,    -20.52351,   53.9969521,  -6.36363649
  36390,  -21.4158363,   54.1707344,  -6.36363649
  36391,  -22.3081627,   54.3445129,  -6.36363649
  36392,   -23.200489,   54.5182953,  -6.36363649
  36393,  -24.0928154,   54.6920738,  -6.36363649
  36394,  -24.9851398,   54.8658562,  -6.36363649
  36395,  -25.8774662,   55.0396347,  -6.36363649
  36396,  -26.7697926,   55.2134171,  -6.36363649
  36397,  -27.6621189,   55.3871994,  -6.36363649
  36398,  -28.5544472,   55.5609779,  -6.36363649
  36399,    -20.52351,   53.9969521,  -7.27272749
  36400,  -21.4158363,   54.1707344,  -7.27272749
  36401,  -22.3081627,   54.3445129,  -7.27272749
  36402,   -23.200489,   54.5182953,  -7.27272749
  36403,  -24.0928154,   54.6920738,  -7.27272749
  36404,  -24.9851398,   54.8658562,  -7.27272749
  36405,  -25.8774662,   55.0396347,  -7.27272749
  36406,  -26.7697926,   55.2134171,  -7.27272749
  36407,  -27.6621189,   55.3871994,  -7.27272749
  36408,  -28.5544472,   55.5609779,  -7.27272749
  36409,    -20.52351,   53.9969521,  -8.18181801
  36410,  -21.4158363,   54.1707344,  -8.18181801
  36411,  -22.3081627,   54.3445129,  -8.18181801
  36412,   -23.200489,   54.5182953,  -8.18181801
  36413,  -24.0928154,   54.6920738,  -8.18181801
  36414,  -24.9851398,   54.8658562,  -8.18181801
  36415,  -25.8774662,   55.0396347,  -8.18181801
  36416,  -26.7697926,   55.2134171,  -8.18181801
  36417,  -27.6621189,   55.3871994,  -8.18181801
  36418,  -28.5544472,   55.5609779,  -8.18181801
  36419,    -20.52351,   53.9969521,    -9.090909
  36420,  -21.4158363,   54.1707344,    -9.090909
  36421,  -22.3081627,   54.3445129,    -9.090909
  36422,   -23.200489,   54.5182953,    -9.090909
  36423,  -24.0928154,   54.6920738,    -9.090909
  36424,  -24.9851398,   54.8658562,    -9.090909
  36425,  -25.8774662,   55.0396347,    -9.090909
  36426,  -26.7697926,   55.2134171,    -9.090909
  36427,  -27.6621189,   55.3871994,    -9.090909
  36428,  -28.5544472,   55.5609779,    -9.090909
  36429,  -20.6410732,   53.3370895, -0.909090936
  36430,  -21.5385113,   53.4821777, -0.909090936
  36431,  -22.4359493,   53.6272697, -0.909090936
  36432,  -23.3333874,   53.7723618, -0.909090936
  36433,  -24.2308254,   53.9174538, -0.909090936
  36434,  -25.1282635,    54.062542, -0.909090936
  36435,  -26.0257015,    54.207634, -0.909090936
  36436,  -26.9231396,    54.352726, -0.909090936
  36437,  -27.8205776,   54.4978142, -0.909090936
  36438,  -28.7180157,   54.6429062, -0.909090936
  36439,  -20.6410732,   53.3370895,  -1.81818187
  36440,  -21.5385113,   53.4821777,  -1.81818187
  36441,  -22.4359493,   53.6272697,  -1.81818187
  36442,  -23.3333874,   53.7723618,  -1.81818187
  36443,  -24.2308254,   53.9174538,  -1.81818187
  36444,  -25.1282635,    54.062542,  -1.81818187
  36445,  -26.0257015,    54.207634,  -1.81818187
  36446,  -26.9231396,    54.352726,  -1.81818187
  36447,  -27.8205776,   54.4978142,  -1.81818187
  36448,  -28.7180157,   54.6429062,  -1.81818187
  36449,  -20.6410732,   53.3370895,  -2.72727275
  36450,  -21.5385113,   53.4821777,  -2.72727275
  36451,  -22.4359493,   53.6272697,  -2.72727275
  36452,  -23.3333874,   53.7723618,  -2.72727275
  36453,  -24.2308254,   53.9174538,  -2.72727275
  36454,  -25.1282635,    54.062542,  -2.72727275
  36455,  -26.0257015,    54.207634,  -2.72727275
  36456,  -26.9231396,    54.352726,  -2.72727275
  36457,  -27.8205776,   54.4978142,  -2.72727275
  36458,  -28.7180157,   54.6429062,  -2.72727275
  36459,  -20.6410732,   53.3370895,  -3.63636374
  36460,  -21.5385113,   53.4821777,  -3.63636374
  36461,  -22.4359493,   53.6272697,  -3.63636374
  36462,  -23.3333874,   53.7723618,  -3.63636374
  36463,  -24.2308254,   53.9174538,  -3.63636374
  36464,  -25.1282635,    54.062542,  -3.63636374
  36465,  -26.0257015,    54.207634,  -3.63636374
  36466,  -26.9231396,    54.352726,  -3.63636374
  36467,  -27.8205776,   54.4978142,  -3.63636374
  36468,  -28.7180157,   54.6429062,  -3.63636374
  36469,  -20.6410732,   53.3370895,   -4.5454545
  36470,  -21.5385113,   53.4821777,   -4.5454545
  36471,  -22.4359493,   53.6272697,   -4.5454545
  36472,  -23.3333874,   53.7723618,   -4.5454545
  36473,  -24.2308254,   53.9174538,   -4.5454545
  36474,  -25.1282635,    54.062542,   -4.5454545
  36475,  -26.0257015,    54.207634,   -4.5454545
  36476,  -26.9231396,    54.352726,   -4.5454545
  36477,  -27.8205776,   54.4978142,   -4.5454545
  36478,  -28.7180157,   54.6429062,   -4.5454545
  36479,  -20.6410732,   53.3370895,   -5.4545455
  36480,  -21.5385113,   53.4821777,   -5.4545455
  36481,  -22.4359493,   53.6272697,   -5.4545455
  36482,  -23.3333874,   53.7723618,   -5.4545455
  36483,  -24.2308254,   53.9174538,   -5.4545455
  36484,  -25.1282635,    54.062542,   -5.4545455
  36485,  -26.0257015,    54.207634,   -5.4545455
  36486,  -26.9231396,    54.352726,   -5.4545455
  36487,  -27.8205776,   54.4978142,   -5.4545455
  36488,  -28.7180157,   54.6429062,   -5.4545455
  36489,  -20.6410732,   53.3370895,  -6.36363649
  36490,  -21.5385113,   53.4821777,  -6.36363649
  36491,  -22.4359493,   53.6272697,  -6.36363649
  36492,  -23.3333874,   53.7723618,  -6.36363649
  36493,  -24.2308254,   53.9174538,  -6.36363649
  36494,  -25.1282635,    54.062542,  -6.36363649
  36495,  -26.0257015,    54.207634,  -6.36363649
  36496,  -26.9231396,    54.352726,  -6.36363649
  36497,  -27.8205776,   54.4978142,  -6.36363649
  36498,  -28.7180157,   54.6429062,  -6.36363649
  36499,  -20.6410732,   53.3370895,  -7.27272749
  36500,  -21.5385113,   53.4821777,  -7.27272749
  36501,  -22.4359493,   53.6272697,  -7.27272749
  36502,  -23.3333874,   53.7723618,  -7.27272749
  36503,  -24.2308254,   53.9174538,  -7.27272749
  36504,  -25.1282635,    54.062542,  -7.27272749
  36505,  -26.0257015,    54.207634,  -7.27272749
  36506,  -26.9231396,    54.352726,  -7.27272749
  36507,  -27.8205776,   54.4978142,  -7.27272749
  36508,  -28.7180157,   54.6429062,  -7.27272749
  36509,  -20.6410732,   53.3370895,  -8.18181801
  36510,  -21.5385113,   53.4821777,  -8.18181801
  36511,  -22.4359493,   53.6272697,  -8.18181801
  36512,  -23.3333874,   53.7723618,  -8.18181801
  36513,  -24.2308254,   53.9174538,  -8.18181801
  36514,  -25.1282635,    54.062542,  -8.18181801
  36515,  -26.0257015,    54.207634,  -8.18181801
  36516,  -26.9231396,    54.352726,  -8.18181801
  36517,  -27.8205776,   54.4978142,  -8.18181801
  36518,  -28.7180157,   54.6429062,  -8.18181801
  36519,  -20.6410732,   53.3370895,    -9.090909
  36520,  -21.5385113,   53.4821777,    -9.090909
  36521,  -22.4359493,   53.6272697,    -9.090909
  36522,  -23.3333874,   53.7723618,    -9.090909
  36523,  -24.2308254,   53.9174538,    -9.090909
  36524,  -25.1282635,    54.062542,    -9.090909
  36525,  -26.0257015,    54.207634,    -9.090909
  36526,  -26.9231396,    54.352726,    -9.090909
  36527,  -27.8205776,   54.4978142,    -9.090909
  36528,  -28.7180157,   54.6429062,    -9.090909
  36529,  -20.7374268,   52.6737938, -0.909090936
  36530,  -21.6390553,   52.7900467, -0.909090936
  36531,  -22.5406818,   52.9062996, -0.909090936
  36532,  -23.4423103,   53.0225525, -0.909090936
  36533,  -24.3439369,   53.1388016, -0.909090936
  36534,  -25.2455635,   53.2550545, -0.909090936
  36535,   -26.147192,   53.3713074, -0.909090936
  36536,  -27.0488186,   53.4875603, -0.909090936
  36537,  -27.9504452,   53.6038094, -0.909090936
  36538,  -28.8520737,   53.7200623, -0.909090936
  36539,  -20.7374268,   52.6737938,  -1.81818187
  36540,  -21.6390553,   52.7900467,  -1.81818187
  36541,  -22.5406818,   52.9062996,  -1.81818187
  36542,  -23.4423103,   53.0225525,  -1.81818187
  36543,  -24.3439369,   53.1388016,  -1.81818187
  36544,  -25.2455635,   53.2550545,  -1.81818187
  36545,   -26.147192,   53.3713074,  -1.81818187
  36546,  -27.0488186,   53.4875603,  -1.81818187
  36547,  -27.9504452,   53.6038094,  -1.81818187
  36548,  -28.8520737,   53.7200623,  -1.81818187
  36549,  -20.7374268,   52.6737938,  -2.72727275
  36550,  -21.6390553,   52.7900467,  -2.72727275
  36551,  -22.5406818,   52.9062996,  -2.72727275
  36552,  -23.4423103,   53.0225525,  -2.72727275
  36553,  -24.3439369,   53.1388016,  -2.72727275
  36554,  -25.2455635,   53.2550545,  -2.72727275
  36555,   -26.147192,   53.3713074,  -2.72727275
  36556,  -27.0488186,   53.4875603,  -2.72727275
  36557,  -27.9504452,   53.6038094,  -2.72727275
  36558,  -28.8520737,   53.7200623,  -2.72727275
  36559,  -20.7374268,   52.6737938,  -3.63636374
  36560,  -21.6390553,   52.7900467,  -3.63636374
  36561,  -22.5406818,   52.9062996,  -3.63636374
  36562,  -23.4423103,   53.0225525,  -3.63636374
  36563,  -24.3439369,   53.1388016,  -3.63636374
  36564,  -25.2455635,   53.2550545,  -3.63636374
  36565,   -26.147192,   53.3713074,  -3.63636374
  36566,  -27.0488186,   53.4875603,  -3.63636374
  36567,  -27.9504452,   53.6038094,  -3.63636374
  36568,  -28.8520737,   53.7200623,  -3.63636374
  36569,  -20.7374268,   52.6737938,   -4.5454545
  36570,  -21.6390553,   52.7900467,   -4.5454545
  36571,  -22.5406818,   52.9062996,   -4.5454545
  36572,  -23.4423103,   53.0225525,   -4.5454545
  36573,  -24.3439369,   53.1388016,   -4.5454545
  36574,  -25.2455635,   53.2550545,   -4.5454545
  36575,   -26.147192,   53.3713074,   -4.5454545
  36576,  -27.0488186,   53.4875603,   -4.5454545
  36577,  -27.9504452,   53.6038094,   -4.5454545
  36578,  -28.8520737,   53.7200623,   -4.5454545
  36579,  -20.7374268,   52.6737938,   -5.4545455
  36580,  -21.6390553,   52.7900467,   -5.4545455
  36581,  -22.5406818,   52.9062996,   -5.4545455
  36582,  -23.4423103,   53.0225525,   -5.4545455
  36583,  -24.3439369,   53.1388016,   -5.4545455
  36584,  -25.2455635,   53.2550545,   -5.4545455
  36585,   -26.147192,   53.3713074,   -5.4545455
  36586,  -27.0488186,   53.4875603,   -5.4545455
  36587,  -27.9504452,   53.6038094,   -5.4545455
  36588,  -28.8520737,   53.7200623,   -5.4545455
  36589,  -20.7374268,   52.6737938,  -6.36363649
  36590,  -21.6390553,   52.7900467,  -6.36363649
  36591,  -22.5406818,   52.9062996,  -6.36363649
  36592,  -23.4423103,   53.0225525,  -6.36363649
  36593,  -24.3439369,   53.1388016,  -6.36363649
  36594,  -25.2455635,   53.2550545,  -6.36363649
  36595,   -26.147192,   53.3713074,  -6.36363649
  36596,  -27.0488186,   53.4875603,  -6.36363649
  36597,  -27.9504452,   53.6038094,  -6.36363649
  36598,  -28.8520737,   53.7200623,  -6.36363649
  36599,  -20.7374268,   52.6737938,  -7.27272749
  36600,  -21.6390553,   52.7900467,  -7.27272749
  36601,  -22.5406818,   52.9062996,  -7.27272749
  36602,  -23.4423103,   53.0225525,  -7.27272749
  36603,  -24.3439369,   53.1388016,  -7.27272749
  36604,  -25.2455635,   53.2550545,  -7.27272749
  36605,   -26.147192,   53.3713074,  -7.27272749
  36606,  -27.0488186,   53.4875603,  -7.27272749
  36607,  -27.9504452,   53.6038094,  -7.27272749
  36608,  -28.8520737,   53.7200623,  -7.27272749
  36609,  -20.7374268,   52.6737938,  -8.18181801
  36610,  -21.6390553,   52.7900467,  -8.18181801
  36611,  -22.5406818,   52.9062996,  -8.18181801
  36612,  -23.4423103,   53.0225525,  -8.18181801
  36613,  -24.3439369,   53.1388016,  -8.18181801
  36614,  -25.2455635,   53.2550545,  -8.18181801
  36615,   -26.147192,   53.3713074,  -8.18181801
  36616,  -27.0488186,   53.4875603,  -8.18181801
  36617,  -27.9504452,   53.6038094,  -8.18181801
  36618,  -28.8520737,   53.7200623,  -8.18181801
  36619,  -20.7374268,   52.6737938,    -9.090909
  36620,  -21.6390553,   52.7900467,    -9.090909
  36621,  -22.5406818,   52.9062996,    -9.090909
  36622,  -23.4423103,   53.0225525,    -9.090909
  36623,  -24.3439369,   53.1388016,    -9.090909
  36624,  -25.2455635,   53.2550545,    -9.090909
  36625,   -26.147192,   53.3713074,    -9.090909
  36626,  -27.0488186,   53.4875603,    -9.090909
  36627,  -27.9504452,   53.6038094,    -9.090909
  36628,  -28.8520737,   53.7200623,    -9.090909
  36629,  -20.8124752,   52.0077553, -0.909090936
  36630,  -21.7173653,    52.095047, -0.909090936
  36631,  -22.6222553,   52.1823425, -0.909090936
  36632,  -23.5271454,   52.2696342, -0.909090936
  36633,  -24.4320354,   52.3569298, -0.909090936
  36634,  -25.3369236,   52.4442215, -0.909090936
  36635,  -26.2418137,    52.531517, -0.909090936
  36636,  -27.1467037,   52.6188087, -0.909090936
  36637,  -28.0515938,   52.7061043, -0.909090936
  36638,  -28.9564838,    52.793396, -0.909090936
  36639,  -20.8124752,   52.0077553,  -1.81818187
  36640,  -21.7173653,    52.095047,  -1.81818187
  36641,  -22.6222553,   52.1823425,  -1.81818187
  36642,  -23.5271454,   52.2696342,  -1.81818187
  36643,  -24.4320354,   52.3569298,  -1.81818187
  36644,  -25.3369236,   52.4442215,  -1.81818187
  36645,  -26.2418137,    52.531517,  -1.81818187
  36646,  -27.1467037,   52.6188087,  -1.81818187
  36647,  -28.0515938,   52.7061043,  -1.81818187
  36648,  -28.9564838,    52.793396,  -1.81818187
  36649,  -20.8124752,   52.0077553,  -2.72727275
  36650,  -21.7173653,    52.095047,  -2.72727275
  36651,  -22.6222553,   52.1823425,  -2.72727275
  36652,  -23.5271454,   52.2696342,  -2.72727275
  36653,  -24.4320354,   52.3569298,  -2.72727275
  36654,  -25.3369236,   52.4442215,  -2.72727275
  36655,  -26.2418137,    52.531517,  -2.72727275
  36656,  -27.1467037,   52.6188087,  -2.72727275
  36657,  -28.0515938,   52.7061043,  -2.72727275
  36658,  -28.9564838,    52.793396,  -2.72727275
  36659,  -20.8124752,   52.0077553,  -3.63636374
  36660,  -21.7173653,    52.095047,  -3.63636374
  36661,  -22.6222553,   52.1823425,  -3.63636374
  36662,  -23.5271454,   52.2696342,  -3.63636374
  36663,  -24.4320354,   52.3569298,  -3.63636374
  36664,  -25.3369236,   52.4442215,  -3.63636374
  36665,  -26.2418137,    52.531517,  -3.63636374
  36666,  -27.1467037,   52.6188087,  -3.63636374
  36667,  -28.0515938,   52.7061043,  -3.63636374
  36668,  -28.9564838,    52.793396,  -3.63636374
  36669,  -20.8124752,   52.0077553,   -4.5454545
  36670,  -21.7173653,    52.095047,   -4.5454545
  36671,  -22.6222553,   52.1823425,   -4.5454545
  36672,  -23.5271454,   52.2696342,   -4.5454545
  36673,  -24.4320354,   52.3569298,   -4.5454545
  36674,  -25.3369236,   52.4442215,   -4.5454545
  36675,  -26.2418137,    52.531517,   -4.5454545
  36676,  -27.1467037,   52.6188087,   -4.5454545
  36677,  -28.0515938,   52.7061043,   -4.5454545
  36678,  -28.9564838,    52.793396,   -4.5454545
  36679,  -20.8124752,   52.0077553,   -5.4545455
  36680,  -21.7173653,    52.095047,   -5.4545455
  36681,  -22.6222553,   52.1823425,   -5.4545455
  36682,  -23.5271454,   52.2696342,   -5.4545455
  36683,  -24.4320354,   52.3569298,   -5.4545455
  36684,  -25.3369236,   52.4442215,   -5.4545455
  36685,  -26.2418137,    52.531517,   -5.4545455
  36686,  -27.1467037,   52.6188087,   -5.4545455
  36687,  -28.0515938,   52.7061043,   -5.4545455
  36688,  -28.9564838,    52.793396,   -5.4545455
  36689,  -20.8124752,   52.0077553,  -6.36363649
  36690,  -21.7173653,    52.095047,  -6.36363649
  36691,  -22.6222553,   52.1823425,  -6.36363649
  36692,  -23.5271454,   52.2696342,  -6.36363649
  36693,  -24.4320354,   52.3569298,  -6.36363649
  36694,  -25.3369236,   52.4442215,  -6.36363649
  36695,  -26.2418137,    52.531517,  -6.36363649
  36696,  -27.1467037,   52.6188087,  -6.36363649
  36697,  -28.0515938,   52.7061043,  -6.36363649
  36698,  -28.9564838,    52.793396,  -6.36363649
  36699,  -20.8124752,   52.0077553,  -7.27272749
  36700,  -21.7173653,    52.095047,  -7.27272749
  36701,  -22.6222553,   52.1823425,  -7.27272749
  36702,  -23.5271454,   52.2696342,  -7.27272749
  36703,  -24.4320354,   52.3569298,  -7.27272749
  36704,  -25.3369236,   52.4442215,  -7.27272749
  36705,  -26.2418137,    52.531517,  -7.27272749
  36706,  -27.1467037,   52.6188087,  -7.27272749
  36707,  -28.0515938,   52.7061043,  -7.27272749
  36708,  -28.9564838,    52.793396,  -7.27272749
  36709,  -20.8124752,   52.0077553,  -8.18181801
  36710,  -21.7173653,    52.095047,  -8.18181801
  36711,  -22.6222553,   52.1823425,  -8.18181801
  36712,  -23.5271454,   52.2696342,  -8.18181801
  36713,  -24.4320354,   52.3569298,  -8.18181801
  36714,  -25.3369236,   52.4442215,  -8.18181801
  36715,  -26.2418137,    52.531517,  -8.18181801
  36716,  -27.1467037,   52.6188087,  -8.18181801
  36717,  -28.0515938,   52.7061043,  -8.18181801
  36718,  -28.9564838,    52.793396,  -8.18181801
  36719,  -20.8124752,   52.0077553,    -9.090909
  36720,  -21.7173653,    52.095047,    -9.090909
  36721,  -22.6222553,   52.1823425,    -9.090909
  36722,  -23.5271454,   52.2696342,    -9.090909
  36723,  -24.4320354,   52.3569298,    -9.090909
  36724,  -25.3369236,   52.4442215,    -9.090909
  36725,  -26.2418137,    52.531517,    -9.090909
  36726,  -27.1467037,   52.6188087,    -9.090909
  36727,  -28.0515938,   52.7061043,    -9.090909
  36728,  -28.9564838,    52.793396,    -9.090909
  36729,  -20.8661308,   51.3396492, -0.909090936
  36730,  -21.7733536,   51.3978958, -0.909090936
  36731,  -22.6805763,   51.4561424, -0.909090936
  36732,   -23.587801,   51.5143852, -0.909090936
  36733,  -24.4950237,   51.5726318, -0.909090936
  36734,  -25.4022465,   51.6308784, -0.909090936
  36735,  -26.3094692,   51.6891251, -0.909090936
  36736,   -27.216692,   51.7473679, -0.909090936
  36737,  -28.1239147,   51.8056145, -0.909090936
  36738,  -29.0311394,   51.8638611, -0.909090936
  36739,  -20.8661308,   51.3396492,  -1.81818187
  36740,  -21.7733536,   51.3978958,  -1.81818187
  36741,  -22.6805763,   51.4561424,  -1.81818187
  36742,   -23.587801,   51.5143852,  -1.81818187
  36743,  -24.4950237,   51.5726318,  -1.81818187
  36744,  -25.4022465,   51.6308784,  -1.81818187
  36745,  -26.3094692,   51.6891251,  -1.81818187
  36746,   -27.216692,   51.7473679,  -1.81818187
  36747,  -28.1239147,   51.8056145,  -1.81818187
  36748,  -29.0311394,   51.8638611,  -1.81818187
  36749,  -20.8661308,   51.3396492,  -2.72727275
  36750,  -21.7733536,   51.3978958,  -2.72727275
  36751,  -22.6805763,   51.4561424,  -2.72727275
  36752,   -23.587801,   51.5143852,  -2.72727275
  36753,  -24.4950237,   51.5726318,  -2.72727275
  36754,  -25.4022465,   51.6308784,  -2.72727275
  36755,  -26.3094692,   51.6891251,  -2.72727275
  36756,   -27.216692,   51.7473679,  -2.72727275
  36757,  -28.1239147,   51.8056145,  -2.72727275
  36758,  -29.0311394,   51.8638611,  -2.72727275
  36759,  -20.8661308,   51.3396492,  -3.63636374
  36760,  -21.7733536,   51.3978958,  -3.63636374
  36761,  -22.6805763,   51.4561424,  -3.63636374
  36762,   -23.587801,   51.5143852,  -3.63636374
  36763,  -24.4950237,   51.5726318,  -3.63636374
  36764,  -25.4022465,   51.6308784,  -3.63636374
  36765,  -26.3094692,   51.6891251,  -3.63636374
  36766,   -27.216692,   51.7473679,  -3.63636374
  36767,  -28.1239147,   51.8056145,  -3.63636374
  36768,  -29.0311394,   51.8638611,  -3.63636374
  36769,  -20.8661308,   51.3396492,   -4.5454545
  36770,  -21.7733536,   51.3978958,   -4.5454545
  36771,  -22.6805763,   51.4561424,   -4.5454545
  36772,   -23.587801,   51.5143852,   -4.5454545
  36773,  -24.4950237,   51.5726318,   -4.5454545
  36774,  -25.4022465,   51.6308784,   -4.5454545
  36775,  -26.3094692,   51.6891251,   -4.5454545
  36776,   -27.216692,   51.7473679,   -4.5454545
  36777,  -28.1239147,   51.8056145,   -4.5454545
  36778,  -29.0311394,   51.8638611,   -4.5454545
  36779,  -20.8661308,   51.3396492,   -5.4545455
  36780,  -21.7733536,   51.3978958,   -5.4545455
  36781,  -22.6805763,   51.4561424,   -5.4545455
  36782,   -23.587801,   51.5143852,   -5.4545455
  36783,  -24.4950237,   51.5726318,   -5.4545455
  36784,  -25.4022465,   51.6308784,   -5.4545455
  36785,  -26.3094692,   51.6891251,   -5.4545455
  36786,   -27.216692,   51.7473679,   -5.4545455
  36787,  -28.1239147,   51.8056145,   -5.4545455
  36788,  -29.0311394,   51.8638611,   -5.4545455
  36789,  -20.8661308,   51.3396492,  -6.36363649
  36790,  -21.7733536,   51.3978958,  -6.36363649
  36791,  -22.6805763,   51.4561424,  -6.36363649
  36792,   -23.587801,   51.5143852,  -6.36363649
  36793,  -24.4950237,   51.5726318,  -6.36363649
  36794,  -25.4022465,   51.6308784,  -6.36363649
  36795,  -26.3094692,   51.6891251,  -6.36363649
  36796,   -27.216692,   51.7473679,  -6.36363649
  36797,  -28.1239147,   51.8056145,  -6.36363649
  36798,  -29.0311394,   51.8638611,  -6.36363649
  36799,  -20.8661308,   51.3396492,  -7.27272749
  36800,  -21.7733536,   51.3978958,  -7.27272749
  36801,  -22.6805763,   51.4561424,  -7.27272749
  36802,   -23.587801,   51.5143852,  -7.27272749
  36803,  -24.4950237,   51.5726318,  -7.27272749
  36804,  -25.4022465,   51.6308784,  -7.27272749
  36805,  -26.3094692,   51.6891251,  -7.27272749
  36806,   -27.216692,   51.7473679,  -7.27272749
  36807,  -28.1239147,   51.8056145,  -7.27272749
  36808,  -29.0311394,   51.8638611,  -7.27272749
  36809,  -20.8661308,   51.3396492,  -8.18181801
  36810,  -21.7733536,   51.3978958,  -8.18181801
  36811,  -22.6805763,   51.4561424,  -8.18181801
  36812,   -23.587801,   51.5143852,  -8.18181801
  36813,  -24.4950237,   51.5726318,  -8.18181801
  36814,  -25.4022465,   51.6308784,  -8.18181801
  36815,  -26.3094692,   51.6891251,  -8.18181801
  36816,   -27.216692,   51.7473679,  -8.18181801
  36817,  -28.1239147,   51.8056145,  -8.18181801
  36818,  -29.0311394,   51.8638611,  -8.18181801
  36819,  -20.8661308,   51.3396492,    -9.090909
  36820,  -21.7733536,   51.3978958,    -9.090909
  36821,  -22.6805763,   51.4561424,    -9.090909
  36822,   -23.587801,   51.5143852,    -9.090909
  36823,  -24.4950237,   51.5726318,    -9.090909
  36824,  -25.4022465,   51.6308784,    -9.090909
  36825,  -26.3094692,   51.6891251,    -9.090909
  36826,   -27.216692,   51.7473679,    -9.090909
  36827,  -28.1239147,   51.8056145,    -9.090909
  36828,  -29.0311394,   51.8638611,    -9.090909
  36829,  -20.8983479,   50.6701698, -0.909090936
  36830,  -21.8069725,   50.6993065, -0.909090936
  36831,  -22.7155952,   50.7284431, -0.909090936
  36832,  -23.6242199,   50.7575836, -0.909090936
  36833,  -24.5328426,   50.7867203, -0.909090936
  36834,  -25.4414673,   50.8158569, -0.909090936
  36835,  -26.3500919,   50.8449974, -0.909090936
  36836,  -27.2587147,   50.8741341, -0.909090936
  36837,  -28.1673393,   50.9032707, -0.909090936
  36838,  -29.0759621,   50.9324112, -0.909090936
  36839,  -20.8983479,   50.6701698,  -1.81818187
  36840,  -21.8069725,   50.6993065,  -1.81818187
  36841,  -22.7155952,   50.7284431,  -1.81818187
  36842,  -23.6242199,   50.7575836,  -1.81818187
  36843,  -24.5328426,   50.7867203,  -1.81818187
  36844,  -25.4414673,   50.8158569,  -1.81818187
  36845,  -26.3500919,   50.8449974,  -1.81818187
  36846,  -27.2587147,   50.8741341,  -1.81818187
  36847,  -28.1673393,   50.9032707,  -1.81818187
  36848,  -29.0759621,   50.9324112,  -1.81818187
  36849,  -20.8983479,   50.6701698,  -2.72727275
  36850,  -21.8069725,   50.6993065,  -2.72727275
  36851,  -22.7155952,   50.7284431,  -2.72727275
  36852,  -23.6242199,   50.7575836,  -2.72727275
  36853,  -24.5328426,   50.7867203,  -2.72727275
  36854,  -25.4414673,   50.8158569,  -2.72727275
  36855,  -26.3500919,   50.8449974,  -2.72727275
  36856,  -27.2587147,   50.8741341,  -2.72727275
  36857,  -28.1673393,   50.9032707,  -2.72727275
  36858,  -29.0759621,   50.9324112,  -2.72727275
  36859,  -20.8983479,   50.6701698,  -3.63636374
  36860,  -21.8069725,   50.6993065,  -3.63636374
  36861,  -22.7155952,   50.7284431,  -3.63636374
  36862,  -23.6242199,   50.7575836,  -3.63636374
  36863,  -24.5328426,   50.7867203,  -3.63636374
  36864,  -25.4414673,   50.8158569,  -3.63636374
  36865,  -26.3500919,   50.8449974,  -3.63636374
  36866,  -27.2587147,   50.8741341,  -3.63636374
  36867,  -28.1673393,   50.9032707,  -3.63636374
  36868,  -29.0759621,   50.9324112,  -3.63636374
  36869,  -20.8983479,   50.6701698,   -4.5454545
  36870,  -21.8069725,   50.6993065,   -4.5454545
  36871,  -22.7155952,   50.7284431,   -4.5454545
  36872,  -23.6242199,   50.7575836,   -4.5454545
  36873,  -24.5328426,   50.7867203,   -4.5454545
  36874,  -25.4414673,   50.8158569,   -4.5454545
  36875,  -26.3500919,   50.8449974,   -4.5454545
  36876,  -27.2587147,   50.8741341,   -4.5454545
  36877,  -28.1673393,   50.9032707,   -4.5454545
  36878,  -29.0759621,   50.9324112,   -4.5454545
  36879,  -20.8983479,   50.6701698,   -5.4545455
  36880,  -21.8069725,   50.6993065,   -5.4545455
  36881,  -22.7155952,   50.7284431,   -5.4545455
  36882,  -23.6242199,   50.7575836,   -5.4545455
  36883,  -24.5328426,   50.7867203,   -5.4545455
  36884,  -25.4414673,   50.8158569,   -5.4545455
  36885,  -26.3500919,   50.8449974,   -5.4545455
  36886,  -27.2587147,   50.8741341,   -5.4545455
  36887,  -28.1673393,   50.9032707,   -5.4545455
  36888,  -29.0759621,   50.9324112,   -5.4545455
  36889,  -20.8983479,   50.6701698,  -6.36363649
  36890,  -21.8069725,   50.6993065,  -6.36363649
  36891,  -22.7155952,   50.7284431,  -6.36363649
  36892,  -23.6242199,   50.7575836,  -6.36363649
  36893,  -24.5328426,   50.7867203,  -6.36363649
  36894,  -25.4414673,   50.8158569,  -6.36363649
  36895,  -26.3500919,   50.8449974,  -6.36363649
  36896,  -27.2587147,   50.8741341,  -6.36363649
  36897,  -28.1673393,   50.9032707,  -6.36363649
  36898,  -29.0759621,   50.9324112,  -6.36363649
  36899,  -20.8983479,   50.6701698,  -7.27272749
  36900,  -21.8069725,   50.6993065,  -7.27272749
  36901,  -22.7155952,   50.7284431,  -7.27272749
  36902,  -23.6242199,   50.7575836,  -7.27272749
  36903,  -24.5328426,   50.7867203,  -7.27272749
  36904,  -25.4414673,   50.8158569,  -7.27272749
  36905,  -26.3500919,   50.8449974,  -7.27272749
  36906,  -27.2587147,   50.8741341,  -7.27272749
  36907,  -28.1673393,   50.9032707,  -7.27272749
  36908,  -29.0759621,   50.9324112,  -7.27272749
  36909,  -20.8983479,   50.6701698,  -8.18181801
  36910,  -21.8069725,   50.6993065,  -8.18181801
  36911,  -22.7155952,   50.7284431,  -8.18181801
  36912,  -23.6242199,   50.7575836,  -8.18181801
  36913,  -24.5328426,   50.7867203,  -8.18181801
  36914,  -25.4414673,   50.8158569,  -8.18181801
  36915,  -26.3500919,   50.8449974,  -8.18181801
  36916,  -27.2587147,   50.8741341,  -8.18181801
  36917,  -28.1673393,   50.9032707,  -8.18181801
  36918,  -29.0759621,   50.9324112,  -8.18181801
  36919,  -20.8983479,   50.6701698,    -9.090909
  36920,  -21.8069725,   50.6993065,    -9.090909
  36921,  -22.7155952,   50.7284431,    -9.090909
  36922,  -23.6242199,   50.7575836,    -9.090909
  36923,  -24.5328426,   50.7867203,    -9.090909
  36924,  -25.4414673,   50.8158569,    -9.090909
  36925,  -26.3500919,   50.8449974,    -9.090909
  36926,  -27.2587147,   50.8741341,    -9.090909
  36927,  -28.1673393,   50.9032707,    -9.090909
  36928,  -29.0759621,   50.9324112,    -9.090909
  36929,   29.0759621,   50.9324112,  0.909090936
  36930,   29.0311394,   51.8638611,  0.909090936
  36931,   28.9564838,    52.793396,  0.909090936
  36932,   28.8520737,   53.7200623,  0.909090936
  36933,   28.7180157,   54.6429062,  0.909090936
  36934,   28.5544472,   55.5609779,  0.909090936
  36935,   28.3615398,   56.4733353,  0.909090936
  36936,   28.1394863,   57.3790436,  0.909090936
  36937,   27.8885193,   58.2771645,  0.909090936
  36938,   27.6088943,   59.1667862,  0.909090936
  36939,   27.3008995,   60.0469818,  0.909090936
  36940,   26.9648514,   60.9168587,  0.909090936
  36941,   26.6010952,   61.7755165,  0.909090936
  36942,   26.2100029,   62.6220741,  0.909090936
  36943,   25.7919807,    63.455658,  0.909090936
  36944,   25.3474541,   64.2754211,  0.909090936
  36945,   24.8768787,    65.080513,  0.909090936
  36946,    24.380743,   65.8701096,  0.909090936
  36947,   23.8595581,   66.6433945,  0.909090936
  36948,   23.3138523,   67.3995819,  0.909090936
  36949,   22.7441864,    68.137886,  0.909090936
  36950,   22.1511555,   68.8575516,  0.909090936
  36951,   21.5353584,   69.5578461,  0.909090936
  36952,   20.8974361,   70.2380371,  0.909090936
  36953,   20.2380352,    70.897438,  0.909090936
  36954,   19.5578423,   71.5353622,  0.909090936
  36955,   18.8575554,   72.1511536,  0.909090936
  36956,    18.137888,   72.7441864,  0.909090936
  36957,   17.3995781,   73.3138504,  0.909090936
  36958,   16.6433926,   73.8595581,  0.909090936
  36959,   15.8701038,   74.3807449,  0.909090936
  36960,    15.080512,   74.8768768,  0.909090936
  36961,   14.2754183,   75.3474503,  0.909090936
  36962,   13.4556599,   75.7919769,  0.909090936
  36963,   12.6220713,   76.2100067,  0.909090936
  36964,   11.7755146,   76.6010971,  0.909090936
  36965,   10.9168587,   76.9648514,  0.909090936
  36966,   10.0469837,   77.3009033,  0.909090936
  36967,   9.16678429,   77.6088943,  0.909090936
  36968,   8.27716732,   77.8885193,  0.909090936
  36969,    7.3790431,   78.1394882,  0.909090936
  36970,   6.47333527,   78.3615417,  0.909090936
  36971,   5.56097794,    78.554451,  0.909090936
  36972,   4.64290571,   78.7180176,  0.909090936
  36973,   3.72006297,   78.8520737,  0.909090936
  36974,   2.79339719,   78.9564819,  0.909090936
  36975,   1.86386096,   79.0311356,  0.909090936
  36976,  0.932409465,   79.0759659,  0.909090936
  36977,           0.,   79.0909119,  0.909090936
  36978, -0.932409465,   79.0759659,  0.909090936
  36979,  -1.86386096,   79.0311356,  0.909090936
  36980,  -2.79339719,   78.9564819,  0.909090936
  36981,  -3.72006297,   78.8520737,  0.909090936
  36982,  -4.64290571,   78.7180176,  0.909090936
  36983,  -5.56097794,    78.554451,  0.909090936
  36984,  -6.47333527,   78.3615417,  0.909090936
  36985,   -7.3790431,   78.1394882,  0.909090936
  36986,  -8.27716732,   77.8885193,  0.909090936
  36987,  -9.16678429,   77.6088943,  0.909090936
  36988,  -10.0469837,   77.3009033,  0.909090936
  36989,  -10.9168587,   76.9648514,  0.909090936
  36990,  -11.7755146,   76.6010971,  0.909090936
  36991,  -12.6220713,   76.2100067,  0.909090936
  36992,  -13.4556599,   75.7919769,  0.909090936
  36993,  -14.2754183,   75.3474503,  0.909090936
  36994,   -15.080512,   74.8768768,  0.909090936
  36995,  -15.8701038,   74.3807449,  0.909090936
  36996,  -16.6433926,   73.8595581,  0.909090936
  36997,  -17.3995781,   73.3138504,  0.909090936
  36998,   -18.137888,   72.7441864,  0.909090936
  36999,  -18.8575554,   72.1511536,  0.909090936
  37000,  -19.5578423,   71.5353622,  0.909090936
  37001,  -20.2380352,    70.897438,  0.909090936
  37002,  -20.8974361,   70.2380371,  0.909090936
  37003,  -21.5353584,   69.5578461,  0.909090936
  37004,  -22.1511555,   68.8575516,  0.909090936
  37005,  -22.7441864,    68.137886,  0.909090936
  37006,  -23.3138523,   67.3995819,  0.909090936
  37007,  -23.8595581,   66.6433945,  0.909090936
  37008,   -24.380743,   65.8701096,  0.909090936
  37009,  -24.8768787,    65.080513,  0.909090936
  37010,  -25.3474541,   64.2754211,  0.909090936
  37011,  -25.7919807,    63.455658,  0.909090936
  37012,  -26.2100029,   62.6220741,  0.909090936
  37013,  -26.6010952,   61.7755165,  0.909090936
  37014,  -26.9648514,   60.9168587,  0.909090936
  37015,  -27.3008995,   60.0469818,  0.909090936
  37016,  -27.6088943,   59.1667862,  0.909090936
  37017,  -27.8885193,   58.2771645,  0.909090936
  37018,  -28.1394863,   57.3790436,  0.909090936
  37019,  -28.3615398,   56.4733353,  0.909090936
  37020,  -28.5544472,   55.5609779,  0.909090936
  37021,  -28.7180157,   54.6429062,  0.909090936
  37022,  -28.8520737,   53.7200623,  0.909090936
  37023,  -28.9564838,    52.793396,  0.909090936
  37024,  -29.0311394,   51.8638611,  0.909090936
  37025,  -29.0759621,   50.9324112,  0.909090936
  37026,   29.0759621,   50.9324112,   1.81818187
  37027,   29.0311394,   51.8638611,   1.81818187
  37028,   28.9564838,    52.793396,   1.81818187
  37029,   28.8520737,   53.7200623,   1.81818187
  37030,   28.7180157,   54.6429062,   1.81818187
  37031,   28.5544472,   55.5609779,   1.81818187
  37032,   28.3615398,   56.4733353,   1.81818187
  37033,   28.1394863,   57.3790436,   1.81818187
  37034,   27.8885193,   58.2771645,   1.81818187
  37035,   27.6088943,   59.1667862,   1.81818187
  37036,   27.3008995,   60.0469818,   1.81818187
  37037,   26.9648514,   60.9168587,   1.81818187
  37038,   26.6010952,   61.7755165,   1.81818187
  37039,   26.2100029,   62.6220741,   1.81818187
  37040,   25.7919807,    63.455658,   1.81818187
  37041,   25.3474541,   64.2754211,   1.81818187
  37042,   24.8768787,    65.080513,   1.81818187
  37043,    24.380743,   65.8701096,   1.81818187
  37044,   23.8595581,   66.6433945,   1.81818187
  37045,   23.3138523,   67.3995819,   1.81818187
  37046,   22.7441864,    68.137886,   1.81818187
  37047,   22.1511555,   68.8575516,   1.81818187
  37048,   21.5353584,   69.5578461,   1.81818187
  37049,   20.8974361,   70.2380371,   1.81818187
  37050,   20.2380352,    70.897438,   1.81818187
  37051,   19.5578423,   71.5353622,   1.81818187
  37052,   18.8575554,   72.1511536,   1.81818187
  37053,    18.137888,   72.7441864,   1.81818187
  37054,   17.3995781,   73.3138504,   1.81818187
  37055,   16.6433926,   73.8595581,   1.81818187
  37056,   15.8701038,   74.3807449,   1.81818187
  37057,    15.080512,   74.8768768,   1.81818187
  37058,   14.2754183,   75.3474503,   1.81818187
  37059,   13.4556599,   75.7919769,   1.81818187
  37060,   12.6220713,   76.2100067,   1.81818187
  37061,   11.7755146,   76.6010971,   1.81818187
  37062,   10.9168587,   76.9648514,   1.81818187
  37063,   10.0469837,   77.3009033,   1.81818187
  37064,   9.16678429,   77.6088943,   1.81818187
  37065,   8.27716732,   77.8885193,   1.81818187
  37066,    7.3790431,   78.1394882,   1.81818187
  37067,   6.47333527,   78.3615417,   1.81818187
  37068,   5.56097794,    78.554451,   1.81818187
  37069,   4.64290571,   78.7180176,   1.81818187
  37070,   3.72006297,   78.8520737,   1.81818187
  37071,   2.79339719,   78.9564819,   1.81818187
  37072,   1.86386096,   79.0311356,   1.81818187
  37073,  0.932409465,   79.0759659,   1.81818187
  37074,           0.,   79.0909119,   1.81818187
  37075, -0.932409465,   79.0759659,   1.81818187
  37076,  -1.86386096,   79.0311356,   1.81818187
  37077,  -2.79339719,   78.9564819,   1.81818187
  37078,  -3.72006297,   78.8520737,   1.81818187
  37079,  -4.64290571,   78.7180176,   1.81818187
  37080,  -5.56097794,    78.554451,   1.81818187
  37081,  -6.47333527,   78.3615417,   1.81818187
  37082,   -7.3790431,   78.1394882,   1.81818187
  37083,  -8.27716732,   77.8885193,   1.81818187
  37084,  -9.16678429,   77.6088943,   1.81818187
  37085,  -10.0469837,   77.3009033,   1.81818187
  37086,  -10.9168587,   76.9648514,   1.81818187
  37087,  -11.7755146,   76.6010971,   1.81818187
  37088,  -12.6220713,   76.2100067,   1.81818187
  37089,  -13.4556599,   75.7919769,   1.81818187
  37090,  -14.2754183,   75.3474503,   1.81818187
  37091,   -15.080512,   74.8768768,   1.81818187
  37092,  -15.8701038,   74.3807449,   1.81818187
  37093,  -16.6433926,   73.8595581,   1.81818187
  37094,  -17.3995781,   73.3138504,   1.81818187
  37095,   -18.137888,   72.7441864,   1.81818187
  37096,  -18.8575554,   72.1511536,   1.81818187
  37097,  -19.5578423,   71.5353622,   1.81818187
  37098,  -20.2380352,    70.897438,   1.81818187
  37099,  -20.8974361,   70.2380371,   1.81818187
  37100,  -21.5353584,   69.5578461,   1.81818187
  37101,  -22.1511555,   68.8575516,   1.81818187
  37102,  -22.7441864,    68.137886,   1.81818187
  37103,  -23.3138523,   67.3995819,   1.81818187
  37104,  -23.8595581,   66.6433945,   1.81818187
  37105,   -24.380743,   65.8701096,   1.81818187
  37106,  -24.8768787,    65.080513,   1.81818187
  37107,  -25.3474541,   64.2754211,   1.81818187
  37108,  -25.7919807,    63.455658,   1.81818187
  37109,  -26.2100029,   62.6220741,   1.81818187
  37110,  -26.6010952,   61.7755165,   1.81818187
  37111,  -26.9648514,   60.9168587,   1.81818187
  37112,  -27.3008995,   60.0469818,   1.81818187
  37113,  -27.6088943,   59.1667862,   1.81818187
  37114,  -27.8885193,   58.2771645,   1.81818187
  37115,  -28.1394863,   57.3790436,   1.81818187
  37116,  -28.3615398,   56.4733353,   1.81818187
  37117,  -28.5544472,   55.5609779,   1.81818187
  37118,  -28.7180157,   54.6429062,   1.81818187
  37119,  -28.8520737,   53.7200623,   1.81818187
  37120,  -28.9564838,    52.793396,   1.81818187
  37121,  -29.0311394,   51.8638611,   1.81818187
  37122,  -29.0759621,   50.9324112,   1.81818187
  37123,   29.0759621,   50.9324112,   2.72727275
  37124,   29.0311394,   51.8638611,   2.72727275
  37125,   28.9564838,    52.793396,   2.72727275
  37126,   28.8520737,   53.7200623,   2.72727275
  37127,   28.7180157,   54.6429062,   2.72727275
  37128,   28.5544472,   55.5609779,   2.72727275
  37129,   28.3615398,   56.4733353,   2.72727275
  37130,   28.1394863,   57.3790436,   2.72727275
  37131,   27.8885193,   58.2771645,   2.72727275
  37132,   27.6088943,   59.1667862,   2.72727275
  37133,   27.3008995,   60.0469818,   2.72727275
  37134,   26.9648514,   60.9168587,   2.72727275
  37135,   26.6010952,   61.7755165,   2.72727275
  37136,   26.2100029,   62.6220741,   2.72727275
  37137,   25.7919807,    63.455658,   2.72727275
  37138,   25.3474541,   64.2754211,   2.72727275
  37139,   24.8768787,    65.080513,   2.72727275
  37140,    24.380743,   65.8701096,   2.72727275
  37141,   23.8595581,   66.6433945,   2.72727275
  37142,   23.3138523,   67.3995819,   2.72727275
  37143,   22.7441864,    68.137886,   2.72727275
  37144,   22.1511555,   68.8575516,   2.72727275
  37145,   21.5353584,   69.5578461,   2.72727275
  37146,   20.8974361,   70.2380371,   2.72727275
  37147,   20.2380352,    70.897438,   2.72727275
  37148,   19.5578423,   71.5353622,   2.72727275
  37149,   18.8575554,   72.1511536,   2.72727275
  37150,    18.137888,   72.7441864,   2.72727275
  37151,   17.3995781,   73.3138504,   2.72727275
  37152,   16.6433926,   73.8595581,   2.72727275
  37153,   15.8701038,   74.3807449,   2.72727275
  37154,    15.080512,   74.8768768,   2.72727275
  37155,   14.2754183,   75.3474503,   2.72727275
  37156,   13.4556599,   75.7919769,   2.72727275
  37157,   12.6220713,   76.2100067,   2.72727275
  37158,   11.7755146,   76.6010971,   2.72727275
  37159,   10.9168587,   76.9648514,   2.72727275
  37160,   10.0469837,   77.3009033,   2.72727275
  37161,   9.16678429,   77.6088943,   2.72727275
  37162,   8.27716732,   77.8885193,   2.72727275
  37163,    7.3790431,   78.1394882,   2.72727275
  37164,   6.47333527,   78.3615417,   2.72727275
  37165,   5.56097794,    78.554451,   2.72727275
  37166,   4.64290571,   78.7180176,   2.72727275
  37167,   3.72006297,   78.8520737,   2.72727275
  37168,   2.79339719,   78.9564819,   2.72727275
  37169,   1.86386096,   79.0311356,   2.72727275
  37170,  0.932409465,   79.0759659,   2.72727275
  37171,           0.,   79.0909119,   2.72727275
  37172, -0.932409465,   79.0759659,   2.72727275
  37173,  -1.86386096,   79.0311356,   2.72727275
  37174,  -2.79339719,   78.9564819,   2.72727275
  37175,  -3.72006297,   78.8520737,   2.72727275
  37176,  -4.64290571,   78.7180176,   2.72727275
  37177,  -5.56097794,    78.554451,   2.72727275
  37178,  -6.47333527,   78.3615417,   2.72727275
  37179,   -7.3790431,   78.1394882,   2.72727275
  37180,  -8.27716732,   77.8885193,   2.72727275
  37181,  -9.16678429,   77.6088943,   2.72727275
  37182,  -10.0469837,   77.3009033,   2.72727275
  37183,  -10.9168587,   76.9648514,   2.72727275
  37184,  -11.7755146,   76.6010971,   2.72727275
  37185,  -12.6220713,   76.2100067,   2.72727275
  37186,  -13.4556599,   75.7919769,   2.72727275
  37187,  -14.2754183,   75.3474503,   2.72727275
  37188,   -15.080512,   74.8768768,   2.72727275
  37189,  -15.8701038,   74.3807449,   2.72727275
  37190,  -16.6433926,   73.8595581,   2.72727275
  37191,  -17.3995781,   73.3138504,   2.72727275
  37192,   -18.137888,   72.7441864,   2.72727275
  37193,  -18.8575554,   72.1511536,   2.72727275
  37194,  -19.5578423,   71.5353622,   2.72727275
  37195,  -20.2380352,    70.897438,   2.72727275
  37196,  -20.8974361,   70.2380371,   2.72727275
  37197,  -21.5353584,   69.5578461,   2.72727275
  37198,  -22.1511555,   68.8575516,   2.72727275
  37199,  -22.7441864,    68.137886,   2.72727275
  37200,  -23.3138523,   67.3995819,   2.72727275
  37201,  -23.8595581,   66.6433945,   2.72727275
  37202,   -24.380743,   65.8701096,   2.72727275
  37203,  -24.8768787,    65.080513,   2.72727275
  37204,  -25.3474541,   64.2754211,   2.72727275
  37205,  -25.7919807,    63.455658,   2.72727275
  37206,  -26.2100029,   62.6220741,   2.72727275
  37207,  -26.6010952,   61.7755165,   2.72727275
  37208,  -26.9648514,   60.9168587,   2.72727275
  37209,  -27.3008995,   60.0469818,   2.72727275
  37210,  -27.6088943,   59.1667862,   2.72727275
  37211,  -27.8885193,   58.2771645,   2.72727275
  37212,  -28.1394863,   57.3790436,   2.72727275
  37213,  -28.3615398,   56.4733353,   2.72727275
  37214,  -28.5544472,   55.5609779,   2.72727275
  37215,  -28.7180157,   54.6429062,   2.72727275
  37216,  -28.8520737,   53.7200623,   2.72727275
  37217,  -28.9564838,    52.793396,   2.72727275
  37218,  -29.0311394,   51.8638611,   2.72727275
  37219,  -29.0759621,   50.9324112,   2.72727275
  37220,   29.0759621,   50.9324112,   3.63636374
  37221,   29.0311394,   51.8638611,   3.63636374
  37222,   28.9564838,    52.793396,   3.63636374
  37223,   28.8520737,   53.7200623,   3.63636374
  37224,   28.7180157,   54.6429062,   3.63636374
  37225,   28.5544472,   55.5609779,   3.63636374
  37226,   28.3615398,   56.4733353,   3.63636374
  37227,   28.1394863,   57.3790436,   3.63636374
  37228,   27.8885193,   58.2771645,   3.63636374
  37229,   27.6088943,   59.1667862,   3.63636374
  37230,   27.3008995,   60.0469818,   3.63636374
  37231,   26.9648514,   60.9168587,   3.63636374
  37232,   26.6010952,   61.7755165,   3.63636374
  37233,   26.2100029,   62.6220741,   3.63636374
  37234,   25.7919807,    63.455658,   3.63636374
  37235,   25.3474541,   64.2754211,   3.63636374
  37236,   24.8768787,    65.080513,   3.63636374
  37237,    24.380743,   65.8701096,   3.63636374
  37238,   23.8595581,   66.6433945,   3.63636374
  37239,   23.3138523,   67.3995819,   3.63636374
  37240,   22.7441864,    68.137886,   3.63636374
  37241,   22.1511555,   68.8575516,   3.63636374
  37242,   21.5353584,   69.5578461,   3.63636374
  37243,   20.8974361,   70.2380371,   3.63636374
  37244,   20.2380352,    70.897438,   3.63636374
  37245,   19.5578423,   71.5353622,   3.63636374
  37246,   18.8575554,   72.1511536,   3.63636374
  37247,    18.137888,   72.7441864,   3.63636374
  37248,   17.3995781,   73.3138504,   3.63636374
  37249,   16.6433926,   73.8595581,   3.63636374
  37250,   15.8701038,   74.3807449,   3.63636374
  37251,    15.080512,   74.8768768,   3.63636374
  37252,   14.2754183,   75.3474503,   3.63636374
  37253,   13.4556599,   75.7919769,   3.63636374
  37254,   12.6220713,   76.2100067,   3.63636374
  37255,   11.7755146,   76.6010971,   3.63636374
  37256,   10.9168587,   76.9648514,   3.63636374
  37257,   10.0469837,   77.3009033,   3.63636374
  37258,   9.16678429,   77.6088943,   3.63636374
  37259,   8.27716732,   77.8885193,   3.63636374
  37260,    7.3790431,   78.1394882,   3.63636374
  37261,   6.47333527,   78.3615417,   3.63636374
  37262,   5.56097794,    78.554451,   3.63636374
  37263,   4.64290571,   78.7180176,   3.63636374
  37264,   3.72006297,   78.8520737,   3.63636374
  37265,   2.79339719,   78.9564819,   3.63636374
  37266,   1.86386096,   79.0311356,   3.63636374
  37267,  0.932409465,   79.0759659,   3.63636374
  37268,           0.,   79.0909119,   3.63636374
  37269, -0.932409465,   79.0759659,   3.63636374
  37270,  -1.86386096,   79.0311356,   3.63636374
  37271,  -2.79339719,   78.9564819,   3.63636374
  37272,  -3.72006297,   78.8520737,   3.63636374
  37273,  -4.64290571,   78.7180176,   3.63636374
  37274,  -5.56097794,    78.554451,   3.63636374
  37275,  -6.47333527,   78.3615417,   3.63636374
  37276,   -7.3790431,   78.1394882,   3.63636374
  37277,  -8.27716732,   77.8885193,   3.63636374
  37278,  -9.16678429,   77.6088943,   3.63636374
  37279,  -10.0469837,   77.3009033,   3.63636374
  37280,  -10.9168587,   76.9648514,   3.63636374
  37281,  -11.7755146,   76.6010971,   3.63636374
  37282,  -12.6220713,   76.2100067,   3.63636374
  37283,  -13.4556599,   75.7919769,   3.63636374
  37284,  -14.2754183,   75.3474503,   3.63636374
  37285,   -15.080512,   74.8768768,   3.63636374
  37286,  -15.8701038,   74.3807449,   3.63636374
  37287,  -16.6433926,   73.8595581,   3.63636374
  37288,  -17.3995781,   73.3138504,   3.63636374
  37289,   -18.137888,   72.7441864,   3.63636374
  37290,  -18.8575554,   72.1511536,   3.63636374
  37291,  -19.5578423,   71.5353622,   3.63636374
  37292,  -20.2380352,    70.897438,   3.63636374
  37293,  -20.8974361,   70.2380371,   3.63636374
  37294,  -21.5353584,   69.5578461,   3.63636374
  37295,  -22.1511555,   68.8575516,   3.63636374
  37296,  -22.7441864,    68.137886,   3.63636374
  37297,  -23.3138523,   67.3995819,   3.63636374
  37298,  -23.8595581,   66.6433945,   3.63636374
  37299,   -24.380743,   65.8701096,   3.63636374
  37300,  -24.8768787,    65.080513,   3.63636374
  37301,  -25.3474541,   64.2754211,   3.63636374
  37302,  -25.7919807,    63.455658,   3.63636374
  37303,  -26.2100029,   62.6220741,   3.63636374
  37304,  -26.6010952,   61.7755165,   3.63636374
  37305,  -26.9648514,   60.9168587,   3.63636374
  37306,  -27.3008995,   60.0469818,   3.63636374
  37307,  -27.6088943,   59.1667862,   3.63636374
  37308,  -27.8885193,   58.2771645,   3.63636374
  37309,  -28.1394863,   57.3790436,   3.63636374
  37310,  -28.3615398,   56.4733353,   3.63636374
  37311,  -28.5544472,   55.5609779,   3.63636374
  37312,  -28.7180157,   54.6429062,   3.63636374
  37313,  -28.8520737,   53.7200623,   3.63636374
  37314,  -28.9564838,    52.793396,   3.63636374
  37315,  -29.0311394,   51.8638611,   3.63636374
  37316,  -29.0759621,   50.9324112,   3.63636374
  37317,   29.0759621,   50.9324112,    4.5454545
  37318,   29.0311394,   51.8638611,    4.5454545
  37319,   28.9564838,    52.793396,    4.5454545
  37320,   28.8520737,   53.7200623,    4.5454545
  37321,   28.7180157,   54.6429062,    4.5454545
  37322,   28.5544472,   55.5609779,    4.5454545
  37323,   28.3615398,   56.4733353,    4.5454545
  37324,   28.1394863,   57.3790436,    4.5454545
  37325,   27.8885193,   58.2771645,    4.5454545
  37326,   27.6088943,   59.1667862,    4.5454545
  37327,   27.3008995,   60.0469818,    4.5454545
  37328,   26.9648514,   60.9168587,    4.5454545
  37329,   26.6010952,   61.7755165,    4.5454545
  37330,   26.2100029,   62.6220741,    4.5454545
  37331,   25.7919807,    63.455658,    4.5454545
  37332,   25.3474541,   64.2754211,    4.5454545
  37333,   24.8768787,    65.080513,    4.5454545
  37334,    24.380743,   65.8701096,    4.5454545
  37335,   23.8595581,   66.6433945,    4.5454545
  37336,   23.3138523,   67.3995819,    4.5454545
  37337,   22.7441864,    68.137886,    4.5454545
  37338,   22.1511555,   68.8575516,    4.5454545
  37339,   21.5353584,   69.5578461,    4.5454545
  37340,   20.8974361,   70.2380371,    4.5454545
  37341,   20.2380352,    70.897438,    4.5454545
  37342,   19.5578423,   71.5353622,    4.5454545
  37343,   18.8575554,   72.1511536,    4.5454545
  37344,    18.137888,   72.7441864,    4.5454545
  37345,   17.3995781,   73.3138504,    4.5454545
  37346,   16.6433926,   73.8595581,    4.5454545
  37347,   15.8701038,   74.3807449,    4.5454545
  37348,    15.080512,   74.8768768,    4.5454545
  37349,   14.2754183,   75.3474503,    4.5454545
  37350,   13.4556599,   75.7919769,    4.5454545
  37351,   12.6220713,   76.2100067,    4.5454545
  37352,   11.7755146,   76.6010971,    4.5454545
  37353,   10.9168587,   76.9648514,    4.5454545
  37354,   10.0469837,   77.3009033,    4.5454545
  37355,   9.16678429,   77.6088943,    4.5454545
  37356,   8.27716732,   77.8885193,    4.5454545
  37357,    7.3790431,   78.1394882,    4.5454545
  37358,   6.47333527,   78.3615417,    4.5454545
  37359,   5.56097794,    78.554451,    4.5454545
  37360,   4.64290571,   78.7180176,    4.5454545
  37361,   3.72006297,   78.8520737,    4.5454545
  37362,   2.79339719,   78.9564819,    4.5454545
  37363,   1.86386096,   79.0311356,    4.5454545
  37364,  0.932409465,   79.0759659,    4.5454545
  37365,           0.,   79.0909119,    4.5454545
  37366, -0.932409465,   79.0759659,    4.5454545
  37367,  -1.86386096,   79.0311356,    4.5454545
  37368,  -2.79339719,   78.9564819,    4.5454545
  37369,  -3.72006297,   78.8520737,    4.5454545
  37370,  -4.64290571,   78.7180176,    4.5454545
  37371,  -5.56097794,    78.554451,    4.5454545
  37372,  -6.47333527,   78.3615417,    4.5454545
  37373,   -7.3790431,   78.1394882,    4.5454545
  37374,  -8.27716732,   77.8885193,    4.5454545
  37375,  -9.16678429,   77.6088943,    4.5454545
  37376,  -10.0469837,   77.3009033,    4.5454545
  37377,  -10.9168587,   76.9648514,    4.5454545
  37378,  -11.7755146,   76.6010971,    4.5454545
  37379,  -12.6220713,   76.2100067,    4.5454545
  37380,  -13.4556599,   75.7919769,    4.5454545
  37381,  -14.2754183,   75.3474503,    4.5454545
  37382,   -15.080512,   74.8768768,    4.5454545
  37383,  -15.8701038,   74.3807449,    4.5454545
  37384,  -16.6433926,   73.8595581,    4.5454545
  37385,  -17.3995781,   73.3138504,    4.5454545
  37386,   -18.137888,   72.7441864,    4.5454545
  37387,  -18.8575554,   72.1511536,    4.5454545
  37388,  -19.5578423,   71.5353622,    4.5454545
  37389,  -20.2380352,    70.897438,    4.5454545
  37390,  -20.8974361,   70.2380371,    4.5454545
  37391,  -21.5353584,   69.5578461,    4.5454545
  37392,  -22.1511555,   68.8575516,    4.5454545
  37393,  -22.7441864,    68.137886,    4.5454545
  37394,  -23.3138523,   67.3995819,    4.5454545
  37395,  -23.8595581,   66.6433945,    4.5454545
  37396,   -24.380743,   65.8701096,    4.5454545
  37397,  -24.8768787,    65.080513,    4.5454545
  37398,  -25.3474541,   64.2754211,    4.5454545
  37399,  -25.7919807,    63.455658,    4.5454545
  37400,  -26.2100029,   62.6220741,    4.5454545
  37401,  -26.6010952,   61.7755165,    4.5454545
  37402,  -26.9648514,   60.9168587,    4.5454545
  37403,  -27.3008995,   60.0469818,    4.5454545
  37404,  -27.6088943,   59.1667862,    4.5454545
  37405,  -27.8885193,   58.2771645,    4.5454545
  37406,  -28.1394863,   57.3790436,    4.5454545
  37407,  -28.3615398,   56.4733353,    4.5454545
  37408,  -28.5544472,   55.5609779,    4.5454545
  37409,  -28.7180157,   54.6429062,    4.5454545
  37410,  -28.8520737,   53.7200623,    4.5454545
  37411,  -28.9564838,    52.793396,    4.5454545
  37412,  -29.0311394,   51.8638611,    4.5454545
  37413,  -29.0759621,   50.9324112,    4.5454545
  37414,   29.0759621,   50.9324112,    5.4545455
  37415,   29.0311394,   51.8638611,    5.4545455
  37416,   28.9564838,    52.793396,    5.4545455
  37417,   28.8520737,   53.7200623,    5.4545455
  37418,   28.7180157,   54.6429062,    5.4545455
  37419,   28.5544472,   55.5609779,    5.4545455
  37420,   28.3615398,   56.4733353,    5.4545455
  37421,   28.1394863,   57.3790436,    5.4545455
  37422,   27.8885193,   58.2771645,    5.4545455
  37423,   27.6088943,   59.1667862,    5.4545455
  37424,   27.3008995,   60.0469818,    5.4545455
  37425,   26.9648514,   60.9168587,    5.4545455
  37426,   26.6010952,   61.7755165,    5.4545455
  37427,   26.2100029,   62.6220741,    5.4545455
  37428,   25.7919807,    63.455658,    5.4545455
  37429,   25.3474541,   64.2754211,    5.4545455
  37430,   24.8768787,    65.080513,    5.4545455
  37431,    24.380743,   65.8701096,    5.4545455
  37432,   23.8595581,   66.6433945,    5.4545455
  37433,   23.3138523,   67.3995819,    5.4545455
  37434,   22.7441864,    68.137886,    5.4545455
  37435,   22.1511555,   68.8575516,    5.4545455
  37436,   21.5353584,   69.5578461,    5.4545455
  37437,   20.8974361,   70.2380371,    5.4545455
  37438,   20.2380352,    70.897438,    5.4545455
  37439,   19.5578423,   71.5353622,    5.4545455
  37440,   18.8575554,   72.1511536,    5.4545455
  37441,    18.137888,   72.7441864,    5.4545455
  37442,   17.3995781,   73.3138504,    5.4545455
  37443,   16.6433926,   73.8595581,    5.4545455
  37444,   15.8701038,   74.3807449,    5.4545455
  37445,    15.080512,   74.8768768,    5.4545455
  37446,   14.2754183,   75.3474503,    5.4545455
  37447,   13.4556599,   75.7919769,    5.4545455
  37448,   12.6220713,   76.2100067,    5.4545455
  37449,   11.7755146,   76.6010971,    5.4545455
  37450,   10.9168587,   76.9648514,    5.4545455
  37451,   10.0469837,   77.3009033,    5.4545455
  37452,   9.16678429,   77.6088943,    5.4545455
  37453,   8.27716732,   77.8885193,    5.4545455
  37454,    7.3790431,   78.1394882,    5.4545455
  37455,   6.47333527,   78.3615417,    5.4545455
  37456,   5.56097794,    78.554451,    5.4545455
  37457,   4.64290571,   78.7180176,    5.4545455
  37458,   3.72006297,   78.8520737,    5.4545455
  37459,   2.79339719,   78.9564819,    5.4545455
  37460,   1.86386096,   79.0311356,    5.4545455
  37461,  0.932409465,   79.0759659,    5.4545455
  37462,           0.,   79.0909119,    5.4545455
  37463, -0.932409465,   79.0759659,    5.4545455
  37464,  -1.86386096,   79.0311356,    5.4545455
  37465,  -2.79339719,   78.9564819,    5.4545455
  37466,  -3.72006297,   78.8520737,    5.4545455
  37467,  -4.64290571,   78.7180176,    5.4545455
  37468,  -5.56097794,    78.554451,    5.4545455
  37469,  -6.47333527,   78.3615417,    5.4545455
  37470,   -7.3790431,   78.1394882,    5.4545455
  37471,  -8.27716732,   77.8885193,    5.4545455
  37472,  -9.16678429,   77.6088943,    5.4545455
  37473,  -10.0469837,   77.3009033,    5.4545455
  37474,  -10.9168587,   76.9648514,    5.4545455
  37475,  -11.7755146,   76.6010971,    5.4545455
  37476,  -12.6220713,   76.2100067,    5.4545455
  37477,  -13.4556599,   75.7919769,    5.4545455
  37478,  -14.2754183,   75.3474503,    5.4545455
  37479,   -15.080512,   74.8768768,    5.4545455
  37480,  -15.8701038,   74.3807449,    5.4545455
  37481,  -16.6433926,   73.8595581,    5.4545455
  37482,  -17.3995781,   73.3138504,    5.4545455
  37483,   -18.137888,   72.7441864,    5.4545455
  37484,  -18.8575554,   72.1511536,    5.4545455
  37485,  -19.5578423,   71.5353622,    5.4545455
  37486,  -20.2380352,    70.897438,    5.4545455
  37487,  -20.8974361,   70.2380371,    5.4545455
  37488,  -21.5353584,   69.5578461,    5.4545455
  37489,  -22.1511555,   68.8575516,    5.4545455
  37490,  -22.7441864,    68.137886,    5.4545455
  37491,  -23.3138523,   67.3995819,    5.4545455
  37492,  -23.8595581,   66.6433945,    5.4545455
  37493,   -24.380743,   65.8701096,    5.4545455
  37494,  -24.8768787,    65.080513,    5.4545455
  37495,  -25.3474541,   64.2754211,    5.4545455
  37496,  -25.7919807,    63.455658,    5.4545455
  37497,  -26.2100029,   62.6220741,    5.4545455
  37498,  -26.6010952,   61.7755165,    5.4545455
  37499,  -26.9648514,   60.9168587,    5.4545455
  37500,  -27.3008995,   60.0469818,    5.4545455
  37501,  -27.6088943,   59.1667862,    5.4545455
  37502,  -27.8885193,   58.2771645,    5.4545455
  37503,  -28.1394863,   57.3790436,    5.4545455
  37504,  -28.3615398,   56.4733353,    5.4545455
  37505,  -28.5544472,   55.5609779,    5.4545455
  37506,  -28.7180157,   54.6429062,    5.4545455
  37507,  -28.8520737,   53.7200623,    5.4545455
  37508,  -28.9564838,    52.793396,    5.4545455
  37509,  -29.0311394,   51.8638611,    5.4545455
  37510,  -29.0759621,   50.9324112,    5.4545455
  37511,   29.0759621,   50.9324112,   6.36363649
  37512,   29.0311394,   51.8638611,   6.36363649
  37513,   28.9564838,    52.793396,   6.36363649
  37514,   28.8520737,   53.7200623,   6.36363649
  37515,   28.7180157,   54.6429062,   6.36363649
  37516,   28.5544472,   55.5609779,   6.36363649
  37517,   28.3615398,   56.4733353,   6.36363649
  37518,   28.1394863,   57.3790436,   6.36363649
  37519,   27.8885193,   58.2771645,   6.36363649
  37520,   27.6088943,   59.1667862,   6.36363649
  37521,   27.3008995,   60.0469818,   6.36363649
  37522,   26.9648514,   60.9168587,   6.36363649
  37523,   26.6010952,   61.7755165,   6.36363649
  37524,   26.2100029,   62.6220741,   6.36363649
  37525,   25.7919807,    63.455658,   6.36363649
  37526,   25.3474541,   64.2754211,   6.36363649
  37527,   24.8768787,    65.080513,   6.36363649
  37528,    24.380743,   65.8701096,   6.36363649
  37529,   23.8595581,   66.6433945,   6.36363649
  37530,   23.3138523,   67.3995819,   6.36363649
  37531,   22.7441864,    68.137886,   6.36363649
  37532,   22.1511555,   68.8575516,   6.36363649
  37533,   21.5353584,   69.5578461,   6.36363649
  37534,   20.8974361,   70.2380371,   6.36363649
  37535,   20.2380352,    70.897438,   6.36363649
  37536,   19.5578423,   71.5353622,   6.36363649
  37537,   18.8575554,   72.1511536,   6.36363649
  37538,    18.137888,   72.7441864,   6.36363649
  37539,   17.3995781,   73.3138504,   6.36363649
  37540,   16.6433926,   73.8595581,   6.36363649
  37541,   15.8701038,   74.3807449,   6.36363649
  37542,    15.080512,   74.8768768,   6.36363649
  37543,   14.2754183,   75.3474503,   6.36363649
  37544,   13.4556599,   75.7919769,   6.36363649
  37545,   12.6220713,   76.2100067,   6.36363649
  37546,   11.7755146,   76.6010971,   6.36363649
  37547,   10.9168587,   76.9648514,   6.36363649
  37548,   10.0469837,   77.3009033,   6.36363649
  37549,   9.16678429,   77.6088943,   6.36363649
  37550,   8.27716732,   77.8885193,   6.36363649
  37551,    7.3790431,   78.1394882,   6.36363649
  37552,   6.47333527,   78.3615417,   6.36363649
  37553,   5.56097794,    78.554451,   6.36363649
  37554,   4.64290571,   78.7180176,   6.36363649
  37555,   3.72006297,   78.8520737,   6.36363649
  37556,   2.79339719,   78.9564819,   6.36363649
  37557,   1.86386096,   79.0311356,   6.36363649
  37558,  0.932409465,   79.0759659,   6.36363649
  37559,           0.,   79.0909119,   6.36363649
  37560, -0.932409465,   79.0759659,   6.36363649
  37561,  -1.86386096,   79.0311356,   6.36363649
  37562,  -2.79339719,   78.9564819,   6.36363649
  37563,  -3.72006297,   78.8520737,   6.36363649
  37564,  -4.64290571,   78.7180176,   6.36363649
  37565,  -5.56097794,    78.554451,   6.36363649
  37566,  -6.47333527,   78.3615417,   6.36363649
  37567,   -7.3790431,   78.1394882,   6.36363649
  37568,  -8.27716732,   77.8885193,   6.36363649
  37569,  -9.16678429,   77.6088943,   6.36363649
  37570,  -10.0469837,   77.3009033,   6.36363649
  37571,  -10.9168587,   76.9648514,   6.36363649
  37572,  -11.7755146,   76.6010971,   6.36363649
  37573,  -12.6220713,   76.2100067,   6.36363649
  37574,  -13.4556599,   75.7919769,   6.36363649
  37575,  -14.2754183,   75.3474503,   6.36363649
  37576,   -15.080512,   74.8768768,   6.36363649
  37577,  -15.8701038,   74.3807449,   6.36363649
  37578,  -16.6433926,   73.8595581,   6.36363649
  37579,  -17.3995781,   73.3138504,   6.36363649
  37580,   -18.137888,   72.7441864,   6.36363649
  37581,  -18.8575554,   72.1511536,   6.36363649
  37582,  -19.5578423,   71.5353622,   6.36363649
  37583,  -20.2380352,    70.897438,   6.36363649
  37584,  -20.8974361,   70.2380371,   6.36363649
  37585,  -21.5353584,   69.5578461,   6.36363649
  37586,  -22.1511555,   68.8575516,   6.36363649
  37587,  -22.7441864,    68.137886,   6.36363649
  37588,  -23.3138523,   67.3995819,   6.36363649
  37589,  -23.8595581,   66.6433945,   6.36363649
  37590,   -24.380743,   65.8701096,   6.36363649
  37591,  -24.8768787,    65.080513,   6.36363649
  37592,  -25.3474541,   64.2754211,   6.36363649
  37593,  -25.7919807,    63.455658,   6.36363649
  37594,  -26.2100029,   62.6220741,   6.36363649
  37595,  -26.6010952,   61.7755165,   6.36363649
  37596,  -26.9648514,   60.9168587,   6.36363649
  37597,  -27.3008995,   60.0469818,   6.36363649
  37598,  -27.6088943,   59.1667862,   6.36363649
  37599,  -27.8885193,   58.2771645,   6.36363649
  37600,  -28.1394863,   57.3790436,   6.36363649
  37601,  -28.3615398,   56.4733353,   6.36363649
  37602,  -28.5544472,   55.5609779,   6.36363649
  37603,  -28.7180157,   54.6429062,   6.36363649
  37604,  -28.8520737,   53.7200623,   6.36363649
  37605,  -28.9564838,    52.793396,   6.36363649
  37606,  -29.0311394,   51.8638611,   6.36363649
  37607,  -29.0759621,   50.9324112,   6.36363649
  37608,   29.0759621,   50.9324112,   7.27272749
  37609,   29.0311394,   51.8638611,   7.27272749
  37610,   28.9564838,    52.793396,   7.27272749
  37611,   28.8520737,   53.7200623,   7.27272749
  37612,   28.7180157,   54.6429062,   7.27272749
  37613,   28.5544472,   55.5609779,   7.27272749
  37614,   28.3615398,   56.4733353,   7.27272749
  37615,   28.1394863,   57.3790436,   7.27272749
  37616,   27.8885193,   58.2771645,   7.27272749
  37617,   27.6088943,   59.1667862,   7.27272749
  37618,   27.3008995,   60.0469818,   7.27272749
  37619,   26.9648514,   60.9168587,   7.27272749
  37620,   26.6010952,   61.7755165,   7.27272749
  37621,   26.2100029,   62.6220741,   7.27272749
  37622,   25.7919807,    63.455658,   7.27272749
  37623,   25.3474541,   64.2754211,   7.27272749
  37624,   24.8768787,    65.080513,   7.27272749
  37625,    24.380743,   65.8701096,   7.27272749
  37626,   23.8595581,   66.6433945,   7.27272749
  37627,   23.3138523,   67.3995819,   7.27272749
  37628,   22.7441864,    68.137886,   7.27272749
  37629,   22.1511555,   68.8575516,   7.27272749
  37630,   21.5353584,   69.5578461,   7.27272749
  37631,   20.8974361,   70.2380371,   7.27272749
  37632,   20.2380352,    70.897438,   7.27272749
  37633,   19.5578423,   71.5353622,   7.27272749
  37634,   18.8575554,   72.1511536,   7.27272749
  37635,    18.137888,   72.7441864,   7.27272749
  37636,   17.3995781,   73.3138504,   7.27272749
  37637,   16.6433926,   73.8595581,   7.27272749
  37638,   15.8701038,   74.3807449,   7.27272749
  37639,    15.080512,   74.8768768,   7.27272749
  37640,   14.2754183,   75.3474503,   7.27272749
  37641,   13.4556599,   75.7919769,   7.27272749
  37642,   12.6220713,   76.2100067,   7.27272749
  37643,   11.7755146,   76.6010971,   7.27272749
  37644,   10.9168587,   76.9648514,   7.27272749
  37645,   10.0469837,   77.3009033,   7.27272749
  37646,   9.16678429,   77.6088943,   7.27272749
  37647,   8.27716732,   77.8885193,   7.27272749
  37648,    7.3790431,   78.1394882,   7.27272749
  37649,   6.47333527,   78.3615417,   7.27272749
  37650,   5.56097794,    78.554451,   7.27272749
  37651,   4.64290571,   78.7180176,   7.27272749
  37652,   3.72006297,   78.8520737,   7.27272749
  37653,   2.79339719,   78.9564819,   7.27272749
  37654,   1.86386096,   79.0311356,   7.27272749
  37655,  0.932409465,   79.0759659,   7.27272749
  37656,           0.,   79.0909119,   7.27272749
  37657, -0.932409465,   79.0759659,   7.27272749
  37658,  -1.86386096,   79.0311356,   7.27272749
  37659,  -2.79339719,   78.9564819,   7.27272749
  37660,  -3.72006297,   78.8520737,   7.27272749
  37661,  -4.64290571,   78.7180176,   7.27272749
  37662,  -5.56097794,    78.554451,   7.27272749
  37663,  -6.47333527,   78.3615417,   7.27272749
  37664,   -7.3790431,   78.1394882,   7.27272749
  37665,  -8.27716732,   77.8885193,   7.27272749
  37666,  -9.16678429,   77.6088943,   7.27272749
  37667,  -10.0469837,   77.3009033,   7.27272749
  37668,  -10.9168587,   76.9648514,   7.27272749
  37669,  -11.7755146,   76.6010971,   7.27272749
  37670,  -12.6220713,   76.2100067,   7.27272749
  37671,  -13.4556599,   75.7919769,   7.27272749
  37672,  -14.2754183,   75.3474503,   7.27272749
  37673,   -15.080512,   74.8768768,   7.27272749
  37674,  -15.8701038,   74.3807449,   7.27272749
  37675,  -16.6433926,   73.8595581,   7.27272749
  37676,  -17.3995781,   73.3138504,   7.27272749
  37677,   -18.137888,   72.7441864,   7.27272749
  37678,  -18.8575554,   72.1511536,   7.27272749
  37679,  -19.5578423,   71.5353622,   7.27272749
  37680,  -20.2380352,    70.897438,   7.27272749
  37681,  -20.8974361,   70.2380371,   7.27272749
  37682,  -21.5353584,   69.5578461,   7.27272749
  37683,  -22.1511555,   68.8575516,   7.27272749
  37684,  -22.7441864,    68.137886,   7.27272749
  37685,  -23.3138523,   67.3995819,   7.27272749
  37686,  -23.8595581,   66.6433945,   7.27272749
  37687,   -24.380743,   65.8701096,   7.27272749
  37688,  -24.8768787,    65.080513,   7.27272749
  37689,  -25.3474541,   64.2754211,   7.27272749
  37690,  -25.7919807,    63.455658,   7.27272749
  37691,  -26.2100029,   62.6220741,   7.27272749
  37692,  -26.6010952,   61.7755165,   7.27272749
  37693,  -26.9648514,   60.9168587,   7.27272749
  37694,  -27.3008995,   60.0469818,   7.27272749
  37695,  -27.6088943,   59.1667862,   7.27272749
  37696,  -27.8885193,   58.2771645,   7.27272749
  37697,  -28.1394863,   57.3790436,   7.27272749
  37698,  -28.3615398,   56.4733353,   7.27272749
  37699,  -28.5544472,   55.5609779,   7.27272749
  37700,  -28.7180157,   54.6429062,   7.27272749
  37701,  -28.8520737,   53.7200623,   7.27272749
  37702,  -28.9564838,    52.793396,   7.27272749
  37703,  -29.0311394,   51.8638611,   7.27272749
  37704,  -29.0759621,   50.9324112,   7.27272749
  37705,   29.0759621,   50.9324112,   8.18181801
  37706,   29.0311394,   51.8638611,   8.18181801
  37707,   28.9564838,    52.793396,   8.18181801
  37708,   28.8520737,   53.7200623,   8.18181801
  37709,   28.7180157,   54.6429062,   8.18181801
  37710,   28.5544472,   55.5609779,   8.18181801
  37711,   28.3615398,   56.4733353,   8.18181801
  37712,   28.1394863,   57.3790436,   8.18181801
  37713,   27.8885193,   58.2771645,   8.18181801
  37714,   27.6088943,   59.1667862,   8.18181801
  37715,   27.3008995,   60.0469818,   8.18181801
  37716,   26.9648514,   60.9168587,   8.18181801
  37717,   26.6010952,   61.7755165,   8.18181801
  37718,   26.2100029,   62.6220741,   8.18181801
  37719,   25.7919807,    63.455658,   8.18181801
  37720,   25.3474541,   64.2754211,   8.18181801
  37721,   24.8768787,    65.080513,   8.18181801
  37722,    24.380743,   65.8701096,   8.18181801
  37723,   23.8595581,   66.6433945,   8.18181801
  37724,   23.3138523,   67.3995819,   8.18181801
  37725,   22.7441864,    68.137886,   8.18181801
  37726,   22.1511555,   68.8575516,   8.18181801
  37727,   21.5353584,   69.5578461,   8.18181801
  37728,   20.8974361,   70.2380371,   8.18181801
  37729,   20.2380352,    70.897438,   8.18181801
  37730,   19.5578423,   71.5353622,   8.18181801
  37731,   18.8575554,   72.1511536,   8.18181801
  37732,    18.137888,   72.7441864,   8.18181801
  37733,   17.3995781,   73.3138504,   8.18181801
  37734,   16.6433926,   73.8595581,   8.18181801
  37735,   15.8701038,   74.3807449,   8.18181801
  37736,    15.080512,   74.8768768,   8.18181801
  37737,   14.2754183,   75.3474503,   8.18181801
  37738,   13.4556599,   75.7919769,   8.18181801
  37739,   12.6220713,   76.2100067,   8.18181801
  37740,   11.7755146,   76.6010971,   8.18181801
  37741,   10.9168587,   76.9648514,   8.18181801
  37742,   10.0469837,   77.3009033,   8.18181801
  37743,   9.16678429,   77.6088943,   8.18181801
  37744,   8.27716732,   77.8885193,   8.18181801
  37745,    7.3790431,   78.1394882,   8.18181801
  37746,   6.47333527,   78.3615417,   8.18181801
  37747,   5.56097794,    78.554451,   8.18181801
  37748,   4.64290571,   78.7180176,   8.18181801
  37749,   3.72006297,   78.8520737,   8.18181801
  37750,   2.79339719,   78.9564819,   8.18181801
  37751,   1.86386096,   79.0311356,   8.18181801
  37752,  0.932409465,   79.0759659,   8.18181801
  37753,           0.,   79.0909119,   8.18181801
  37754, -0.932409465,   79.0759659,   8.18181801
  37755,  -1.86386096,   79.0311356,   8.18181801
  37756,  -2.79339719,   78.9564819,   8.18181801
  37757,  -3.72006297,   78.8520737,   8.18181801
  37758,  -4.64290571,   78.7180176,   8.18181801
  37759,  -5.56097794,    78.554451,   8.18181801
  37760,  -6.47333527,   78.3615417,   8.18181801
  37761,   -7.3790431,   78.1394882,   8.18181801
  37762,  -8.27716732,   77.8885193,   8.18181801
  37763,  -9.16678429,   77.6088943,   8.18181801
  37764,  -10.0469837,   77.3009033,   8.18181801
  37765,  -10.9168587,   76.9648514,   8.18181801
  37766,  -11.7755146,   76.6010971,   8.18181801
  37767,  -12.6220713,   76.2100067,   8.18181801
  37768,  -13.4556599,   75.7919769,   8.18181801
  37769,  -14.2754183,   75.3474503,   8.18181801
  37770,   -15.080512,   74.8768768,   8.18181801
  37771,  -15.8701038,   74.3807449,   8.18181801
  37772,  -16.6433926,   73.8595581,   8.18181801
  37773,  -17.3995781,   73.3138504,   8.18181801
  37774,   -18.137888,   72.7441864,   8.18181801
  37775,  -18.8575554,   72.1511536,   8.18181801
  37776,  -19.5578423,   71.5353622,   8.18181801
  37777,  -20.2380352,    70.897438,   8.18181801
  37778,  -20.8974361,   70.2380371,   8.18181801
  37779,  -21.5353584,   69.5578461,   8.18181801
  37780,  -22.1511555,   68.8575516,   8.18181801
  37781,  -22.7441864,    68.137886,   8.18181801
  37782,  -23.3138523,   67.3995819,   8.18181801
  37783,  -23.8595581,   66.6433945,   8.18181801
  37784,   -24.380743,   65.8701096,   8.18181801
  37785,  -24.8768787,    65.080513,   8.18181801
  37786,  -25.3474541,   64.2754211,   8.18181801
  37787,  -25.7919807,    63.455658,   8.18181801
  37788,  -26.2100029,   62.6220741,   8.18181801
  37789,  -26.6010952,   61.7755165,   8.18181801
  37790,  -26.9648514,   60.9168587,   8.18181801
  37791,  -27.3008995,   60.0469818,   8.18181801
  37792,  -27.6088943,   59.1667862,   8.18181801
  37793,  -27.8885193,   58.2771645,   8.18181801
  37794,  -28.1394863,   57.3790436,   8.18181801
  37795,  -28.3615398,   56.4733353,   8.18181801
  37796,  -28.5544472,   55.5609779,   8.18181801
  37797,  -28.7180157,   54.6429062,   8.18181801
  37798,  -28.8520737,   53.7200623,   8.18181801
  37799,  -28.9564838,    52.793396,   8.18181801
  37800,  -29.0311394,   51.8638611,   8.18181801
  37801,  -29.0759621,   50.9324112,   8.18181801
  37802,   29.0759621,   50.9324112,     9.090909
  37803,   29.0311394,   51.8638611,     9.090909
  37804,   28.9564838,    52.793396,     9.090909
  37805,   28.8520737,   53.7200623,     9.090909
  37806,   28.7180157,   54.6429062,     9.090909
  37807,   28.5544472,   55.5609779,     9.090909
  37808,   28.3615398,   56.4733353,     9.090909
  37809,   28.1394863,   57.3790436,     9.090909
  37810,   27.8885193,   58.2771645,     9.090909
  37811,   27.6088943,   59.1667862,     9.090909
  37812,   27.3008995,   60.0469818,     9.090909
  37813,   26.9648514,   60.9168587,     9.090909
  37814,   26.6010952,   61.7755165,     9.090909
  37815,   26.2100029,   62.6220741,     9.090909
  37816,   25.7919807,    63.455658,     9.090909
  37817,   25.3474541,   64.2754211,     9.090909
  37818,   24.8768787,    65.080513,     9.090909
  37819,    24.380743,   65.8701096,     9.090909
  37820,   23.8595581,   66.6433945,     9.090909
  37821,   23.3138523,   67.3995819,     9.090909
  37822,   22.7441864,    68.137886,     9.090909
  37823,   22.1511555,   68.8575516,     9.090909
  37824,   21.5353584,   69.5578461,     9.090909
  37825,   20.8974361,   70.2380371,     9.090909
  37826,   20.2380352,    70.897438,     9.090909
  37827,   19.5578423,   71.5353622,     9.090909
  37828,   18.8575554,   72.1511536,     9.090909
  37829,    18.137888,   72.7441864,     9.090909
  37830,   17.3995781,   73.3138504,     9.090909
  37831,   16.6433926,   73.8595581,     9.090909
  37832,   15.8701038,   74.3807449,     9.090909
  37833,    15.080512,   74.8768768,     9.090909
  37834,   14.2754183,   75.3474503,     9.090909
  37835,   13.4556599,   75.7919769,     9.090909
  37836,   12.6220713,   76.2100067,     9.090909
  37837,   11.7755146,   76.6010971,     9.090909
  37838,   10.9168587,   76.9648514,     9.090909
  37839,   10.0469837,   77.3009033,     9.090909
  37840,   9.16678429,   77.6088943,     9.090909
  37841,   8.27716732,   77.8885193,     9.090909
  37842,    7.3790431,   78.1394882,     9.090909
  37843,   6.47333527,   78.3615417,     9.090909
  37844,   5.56097794,    78.554451,     9.090909
  37845,   4.64290571,   78.7180176,     9.090909
  37846,   3.72006297,   78.8520737,     9.090909
  37847,   2.79339719,   78.9564819,     9.090909
  37848,   1.86386096,   79.0311356,     9.090909
  37849,  0.932409465,   79.0759659,     9.090909
  37850,           0.,   79.0909119,     9.090909
  37851, -0.932409465,   79.0759659,     9.090909
  37852,  -1.86386096,   79.0311356,     9.090909
  37853,  -2.79339719,   78.9564819,     9.090909
  37854,  -3.72006297,   78.8520737,     9.090909
  37855,  -4.64290571,   78.7180176,     9.090909
  37856,  -5.56097794,    78.554451,     9.090909
  37857,  -6.47333527,   78.3615417,     9.090909
  37858,   -7.3790431,   78.1394882,     9.090909
  37859,  -8.27716732,   77.8885193,     9.090909
  37860,  -9.16678429,   77.6088943,     9.090909
  37861,  -10.0469837,   77.3009033,     9.090909
  37862,  -10.9168587,   76.9648514,     9.090909
  37863,  -11.7755146,   76.6010971,     9.090909
  37864,  -12.6220713,   76.2100067,     9.090909
  37865,  -13.4556599,   75.7919769,     9.090909
  37866,  -14.2754183,   75.3474503,     9.090909
  37867,   -15.080512,   74.8768768,     9.090909
  37868,  -15.8701038,   74.3807449,     9.090909
  37869,  -16.6433926,   73.8595581,     9.090909
  37870,  -17.3995781,   73.3138504,     9.090909
  37871,   -18.137888,   72.7441864,     9.090909
  37872,  -18.8575554,   72.1511536,     9.090909
  37873,  -19.5578423,   71.5353622,     9.090909
  37874,  -20.2380352,    70.897438,     9.090909
  37875,  -20.8974361,   70.2380371,     9.090909
  37876,  -21.5353584,   69.5578461,     9.090909
  37877,  -22.1511555,   68.8575516,     9.090909
  37878,  -22.7441864,    68.137886,     9.090909
  37879,  -23.3138523,   67.3995819,     9.090909
  37880,  -23.8595581,   66.6433945,     9.090909
  37881,   -24.380743,   65.8701096,     9.090909
  37882,  -24.8768787,    65.080513,     9.090909
  37883,  -25.3474541,   64.2754211,     9.090909
  37884,  -25.7919807,    63.455658,     9.090909
  37885,  -26.2100029,   62.6220741,     9.090909
  37886,  -26.6010952,   61.7755165,     9.090909
  37887,  -26.9648514,   60.9168587,     9.090909
  37888,  -27.3008995,   60.0469818,     9.090909
  37889,  -27.6088943,   59.1667862,     9.090909
  37890,  -27.8885193,   58.2771645,     9.090909
  37891,  -28.1394863,   57.3790436,     9.090909
  37892,  -28.3615398,   56.4733353,     9.090909
  37893,  -28.5544472,   55.5609779,     9.090909
  37894,  -28.7180157,   54.6429062,     9.090909
  37895,  -28.8520737,   53.7200623,     9.090909
  37896,  -28.9564838,    52.793396,     9.090909
  37897,  -29.0311394,   51.8638611,     9.090909
  37898,  -29.0759621,   50.9324112,     9.090909
  37899,   28.1673393,   50.9032707,  0.909090936
  37900,   28.1239147,   51.8056145,  0.909090936
  37901,   28.0515938,   52.7061043,  0.909090936
  37902,   27.9504452,   53.6038094,  0.909090936
  37903,   27.8205776,   54.4978142,  0.909090936
  37904,   27.6621189,   55.3871994,  0.909090936
  37905,   27.4752407,   56.2710457,  0.909090936
  37906,    27.260128,   57.1484489,  0.909090936
  37907,    27.017004,   58.0185051,  0.909090936
  37908,   26.7461166,   58.8803215,  0.909090936
  37909,   26.4477463,    59.733017,  0.909090936
  37910,      26.1222,   60.5757065,  0.909090936
  37911,   25.7698097,   61.4075317,  0.909090936
  37912,   25.3909416,   62.2276344,  0.909090936
  37913,    24.985981,   63.0351715,  0.909090936
  37914,   24.5553455,   63.8293114,  0.909090936
  37915,   24.0994759,   64.6092453,  0.909090936
  37916,    23.618845,   65.3741684,  0.909090936
  37917,   23.1139469,    66.123291,  0.909090936
  37918,   22.5852947,   66.8558426,  0.909090936
  37919,   22.0334301,   67.5710754,  0.909090936
  37920,    21.458931,   68.2682571,  0.909090936
  37921,   20.8623772,   68.9466629,  0.909090936
  37922,   20.2443905,   69.6055984,  0.909090936
  37923,   19.6055965,   70.2443924,  0.909090936
  37924,   18.9466591,    70.862381,  0.909090936
  37925,   18.2682571,    71.458931,  0.909090936
  37926,   17.5710773,    72.033432,  0.909090936
  37927,   16.8558407,   72.5852966,  0.909090936
  37928,   16.1232853,    73.113945,  0.909090936
  37929,   15.3741636,   73.6188431,  0.909090936
  37930,   14.6092463,   74.0994797,  0.909090936
  37931,   13.8293123,   74.5553436,  0.909090936
  37932,   13.0351706,   74.9859772,  0.909090936
  37933,   12.2276316,   75.3909378,  0.909090936
  37934,   11.4075298,   75.7698135,  0.909090936
  37935,   10.5757065,      76.1222,  0.909090936
  37936,   9.73301506,   76.4477463,  0.909090936
  37937,   8.88032246,   76.7461166,  0.909090936
  37938,   8.01850605,   77.0170059,  0.909090936
  37939,   7.14844799,   77.2601242,  0.909090936
  37940,   6.27104378,   77.4752426,  0.909090936
  37941,   5.38719702,   77.6621246,  0.909090936
  37942,   4.49781466,   77.8205795,  0.909090936
  37943,   3.60381103,   77.9504471,  0.909090936
  37944,   2.70610356,     78.05159,  0.909090936
  37945,   1.80561531,   78.1239166,  0.909090936
  37946,  0.903271675,   78.1673355,  0.909090936
  37947,           0.,   78.1818161,  0.909090936
  37948, -0.903271675,   78.1673355,  0.909090936
  37949,  -1.80561531,   78.1239166,  0.909090936
  37950,  -2.70610356,     78.05159,  0.909090936
  37951,  -3.60381103,   77.9504471,  0.909090936
  37952,  -4.49781466,   77.8205795,  0.909090936
  37953,  -5.38719702,   77.6621246,  0.909090936
  37954,  -6.27104378,   77.4752426,  0.909090936
  37955,  -7.14844799,   77.2601242,  0.909090936
  37956,  -8.01850605,   77.0170059,  0.909090936
  37957,  -8.88032246,   76.7461166,  0.909090936
  37958,  -9.73301506,   76.4477463,  0.909090936
  37959,  -10.5757065,      76.1222,  0.909090936
  37960,  -11.4075298,   75.7698135,  0.909090936
  37961,  -12.2276316,   75.3909378,  0.909090936
  37962,  -13.0351706,   74.9859772,  0.909090936
  37963,  -13.8293123,   74.5553436,  0.909090936
  37964,  -14.6092463,   74.0994797,  0.909090936
  37965,  -15.3741636,   73.6188431,  0.909090936
  37966,  -16.1232853,    73.113945,  0.909090936
  37967,  -16.8558407,   72.5852966,  0.909090936
  37968,  -17.5710773,    72.033432,  0.909090936
  37969,  -18.2682571,    71.458931,  0.909090936
  37970,  -18.9466591,    70.862381,  0.909090936
  37971,  -19.6055965,   70.2443924,  0.909090936
  37972,  -20.2443905,   69.6055984,  0.909090936
  37973,  -20.8623772,   68.9466629,  0.909090936
  37974,   -21.458931,   68.2682571,  0.909090936
  37975,  -22.0334301,   67.5710754,  0.909090936
  37976,  -22.5852947,   66.8558426,  0.909090936
  37977,  -23.1139469,    66.123291,  0.909090936
  37978,   -23.618845,   65.3741684,  0.909090936
  37979,  -24.0994759,   64.6092453,  0.909090936
  37980,  -24.5553455,   63.8293114,  0.909090936
  37981,   -24.985981,   63.0351715,  0.909090936
  37982,  -25.3909416,   62.2276344,  0.909090936
  37983,  -25.7698097,   61.4075317,  0.909090936
  37984,     -26.1222,   60.5757065,  0.909090936
  37985,  -26.4477463,    59.733017,  0.909090936
  37986,  -26.7461166,   58.8803215,  0.909090936
  37987,   -27.017004,   58.0185051,  0.909090936
  37988,   -27.260128,   57.1484489,  0.909090936
  37989,  -27.4752407,   56.2710457,  0.909090936
  37990,  -27.6621189,   55.3871994,  0.909090936
  37991,  -27.8205776,   54.4978142,  0.909090936
  37992,  -27.9504452,   53.6038094,  0.909090936
  37993,  -28.0515938,   52.7061043,  0.909090936
  37994,  -28.1239147,   51.8056145,  0.909090936
